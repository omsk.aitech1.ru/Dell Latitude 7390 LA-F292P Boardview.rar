# Allegro board LAF292PR10-1114.brd (continued)
## Nets (continued)
PCH_SPI_D3_1_R: RC407.2 UC6.7
PCH_SPI_D3_R1: JSPI1.8 RC31.1 RC40.1 RC316.1 RC407.1 RPC1.4
PCH_SPI_DO2_XDP: JXDP1.60 RC11.1
PCH_SPI_DO_XDP: RC10.1 RC128.1 RC133.1
PCH_TBT_PERST#: RC557.1 RC558.1 RT420.2 RT444.1 UC1.AB1
PCI_CLK_LPC1: RC22.1 UC1.AY9
PCIE_PRX_C_DTX_N1: CT7.1 UT1.V22
PCIE_PRX_C_DTX_N2: CT9.1 UT1.P22
PCIE_PRX_C_DTX_N3: CT128.1 UT1.K22
PCIE_PRX_C_DTX_N4: CT130.1 UT1.F22
PCIE_PRX_C_DTX_P1: CT6.1 UT1.V23
PCIE_PRX_C_DTX_P2: CT8.1 UT1.P23
PCIE_PRX_C_DTX_P3: CT127.1 UT1.K23
PCIE_PRX_C_DTX_P4: CT129.1 UT1.F23
PCIE_PRX_DTX_N1: CT7.2 UC1.H13
PCIE_PRX_DTX_N2: CT9.2 UC1.G11
PCIE_PRX_DTX_N3: CT128.2 UC1.H16
PCIE_PRX_DTX_N4: CT130.2 UC1.G15
PCIE_PRX_DTX_N5: JNGFF1.43 UC1.F16
PCIE_PRX_DTX_N7: UC1.F20 UZ29.14
PCIE_PRX_DTX_N8: JNGFF2.43 UC1.G21
PCIE_PRX_DTX_N9: JNGFF3.5 UC1.E22
PCIE_PRX_DTX_N10: JNGFF3.17 UC1.F25
PCIE_PRX_DTX_N11: JNGFF3.29 UC1.E28
PCIE_PRX_DTX_N12: JNGFF3.43 UC1.E30
PCIE_PRX_DTX_P1: CT6.2 UC1.G13
PCIE_PRX_DTX_P2: CT8.2 UC1.F11
PCIE_PRX_DTX_P3: CT127.2 UC1.G16
PCIE_PRX_DTX_P4: CT129.2 UC1.F15
PCIE_PRX_DTX_P5: JNGFF1.41 UC1.E16
PCIE_PRX_DTX_P7: UC1.E20 UZ29.15
PCIE_PRX_DTX_P8: JNGFF2.41 UC1.F21
PCIE_PRX_DTX_P9: JNGFF3.7 UC1.E23
PCIE_PRX_DTX_P10: JNGFF3.19 UC1.E25
PCIE_PRX_DTX_P11: JNGFF3.31 UC1.E27
PCIE_PRX_DTX_P12: JNGFF3.41 UC1.F30
PCIE_PRX_L_DTX_N7: JNGFF2.29 LI16.2 RI27.2
PCIE_PRX_L_DTX_P7: JNGFF2.31 LI16.3 RI28.2
PCIE_PRX_SW_DTX_N7: LI16.1 RI27.1 UZ29.4
PCIE_PRX_SW_DTX_P7: LI16.4 RI28.1 UZ29.3
PCIE_PTX_C_DRX_N1: CT3.2 UT1.Y22
PCIE_PTX_C_DRX_N2: CT5.2 UT1.T22
PCIE_PTX_C_DRX_N3: CT124.2 UT1.M22
PCIE_PTX_C_DRX_N4: CT126.2 UT1.H22
PCIE_PTX_C_DRX_N5: CZ13.2 JNGFF1.37
PCIE_PTX_C_DRX_N8: CZ10.2 JNGFF2.47
PCIE_PTX_C_DRX_N9: CN65.1 JNGFF3.11
PCIE_PTX_C_DRX_N10: CN67.1 JNGFF3.23
PCIE_PTX_C_DRX_N11: CN69.1 JNGFF3.35
PCIE_PTX_C_DRX_N12: CN71.1 JNGFF3.47
PCIE_PTX_C_DRX_P1: CT2.2 UT1.Y23
PCIE_PTX_C_DRX_P2: CT4.2 UT1.T23
PCIE_PTX_C_DRX_P3: CT123.2 UT1.M23
PCIE_PTX_C_DRX_P4: CT125.2 UT1.H23
PCIE_PTX_C_DRX_P5: CZ12.2 JNGFF1.35
PCIE_PTX_C_DRX_P8: CZ11.2 JNGFF2.49
PCIE_PTX_C_DRX_P9: CN66.1 JNGFF3.13
PCIE_PTX_C_DRX_P10: CN68.1 JNGFF3.25
PCIE_PTX_C_DRX_P11: CN70.1 JNGFF3.37
PCIE_PTX_C_DRX_P12: CN72.1 JNGFF3.49
PCIE_PTX_C_SW_DRX_N7: CZ153.2 UZ29.12
PCIE_PTX_C_SW_DRX_P7: CZ152.2 UZ29.13
PCIE_PTX_DRX_N1: CT3.1 UC1.B17
PCIE_PTX_DRX_N2: CT5.1 UC1.D16
PCIE_PTX_DRX_N3: CT124.1 UC1.D17
PCIE_PTX_DRX_N4: CT126.1 UC1.B19
PCIE_PTX_DRX_N5: CZ13.1 UC1.C19
PCIE_PTX_DRX_N7: CZ153.1 UC1.B21
PCIE_PTX_DRX_N8: CZ10.1 UC1.D21
PCIE_PTX_DRX_N9: CN65.2 UC1.B23
PCIE_PTX_DRX_N10: CN67.2 UC1.D23
PCIE_PTX_DRX_N11: CN69.2 UC1.D24
PCIE_PTX_DRX_N12: CN71.2 UC1.A25
PCIE_PTX_DRX_P1: CT2.1 UC1.A17
PCIE_PTX_DRX_P2: CT4.1 UC1.C16
PCIE_PTX_DRX_P3: CT123.1 UC1.C17
PCIE_PTX_DRX_P4: CT125.1 UC1.A19
PCIE_PTX_DRX_P5: CZ12.1 UC1.D19
PCIE_PTX_DRX_P7: CZ152.1 UC1.A21
PCIE_PTX_DRX_P8: CZ11.1 UC1.C21
PCIE_PTX_DRX_P9: CN66.2 UC1.A23
PCIE_PTX_DRX_P10: CN68.2 UC1.C23
PCIE_PTX_DRX_P11: CN70.2 UC1.C24
PCIE_PTX_DRX_P12: CN72.2 UC1.B25
PCIE_PTX_L_DRX_N7: JNGFF2.35 LI17.2 RI29.2
PCIE_PTX_L_DRX_P7: JNGFF2.37 LI17.3 RI30.2
PCIE_PTX_SW_DRX_N7: LI17.1 RI29.1 UZ29.8
PCIE_PTX_SW_DRX_P7: LI17.4 RI30.1 UZ29.7
PCIE_RCOMPN: RC45.1 UC1.F5
PCIE_RCOMPP: RC45.2 UC1.E5
PCIE_WAKE#: JNGFF1.55 JNGFF1.70 JNGFF2.54 JNGFF3.54 RE274.1 RE275.1 RT421.2 RT448.1
PCIE_WAKE#_AR: RT421.1 RT422.1 RT441.2 RT454.1 RT455.1 UT1.W1
PCIE_WAKE#_AR_R: RT440.2 RT441.1 UT32.4
PCIE_WAKE#_R: RE35.1 RE275.2 UE1.N13
PD1_GPIO2: RT71.1 UT5.D10
PD1_GPIO6: RT75.1 UT5.G10
PD1_GPIO7: RT339.1 UT5.D7
PD1_GPIO8: RT76.1 RT377.1 UT5.H6
PD1_USB20_N: RT402.1 RT404.1 UT5.K5
PD1_USB20_P: RT401.1 RT403.1 UT5.L5
PD2_GPIO2: RT167.1 UT11.D10
PD2_GPIO6: RT171.1 UT11.G10
PD2_GPIO7: RT340.1 UT11.D7
PD2_GPIO8: RT172.1 RT378.1 UT11.H6
PD2_USB20_N: RT406.1 RT408.1 UT11.K5
PD2_USB20_P: RT405.1 RT407.1 UT11.L5
PD#: CA31.1 DA8.2 RA18.1 RA48.2 RA50.2 UA1.3
PECI_EC: RE60.2 UC1.A54
PECI_EC_R: RE60.1 UE1.K13
PGOOD_3V: PR107.2 PR119.1 PU100.9
PGOOD_5V: PR113.2 PR120.1 PU102.9
PLTRST_TPM#: RC60.2 RC325.2 UZ12.17
PME#: T115.1(TP-1) UC1.AU11
POA_WAKE#: RE324.1 RZ364.1 UE1.E4
POA_WAKE#_R: JUSH1.4 RZ364.2
POWER_SW#_MB: CE10.1 JAPS1.11 JPWR1.2 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE1.D5
PROCHOT#: CC310.1 PC605.2 PR678.1 PR926.1 RC83.1 RC84.1 RE288.2
PROCHOT#_ISL9538: PQ1228.1 PR926.2 PU901.23
PROCHOT#_R: RC84.2 UC1.C65
PROCHOT#_R1: RE288.1 UE1.H13
PWM1_IA: PR687.1 PU602.12
PWM2_IA: PR692.1 PU602.13
PWM_FAN1: JFAN1.2 RE48.2 UE1.L10
PWM_GT: PR664.1 PU602.22
PWM_SA: PR606.2 PU614.3
PWM_VSA: PR606.1 PU602.30
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE1.A8
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE1.A7
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE1.A10
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE1.A9
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE1.A11
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE1.B10
RESET_IN#: RE362.1 UE1.C1
RESET_OUT: RE548.2 UE1.G4
RESET_OUT#_R: CC33.1 JXDP1.47 RC128.2 RC129.2
RING2: LA10.1 RA5.1 UA1.29
RING2_R: CA4.1 CA13.2 DA3.3 JHP1.4 LA10.2
RTCRST_ON: QE12.2 RE93.1 RE565.2 UE1.F11
RTCRST_ON_R: CE65.1 DE2.2 QE17.2 RE543.1
RTD3 SELECT: RE509.1 RT447.1 RT449.1 UT32.6 UT33.6
RTD3_CIO_PWR_EN: RC559.1 RT392.2 UC1.AC2
RTD3_CIO_PWR_EN_R: RT25.1 RT372.1 RT392.1 UT1.F1
RTD3_USB_PWR_EN: RT26.1 UT1.D4
RUN_ON: PR402.1 QE2.2 RE280.2 RE292.1 RZ320.1 RZ345.1 UE5.4 UZ3.5 UZ4.3 UZ35.2
RUN_ON#: QE2.5 QE2.6 QZ4.2 RE68.1
RUN_ON_1.8V: CZ197.1 RZ345.2 UZ8.3
RUN_ON_EC: RE292.2 RPE10.4 UE1.E8 UE5.2
RUNPWROK: QE2.3 RE67.1 UC8.1 UC8.4 UC8.10 UC8.13 UE1.G3
S1_OVP: PQ1224.6 PR1279.2 PR1296.2
S3_OVP: PQ1226.6 PR1282.2 PR1295.2
S5_1.2V: PC221.1 PR208.2 PR209.1 PU200.1
SA_LGATE: PQ614.8 PU614.5
SA_SNUB: PC622.1 PR627.2
SA_SW: PL614.4 PQ614.9 PR619.2 PR627.1 PU614.8
SA_UGATE: PQ614.1 PU614.1
SAR_DPR#: Q1.1 UE1.M4
SAR_I2C0_SCL: CZ166.1 JSAR1.3 QZ10.3 QZ13.4 RZ351.1
SAR_I2C0_SDA: CZ165.1 JSAR1.2 QZ10.6 QZ13.1 RZ350.1
SATAGP0: RPC4.3 UC1.H2
SATALED#: QZ2.4 RN100.2 RN101.2 RPC4.4 UC1.H1
SBIOS_TX: RE306.1 UC1.AB2
SD/MMCCD#: JSD1.9 UR1.31
SD/MMCCLK: RR5.1 UR1.17
SD/MMCCLK_R: CR21.1 JSD1.5 RR5.2
SD/MMCCMD: RR6.1 UR1.18
SD/MMCCMD_R: JSD1.3 RR6.2
SD/MMCDAT0/RCLK+: RR10.1 UR1.16
SD/MMCDAT0/RCLK+_R: JSD1.7 RR10.2
SD/MMCDAT1/RCLK-: RR9.1 UR1.15
SD/MMCDAT1/RCLK-_R: JSD1.8 RR9.2
SD/MMCDAT2: RR8.1 UR1.20
SD/MMCDAT2_R: JSD1.1 RR8.2
SD/MMCDAT3: RR7.1 UR1.19
SD/MMCDAT3_R: JSD1.2 RR7.2
SD_GPIO0: RR3.2 UR1.32
SD_GPIO1: RR22.2 UR1.1
SD_RCOMP: RC96.1 UC1.AB7
SD_UHS2_D0N: JSD1.19 UR1.25
SD_UHS2_D0P: JSD1.18 UR1.26
SD_UHS2_D1N: JSD1.21 UR1.23
SD_UHS2_D1P: JSD1.22 UR1.22
SDWP: QR1.1 UR1.30
SIM_DET: JNGFF2.66 JSIM1.10
SIO_EXT_SCI#: RC237.1 RC561.2 UC1.AN7
SIO_EXT_SMI#: RC346.1 UC1.A6
SIO_EXT_WAKE#: RC283.1 UC1.AC1 UE1.M12
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.1 UC1.BA15 UE1.K11
SIO_SLP_A#: JAPS1.6 UC1.AN16 UE1.M11
SIO_SLP_LAN#: RC68.1 RC344.1 UC1.AW15 UE1.H9
SIO_SLP_S0#: JAPS1.15 PR425.1 PR426.1 RZ112.1 RZ362.2 RZ363.1 UC1.AT11 UZ35.1
SIO_SLP_S3#: JAPS1.2 QE11.2 RE280.1 UC1.AP15 UE1.K9 UE3.2 UE5.1 UT1.D2
SIO_SLP_S4#: JAPS1.5 PR208.1 PR513.1 UC1.BA16 UE1.N12 UZ21.4 UZ34.2
SIO_SLP_S5#: JAPS1.4 UC1.AY16 UE1.N8
SIO_SLP_SUS#: RC441.1 RE349.1 UC1.AN15
SIO_SLP_SUS#_R: RE349.2 RE561.1 UE1.N4
SIO_SLP_WLAN#: QZ15.1 UC1.BB17 UE1.D9
SLEEVE: LA11.1 RA6.1 UA1.30
SLEEVE_R: CA1.2 CA12.1 DA3.2 JHP1.3 LA11.2
SLOT2_SATA_LED#: JNGFF2.10 RN101.1
SLP_WLAN#_GATE: QZ15.2 RE552.1 RZ518.2
SLP_WLAN#_M: DZ9.3 QZ15.3 RZ71.1
SM_RCOMP0: RC5.1 UC1.AR18
SM_RCOMP1: RC6.1 UC1.AT18
SM_RCOMP2: RC7.1 UC1.AU18
SML0_SMBCLK: CC318.1 RC347.1 UC1.R9
SML0_SMBDATA: RC348.1 UC1.W2
SML1_SMBCLK: CC319.1 RC15.1 UC1.W3 UE1.D8
SML1_SMBDATA: RC17.1 UC1.V3 UE1.E11
SNB_+1VALWP: PC302.1 PR303.2
SNK0_CONFIG1: RT129.1 RT337.1 UT1.N4
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_1V_PRIM: PC419.1 PR409.2
SNUB_1VS_VCCIO: PC401.1 PR405.2
SNUB_CHG1: PC940.1 PR923.2
SNUB_CHG2: PC941.1 PR924.2
SPK_DET#: JSPK1.5 RA58.2 UC1.W7
SPKR: RA12.2 RC183.1 UC1.AW5
SPKR_R: CA27.1 CA72.1 RA12.1 RA51.1
SRTCRST#: CC24.1 RC56.1 UC1.AN18
SS_1V_PRIM: PC420.1 PR428.1 PU402.7
SS_1VS_VCCIO: PC410.1 PR427.1 PU401.7
SUSACK#: RC443.1 UE1.K12
SUSACK#_R: RC443.2 RC550.2 UC1.AP11
SUSCLK: RC48.1 RN99.2 RZ56.1 UC1.BA17
SUSCLK_R: JNGFF3.68 RN99.1
SW_+1VALWP: PC304.2 PL301.1 PR303.1 PU301.6 PU301.19 PU301.20
SW_USB20_N9: LI7.1 UI3.11
SW_USB20_P9: LI7.4 UI3.10
SYS_PWROK: RC129.1 RE56.1 RE548.1 UC1.B6
SYS_RESET#: CC302.1 JAPS1.13 RC224.2 RC291.1 UC1.B5
SYS_RESET#_R: RC224.1 RC290.2 UC12.4
SYSTEM_ID: CE47.1 RE300.2 UE1.J10
TACH_FAN1: JFAN1.3 RE51.2 UE1.E3
TBT_CIO_PLUG_EVENT#: RT371.1 RT391.1 UC1.AB12 UT1.W2
TBT_DP_RBIAS: RT35.1 UT1.N6
TBT_FORCE_PWR: RT27.1 UC1.B7 UT1.H4
TBT_I2C_SCL: RT19.1 UT1.U2 UT5.D2 UT11.D2
TBT_I2C_SDA: RT18.1 UT1.U1 UT5.D1 UT11.D1
TBT_JTAG_TCK: RT6.1 UT1.T4
TBT_JTAG_TDI: RT8.1 UT1.Y4
TBT_JTAG_TDO: RT5.1 UT1.W4
TBT_JTAG_TMS: RT7.1 UT1.V4
TBT_PCIE_RBIAS: RT34.1 UT1.N16
TBT_PERST#: RT419.1 RT420.1 RT443.2 UT1.L4
TBT_PERST#_R: RT442.2 RT443.1 UT33.4
TBT_RBIAS: RT39.2 UT1.H6
TBT_RESET_N_EC: CT205.1 RE506.1 RT11.1 RT110.2 RT203.2 UT1.F4
TBT_RESET_N_EC_R: RE95.1 RE506.2 UE1.L8
TBT_ROM_CLK: UT1.AB4 UT2.6
TBT_ROM_CS#: RT2.1 UT1.AC3 UT2.1
TBT_ROM_DI: UT1.AB3 UT2.5
TBT_ROM_DO: RT3.1 UT1.AC4 UT2.2
TBT_ROM_HOLD#: RT1.1 UT2.7
TBT_ROM_WP#: RT4.1 UT1.V1 UT2.3
TBT_RSENSE: RT39.1 UT1.J6
TBT_SRC_CFG1: RT30.1 RT338.1 UT1.AA1
TBT_TMU_CLK_OUT: RT28.1 UT1.V2
TBTA_AUXN: CT81.1 UT1.W16
TBTA_AUXN_C: CT81.2 RT95.1 UT5.J2
TBTA_AUXP: CT80.1 UT1.Y16
TBTA_AUXP_C: CT80.2 RT96.1 UT5.J1
TBTA_BOT_N: RT122.2 UT5.L7
TBTA_BOT_N_R: DT42.2 DT42.8 JUSBC1.B7 RT122.1
TBTA_BOT_P: RT123.2 UT5.K7
TBTA_BOT_P_R: DT42.4 DT42.7 JUSBC1.B6 RT123.1
TBTA_CC1: DT41.5 DT41.6 JUSBC1.A5 RT104.2
TBTA_CC2: DT42.5 DT42.6 JUSBC1.B5 RT105.2
TBTA_DBG_CTL1: RT106.1 UT5.E4
TBTA_DBG_CTL2: RT107.1 UT5.D5
TBTA_DC_SS: PD903.2 PD1202.2 PQ1202.5 PQ1203.5
TBTA_DEBUG1: RT92.2 UT5.L2
TBTA_DEBUG2: RT93.2 UT5.K2
TBTA_DEBUG3: RT89.2 UT5.L3
TBTA_DEBUG4: RT90.2 UT5.K3
TBTA_HPD: DZ107.1 RT23.1 RT73.2 UT1.G2
TBTA_HPD_R: RT73.1 UT5.C10
TBTA_I2C_INT: RT16.1 RT410.2 UT5.C1
TBTA_I2C_INT_R: RT410.1 UT1.E2
TBTA_LSRX: RT21.1 RT88.1 RT90.1 UT1.B5
TBTA_LSRX_R: RT88.2 UT5.K4
TBTA_LSTX: RT22.1 RT87.1 RT89.1 UT1.B4
TBTA_LSTX_R: RT87.2 UT5.L4
TBTA_MRESET: RT86.1 UT5.E11
TBTA_RESET_N_EC_R: RT110.1 UT5.F11
TBTA_ROM_CLK_PD: RT218.1 UT5.A3
TBTA_ROM_CS#_PD: RT221.1 UT5.B3
TBTA_ROM_DI_PD: RT219.1 UT5.B4
TBTA_ROM_DO_PD: RT220.1 UT5.A4
TBTA_ROSC: RT100.1 UT5.G2
TBTA_RX1N: DT14.1 JUSBC1.B10 UT1.B13
TBTA_RX1P: DT13.1 JUSBC1.B11 UT1.A13
TBTA_RX2N: DT9.1 JUSBC1.A10 UT1.A7
TBTA_RX2P: DT10.1 JUSBC1.A11 UT1.B7
TBTA_SBU1: DT41.1 DT41.9 JUSBC1.A8 RT108.2
TBTA_SBU1_R: RT108.1 UT5.K8
TBTA_SBU2: DT42.1 DT42.9 JUSBC1.B8 RT109.2
TBTA_SBU2_R: RT109.1 UT5.L8
TBTA_TOP_N: RT121.1 UT5.L6
TBTA_TOP_N_R: DT41.2 DT41.8 JUSBC1.A7 RT121.2
TBTA_TOP_P: RT120.1 UT5.K6
TBTA_TOP_P_R: DT41.4 DT41.7 JUSBC1.A6 RT120.2
TBTA_TX1N: CT96.1 UT1.B11
TBTA_TX1N_C: CT96.2 DT6.1 JUSBC1.A3
TBTA_TX1P: CT95.1 UT1.A11
TBTA_TX1P_C: CT95.2 DT5.1 JUSBC1.A2
TBTA_TX2N: CT98.1 UT1.B9
TBTA_TX2N_C: CT98.2 DT18.1 JUSBC1.B3
TBTA_TX2P: CT97.1 UT1.A9
TBTA_TX2P_C: CT97.2 DT17.1 JUSBC1.B2
TBTA_USB2_RBIAS: RT42.1 UT1.F19
TBTA_USB20_N: RT404.2 UT1.D19
TBTA_USB20_P: RT403.2 UT1.E19
TBTB_AUXN: CT157.1 UT1.W15
TBTB_AUXN_C: CT157.2 RT204.1 UT11.J2
TBTB_AUXP: CT156.1 UT1.Y15
TBTB_AUXP_C: CT156.2 RT205.1 UT11.J1
TBTB_BOT_N: RT216.2 UT11.L7
TBTB_BOT_N_R: DT44.2 DT44.8 JUSBC2.B7 RT216.1
TBTB_BOT_P: RT217.2 UT11.K7
TBTB_BOT_P_R: DT44.4 DT44.7 JUSBC2.B6 RT217.1
TBTB_CC1: CT155.1 DT43.5 DT43.6 JUSBC2.A5 RT197.2 UT11.L9
TBTB_CC2: CT154.1 DT44.5 DT44.6 JUSBC2.B5 RT198.2 UT11.L10
TBTB_DBG_CTL1: RT199.1 UT11.E4
TBTB_DBG_CTL2: RT200.1 UT11.D5
TBTB_DC_SS: PD904.2 PD1205.2 PQ1211.5 PQ1212.5
TBTB_DEBUG1: RT188.2 UT11.L2
TBTB_DEBUG2: RT189.2 UT11.K2
TBTB_DEBUG3: RT185.2 UT11.L3
TBTB_DEBUG4: RT186.2 UT11.K3
TBTB_HPD: DZ106.1 RT33.1 RT169.2 UT1.M4
TBTB_HPD_R: RT169.1 UT11.C10
TBTB_I2C_INT: RT17.1 RT409.2 UT11.C1
TBTB_I2C_INT_R: RT409.1 UT1.J4
TBTB_LSRX: RT32.1 RT184.1 RT186.1 UT1.A4
TBTB_LSRX_R: RT184.2 UT11.K4
TBTB_LSTX: RT31.1 RT183.1 RT185.1 UT1.A5
TBTB_LSTX_R: RT183.2 UT11.L4
TBTB_MRESET: RT182.1 UT11.E11
TBTB_RESET_N_EC_R: RT203.1 UT11.F11
TBTB_ROM_CLK_PD: RT54.1 UT11.A3
TBTB_ROM_CLK_PD_R: RT54.2 UT6.6
TBTB_ROM_CS#_PD: RT57.1 UT11.B3
TBTB_ROM_CS#_PD_R: RT51.1 RT57.2 UT6.1
TBTB_ROM_DI_PD: RT55.1 UT11.B4
TBTB_ROM_DI_PD_R: RT55.2 UT6.5
TBTB_ROM_DO_PD: RT56.1 UT11.A4
TBTB_ROM_DO_PD_R: RT52.1 RT56.2 UT6.2
TBTB_ROM_HOLD#_PD: RT50.1 UT6.7
TBTB_ROM_WP#_PD: RT53.1 UT6.3
TBTB_ROSC: RT194.1 UT11.G2
TBTB_RX1N: DT31.1 JUSBC2.B10 UT1.A21
TBTB_RX1P: DT30.1 JUSBC2.B11 UT1.B21
TBTB_RX2N: DT26.1 JUSBC2.A10 UT1.B15
TBTB_RX2P: DT27.1 JUSBC2.A11 UT1.A15
TBTB_SBU1: DT43.1 DT43.9 JUSBC2.A8 RT201.2
TBTB_SBU1_R: RT201.1 UT11.K8
TBTB_SBU2: DT44.1 DT44.9 JUSBC2.B8 RT202.2
TBTB_SBU2_R: RT202.1 UT11.L8
TBTB_TOP_N: RT215.1 UT11.L6
TBTB_TOP_N_R: DT43.2 DT43.8 JUSBC2.A7 RT215.2
TBTB_TOP_P: RT214.1 UT11.K6
TBTB_TOP_P_R: DT43.4 DT43.7 JUSBC2.A6 RT214.2
TBTB_TX1N: CT160.1 UT1.B19
TBTB_TX1N_C: CT160.2 DT23.1 JUSBC2.A3
TBTB_TX1P: CT159.1 UT1.A19
TBTB_TX1P_C: CT159.2 DT22.1 JUSBC2.A2
TBTB_TX2N: CT162.1 UT1.B17
TBTB_TX2N_C: CT162.2 DT35.1 JUSBC2.B3
TBTB_TX2P: CT161.1 UT1.A17
TBTB_TX2P_C: CT161.2 DT34.1 JUSBC2.B2
TBTB_USB2_RBIAS: RT41.1 UT1.H19
TBTB_USB20_N: RT408.2 UT1.D20
TBTB_USB20_P: RT407.2 UT1.E20
TDI_XDP: JXDP1.56 RC229.1 UC8.5
TDO_XDP: CC306.1 JXDP1.52 RC230.1 UC8.2
TDOCK_BATLOW#: RT20.1 UT1.F2
TEST_EN: RT36.1 UT1.E1
TEST_PWRGD: RT37.1 UT1.AB5
THERMDA: UT1.AB23 UT1.AC23
THERMTRIP1#: RE301.1 UE1.B12
THERMTRIP2#: CE36.1 QE4.1 RE69.2 UE1.H3
TOUCH_SCREEN_DET#: JTS1.10 RV8.1 RV305.1 UC1.AY5
TOUCH_SCREEN_PD#: JTS1.3 RC272.1 UC1.A7
TOUCHPAD_INTR#: JKBTP1.16 RE318.2 RPC5.1 UC1.BA5
TP_DISABLE#: JKBTP1.11 RE555.1 UE10.4
TP_DISABLE#_EC: RE529.1 UE1.L2 UE10.2
TPM_GPIO0: RZ112.2 UZ12.29
TPM_GPIO4: T283.1(TP-1) UZ12.13
TPM_LPM#: RZ363.2 UZ12.3
TPM_PIRQ#: RC560.1 RC561.1 RZ69.2 UZ12.18
TPM_PIRQ#_R: RC560.2 UC1.AP8
TRST#_XDP: JXDP1.54 UC8.12
TS_EN: RV306.2 RV323.2 RV326.2 UZ41.3
TS_I2C_SCL: CV55.1 JTS1.6 RV99.1 UC1.U6
TS_I2C_SDA: CV54.1 JTS1.5 RV98.1 UC1.U7
TS_INT#: JTS1.7 RV311.1 UC1.N12
TYPEC_CON_SEL1: RC555.1 RC556.1 UC1.W4
TYPEC_CON_SEL2: RC553.1 RC554.1 UC1.AB3
TYPEC_ID: CE62.1 RE343.1 UE1.F2
UART_MISO: RT82.1 RT83.2 RT346.2 UT5.F2
UART_MISO_R: RT178.1 RT344.1 RT346.1 UT11.E2
UART_MOSI: RT81.1 RT83.1 RT345.2 UT5.E2
UART_MOSI_R: RT178.2 RT343.1 RT345.1 UT11.F2
UG1_ISL9538: PQ905.1 PU901.11
UG2_ISL9538: PQ904.1 PU901.5
UIM_CLK: CZ38.1 JNGFF2.32 JSIM1.3
UIM_DATA: CZ39.1 JNGFF2.34 JSIM1.7 RZ335.2
UIM_RESET: CZ40.1 JNGFF2.30 JSIM1.2
UPD1_HPD: DZ107.2 RE553.2 UE1.K7
UPD1_SMBCLK: QT2.1 RPE12.3 RT150.1 UE1.C3
UPD1_SMBDAT: QT2.4 RPE12.4 RT151.1 UE1.B4
UPD1_SMBINT#: RE92.1 RT156.1 UE1.F10
UPD1_SMBINT#_R: RT60.2 RT68.1 UT5.B6
UPD1_SMBUS_CLK_Q: QT1.6 RT58.2 RT67.1 RT92.1 RT375.2 UT5.B5
UPD1_SMBUS_DAT_Q: QT1.3 RT59.2 RT66.1 RT93.1 RT376.2 UT5.A5
UPD2_HPD: DZ106.2 RE554.2 UE1.M1
UPD2_SMBCLK: QT1.1 RE303.1 RT58.1 UE1.D7
UPD2_SMBDAT: QT1.4 RE302.1 RT59.1 UE1.E7
UPD2_SMBINT#: RE91.1 RT60.1 UE1.F5
UPD2_SMBINT#_R: RT156.2 RT164.1 UT11.B6
UPD2_SMBUS_CLK_Q: QT2.6 RT150.2 RT163.1 RT188.1 RT384.2 UT11.B5
UPD2_SMBUS_DAT_Q: QT2.3 RT151.2 RT162.1 RT189.1 RT383.2 UT11.A5
USB2_ID: RC337.1 UC1.AG3
USB2_VBUSSENSE: RC338.1 UC1.AG4
USB3_PRX_C_DTX_N4: CR14.2 UR1.5
USB3_PRX_C_DTX_P4: CR13.2 UR1.4
USB3_PRX_DTX_N1: DI4.1 DI4.9 JUSB1.5 UC1.H8
USB3_PRX_DTX_N2: UC1.J6 UZ29.18
USB3_PRX_DTX_N3: DI1.1 DI1.9 JUSB2.5 UC1.J10
USB3_PRX_DTX_N4: CR14.1 UC1.E10
USB3_PRX_DTX_P1: DI4.2 DI4.8 JUSB1.6 UC1.G8
USB3_PRX_DTX_P2: UC1.H6 UZ29.19
USB3_PRX_DTX_P3: DI1.2 DI1.8 JUSB2.6 UC1.H10
USB3_PRX_DTX_P4: CR13.1 UC1.F10
USB3_PTX_C_DRX_N1: CI13.1 DI4.4 DI4.7 JUSB1.8
USB3_PTX_C_DRX_N2: CZ151.2 UZ29.16
USB3_PTX_C_DRX_N3: CI5.1 DI1.4 DI1.7 JUSB2.8
USB3_PTX_C_DRX_N4: CR32.2 UR1.3
USB3_PTX_C_DRX_P1: CI16.1 DI4.5 DI4.6 JUSB1.9
USB3_PTX_C_DRX_P2: CZ150.2 UZ29.17
USB3_PTX_C_DRX_P3: CI4.1 DI1.5 DI1.6 JUSB2.9
USB3_PTX_C_DRX_P4: CR31.2 UR1.2
USB3_PTX_DRX_N1: CI13.2 UC1.C13
USB3_PTX_DRX_N2: CZ151.1 UC1.B13
USB3_PTX_DRX_N3: CI5.2 UC1.B15
USB3_PTX_DRX_N4: CR32.1 UC1.C15
USB3_PTX_DRX_P1: CI16.2 UC1.D13
USB3_PTX_DRX_P2: CZ150.1 UC1.A13
USB3_PTX_DRX_P3: CI4.2 UC1.A15
USB3_PTX_DRX_P4: CR31.1 UC1.D15
USB20_N1: RT406.2 UC1.AB9
USB20_N2: LI3.1 UC1.AD6
USB20_N2_R: DI2.3 JUSB2.2 LI3.2
USB20_N3: RT402.2 UC1.AH3
USB20_N4: LI8.4 RI48.1 UC1.AD9
USB20_N4_L: JNGFF2.9 LI8.3 RI48.2
USB20_N5: LZ1.1 UC1.AJ1
USB20_N5_R: JEDP1.7 LZ1.2
USB20_N6: RR21.1 UC1.AF6
USB20_N6_R: RR21.2 UR1.10
USB20_N7: LI9.1 RI49.1 UC1.AH1
USB20_N7_L: JNGFF1.5 LI9.2 RI49.2
USB20_N8: LV27.3 UC1.AF8
USB20_N8_R: DV4.2 JTS1.8 LV27.4
USB20_N9: UC1.AG1 UI3.2
USB20_N9_R: DI5.2 JUSB1.2 LI7.2
USB20_N10: JUSH1.8 UC1.AH7
USB20_P1: RT405.2 UC1.AB10
USB20_P2: LI3.4 UC1.AD7
USB20_P2_R: DI2.2 JUSB2.3 LI3.3
USB20_P3: RT401.2 UC1.AJ3
USB20_P4: LI8.1 RI47.1 UC1.AD10
USB20_P4_L: JNGFF2.7 LI8.2 RI47.2
USB20_P5: LZ1.4 UC1.AJ2
USB20_P5_R: JEDP1.8 LZ1.3
USB20_P6: RR20.1 UC1.AF7
USB20_P6_R: RR20.2 UR1.9
USB20_P7: LI9.4 RI50.1 UC1.AH2
USB20_P7_L: JNGFF1.3 LI9.3 RI50.2
USB20_P8: LV27.2 UC1.AF9
USB20_P8_R: DV4.3 JTS1.9 LV27.1
USB20_P9: UC1.AG2 UI3.3
USB20_P9_R: DI5.3 JUSB1.3 LI7.3
USB20_P10: JUSH1.9 UC1.AH8
USB_OC0#: RPC3.3 UC1.A9 UI3.13
USB_OC1#: RPC3.1 UC1.C9 UI1.3
USB_OC2#: RPC3.4 UC1.D9
USB_OC3#: RPC3.2 UC1.B9
USB_POWERSHARE_EN#: RPE11.2 UE1.J3 UI3.6
USB_POWERSHARE_VBUS_EN: RPE11.4 UE1.J2 UI3.5
USB_PWR_EN1#: RPE11.3 UE1.K3 UI1.4
USB_PWR_EN2#: RPE11.1 UE1.G5
USBCOMP: RC44.1 UC1.AB6
USH_DET#: DZ7.2 RE526.1 RZ87.1 UE1.C13
USH_DET#_R: DZ7.1 JUSH1.26 RZ87.2
USH_EXPANDER_SMBCLK: CZ62.1 JUSH1.11 QZ13.3 QZ14.6 RZ8.2 UE1.B3 UE2.19
USH_EXPANDER_SMBDAT: CZ63.1 JUSH1.12 QZ13.6 QZ14.3 RZ9.2 UE1.E5 UE2.20
USH_PWR_STATE#: JUSH1.22 RZ10.2 UE1.H2
USH_RST#_R: JUSH1.21 RZ114.2
VCI_IN1#: RE507.1 UE1.B5
VCI_IN2#: RE508.1 UE1.D4
VGA_IDENTIFY: RE84.1 RE85.1 UE1.L9
VID0_PRIM_CORE: PR408.2 PR418.2 PR420.1 PU402.9
VID0_VCCIO: PR414.2 PR416.1 PU401.9
VID1_PRIM_CORE: PR411.2 PR417.2 PR419.1 PU402.8
VID1_VCCIO: PR413.2 PR415.1 PU401.8
VIDALERT_N: PR604.2 PR625.1 RC152.1 RC153.2
VIDALERT_N_B: PR625.2 PU602.36
VIDSCLK: CC321.1 PR601.2 PR618.1 UC1.A63
VIDSCLK_B: PR618.2 PU602.37
VIDSOUT: PR605.2 PR626.1 RC157.1 UC1.D64
VIDSOUT_B: PR626.2 PU602.35
VOL_DOWN#: JPWR1.4 RE520.1 UE1.J6
VOL_UP#: JPWR1.3 RE519.1 UE1.D1
VRALERT#: RC73.1 UC1.AM11
VSA_SEN+: PC640.2 PC650.1 PC652.1 PR649.2 RC168.2 UC1.H20
VSA_SEN-: PC649.1 PC650.2 PU602.26 RC166.1 UC1.H21
VSET_5105: CE38.1 RE77.1 UE1.C9
WIGIG_32KHZ: JNGFF1.50 RZ56.2
WLAN_COEX1: JNGFF1.48 RZ130.2
WLAN_COEX2: JNGFF1.46 RZ129.2
WLAN_COEX3: JNGFF1.44 RZ128.2
WLAN_PWR_EN: DZ9.1 RZ38.1 RZ70.2 RZ71.2 UZ2.3
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.1 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.56
WRST#: CE500.1 RE504.2 UE2.4
WWAN_ANTCTL0: JNGFF2.59 RZ327.1
WWAN_ANTCTL0_R: CZ182.1 CZ303.1 JTUN1.3 RZ327.2
WWAN_ANTCTL1: JNGFF2.61 RZ328.1
WWAN_ANTCTL1_R: CZ183.1 CZ302.1 JTUN1.4 RZ328.2
WWAN_ANTCTL2: JNGFF2.63 RZ329.1
WWAN_ANTCTL2_R: CZ184.1 CZ301.1 JTUN1.5 RZ329.2
WWAN_ANTCTL3: JNGFF2.65 RZ330.1
WWAN_ANTCTL3_R: CZ185.1 CZ300.1 JTUN1.6 RZ330.2
WWAN_COEX1: JNGFF2.64 RZ130.1
WWAN_COEX2: JNGFF2.62 RZ129.1
WWAN_COEX3: JNGFF2.60 RZ128.1
WWAN_PWR_EN: CZ198.1 JNGFF2.6 RZ43.1
WWAN_RADIO_DIS#: DZ5.1 RE10.1 UE1.F12
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.23 RE38.1 UE1.M13
XCLK_BIASREF: RC52.1 RC324.1 UC1.E42
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.1 RC290.1 UC12.1
XDP_JTAGX: CC305.1 RC87.1 RC328.1 UC1.A59
XDP_OBS0: JXDP1.21 RC239.2
XDP_OBS0_R: RC239.1 UC1.C55
XDP_OBS1: JXDP1.23 RC240.2
XDP_OBS1_R: RC240.1 UC1.D55
XDP_OBS2_R: T10.1(TP-1) UC1.B54
XDP_OBS3_R: T11.1(TP-1) UC1.C56
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XDP_TMS: JXDP1.58 RC228.1 UC8.9
XTAL24_IN_U22: CC21.1 RC46.2 RC419.2 YC1.3
XTAL24_IN_U22_CPU: RC419.1 UC1.E37
XTAL24_IN_U42: CC338.1 RC415.2 RC417.2 YC3.3
XTAL24_IN_U42_CPU: RC417.1 UC1.E3
XTAL24_OUT_U22: CC22.1 RC46.1 RC420.2 YC1.1
XTAL24_OUT_U22_CPU: RC420.1 UC1.E35
XTAL24_OUT_U42: CC339.1 RC415.1 RC418.2 YC3.1
XTAL24_OUT_U42_CPU: RC418.1 UC1.C7
XTAL_25_IN: RT394.1 UT1.D22
XTAL_25_IN_R: CT21.1 RT394.2 YT1.1
XTAL_25_OUT: RT40.1 UT1.D23
XTAL_25_OUT_R: CT20.1 RT40.2 YT1.3
N04748: PC939.1 PR929.1 PU901.3
N46735: CA33.1 RA17.2
N16399089: PD901.1 PD903.1 PD904.1 PR916.2
N16400770: PR901.3 PR910.1
N16404606: PD905.3 PR939.2
N16404610: PD905.2 PR941.2
N16404614: PR942.2 PU903.2
N16775301: PC208.2 PR204.2 PR206.1 PU200.16
N16775385: PC218.1 PU200.3
N16775433: PC204.1 PR202.2
N16775513: PC205.1 PR203.2
N16775517: PR203.1 PU200.12
N16776853: PC207.1 PU200.14
N16777273: PC222.1 PR210.2 PR212.1 PU200.2
N16783014: PC111.1 PR104.1 PR105.1 PU100.16 PU100.17
N16783095: PC113.2 PR108.1
N16783134: PC127.2 PR117.1
N16783222: PC119.1 PU102.16 PU102.17
N16784595: PC102.1 PR100.2
N16784799: PC114.1 PR111.2
N17113942: PC515.2 PR515.2 PR516.1 PU503.3
N17275961: PR612.2 PR614.2 PU602.39
N17275988: PR616.2 PU602.40
N17419094: PC1204.1 PQ1200.4 PR1206.2 PR1211.2
N17419103: PQ1201.6 PR1211.1
N17419127: PC1216.1 PQ1210.4 PR1236.2 PR1242.2
N17419137: PQ1217.6 PR1242.1
N17420744: PQ1218.1 PR1247.1 PR1258.2
N17421409: PQ1220.2 PQ1220.3 PR1271.1
N17423076: PQ1223.2 PQ1223.3 PR1272.1
N17423090: PQ1221.1 PQ1223.6 PR1268.1 PR1290.2
N17446677: PQ1209.1 PR1222.1 PR1228.2
N18490882: RI14.2 UI3.16
N19725601: PC1206.2 PQ1203.4 PQ1204.1 PR1204.2 PR1212.2
N20151644: PR901.2 PR909.1
N22211458: PQ1207.3 PR1212.1
N22242716: PC1217.2 PQ1211.4 PQ1227.1 PR1237.2 PR1244.2
N22400408: PC1205.2 PQ1202.4 PQ1225.1 PR1203.2 PR1209.2
N22401321: PQ1207.5 PR1221.1 PR1224.2
N22406932: PC1218.2 PQ1212.4 PQ1213.1 PR1238.2 PR1246.2
N22440950: PQ1216.6 PR1244.1
N22511366: PC1208.1 PQ1207.2 PR1214.2 PR1220.2
N23260134: PR1214.1 PU1202.4
N23412536: CD40.2 RD41.1
N23413182: RD29.1 UD1.B4
N23413199: RD28.1 UD1.B3
N23415795: CD39.2 RD40.1
N23511003: RD32.1 UD2.B4
N23511005: RD31.1 UD2.B3
N23718631: CD67.2 RD78.1
N23733501: RD71.1 UD3.B4
N23733503: RD70.1 UD3.B3
N23741962: PQ1216.5 PR1255.1 PR1257.2
N23746943: RD72.1 UD4.B3
N23746945: RD73.1 UD4.B4
N27076067: PC944.1 PR934.2
N27076242: PC930.1 PR914.2
N27077001: PR917.2 PR937.2
N28424999: T113.1(TP-1) UC1.AW71
N28425002: T114.1(TP-1) UC1.AW70
N28489601: RC222.1 SW1.1
N28769860: PR421.2 PR422.1 PU401.5
N28771761: PR404.2 PR425.2 PU401.14
N28771835: PR410.2 PR426.2 PU402.14
N28811129: CZ114.1 UZ3.10
N28856399: T16.1(TP-1) UC1.BA70
N28856402: T17.1(TP-1) UC1.BA68
N28857231: T12.1(TP-1) UC1.BB68
N28857234: T13.1(TP-1) UC1.BB69
N28857237: T14.1(TP-1) UC1.AK13
N28857240: T15.1(TP-1) UC1.AK12
N28861827: RC120.1 UC1.C64
N29708559: T126.1(TP-1) UC1.AY4
N29708561: T127.1(TP-1) UC1.BB3
N29708599: T128.1(TP-1) UC1.AU5
N29708601: T129.1(TP-1) UC1.AT5
N29708639: T130.1(TP-1) UC1.BB5
N30404696: CZ126.1 UZ5.12
N30404698: CZ127.1 UZ5.10
N32590572: CZ117.1 UZ4.12
N32592963: CZ118.1 UZ4.10
N32594166: CZ109.1 UZ2.12
N32819772: CZ121.1 UZ8.6
N34978918: PR1245.2 PR1283.2 PU1203.1
N34978921: PR1247.2 PU1203.2
N34978957: PR1248.1 PU1203.4
N35025004: PR1219.2 PR1284.2 PU1202.1
N35025007: PR1222.2 PU1202.2
N35025022: PC1220.1 PQ1216.2 PR1248.2 PR1250.2
N35029381: PC1212.1 PQ1201.5 PR1223.2
N35029400: PQ1201.2 PQ1201.3 PR1213.1 PR1295.1
N35029414: PC1211.1 PD1201.2 PR1217.2 PR1218.2 PR1223.1 PU1201.1
N35029420: PC1209.1 PD1201.1 PQ1208.1 PR1215.2 PR1218.1 PR1225.1 PR1287.2 PU1201.3
N35029430: PC1210.1 PR1216.2 PR1227.1 PU1201.2
N35029470: PQ1208.2 PR1230.1 PR1231.1 PR1232.1
N35030736: PC1224.1 PQ1217.5 PR1259.2
N35030744: PQ1217.2 PQ1217.3 PR1249.1 PR1296.1
N35030767: PC1223.1 PD1206.2 PR1254.2 PR1256.2 PR1259.1 PU1201.7
N35030773: PC1221.1 PD1206.1 PQ1219.1 PR1252.2 PR1256.1 PR1261.1 PR1288.2 PU1201.5
N35030783: PC1222.1 PR1253.2 PR1262.1 PU1201.6
N35030823: PQ1219.2 PR1266.1 PR1269.1 PR1270.1
N35031412: PQ1205.1 PR1205.1 PR1208.1
N35031421: PQ1206.2 PR1208.2
N35031425: PQ1206.1 PR1207.1
N35031429: PQ1204.2 PR1202.1 PR1207.2
N35032568: PQ1214.1 PR1239.1 PR1241.1
N35032572: PQ1215.2 PR1241.2
N35032578: PQ1215.1 PR1240.1
N35032580: PQ1213.2 PR1235.1 PR1240.2
N35034018: PQ1214.2 PR1243.1
N35034674: PQ1205.2 PR1210.1
N36307052: RT97.2 RT98.1 RT99.1 UT5.F10
N36307117: RT85.1 UT5.G4
N36307119: RT84.1 UT5.F4
N36307451: CT85.1 RT105.1 RT396.2
N36307473: RT395.1 UT5.K9 UT5.L9
N36307634: RT396.1 UT5.K10 UT5.L10
N36307669: RT63.1 UT5.F1
N36307926: RT103.1 UT5.L11
N36827741: RZ120.2 UZ26.4 UZ34.4
N38312012: CT87.1 UT5.H7
N38327809: RT101.1 UT5.D6
N39070459: QE11.3 RE70.1 RE90.2
N39070470: QE4.2 RE70.2
N39317125: PR423.1 PR424.1 PU402.5
N39469798: PR679.1 PU614.7
N39469818: PC631.1 PR630.2
N39469863: PC632.1 PR636.1 PU602.28
N39469972: PR678.2 PU602.38
N39469996: PC611.2 PU614.2
N39469998: PC611.1 PR619.1
N39470129: PC640.1 PR646.2
N39470145: PC601.1 PR652.2
N39470173: PC632.2 PR641.1
N39470189: PH604.1 PR642.2
N39470446: PC603.1 PR602.1 PU602.34
N39470448: PC604.1 PR603.1 PU602.33
N39470528: PR608.1 PU602.32
N39470532: PR611.1 PU602.31
N40166471: RT191.2 RT192.1 RT193.1 UT11.F10
N40166479: RT181.1 UT11.G4
N40166480: RT180.1 UT11.F4
N40166593: RT159.2 UT11.F1
N40166639: RT198.1 UT11.K10
N40166640: RT197.1 UT11.K9
N40166643: RT196.1 UT11.L11
N40166736: CT158.1 UT11.H7
N40166740: RT195.1 UT11.D6
N40421452: T261.1(TP-1) UC1.AT52
N40421453: T260.1(TP-1) UC1.AW50
N40421564: T258.1(TP-1) UC1.AP43
N40421565: T257.1(TP-1) UC1.AN43
N40421566: T259.1(TP-1) UC1.AT13
N41174761: CZ200.1 QZ1.2 RZ380.2
N41174762: QV2.1 RV5.2
N41174857: JEDP1.16 LV1.1
N41193025: CC8.1 RC29.2
N41193026: CC7.1 RC28.2
N41308011: CZ38.2 RZ334.1
N41877854: RA54.1 RA55.1 UA1.47
N41882113: CA35.1 UA1.38
N41884313: CA25.1 UA1.31
N41884577: CA49.1 UA1.24
N41886761: CA29.2 UA1.22
N41886763: CA29.1 UA1.23
N41887296: CA52.1 UA1.17
N41887299: CA53.1 UA1.13
N41887876: CA51.1 RA44.1 UA1.39
N44315031: PC947.1 PR935.1 PR947.1 PU901.29
N44321922: PD905.1 PR950.1 PR961.1 PU903.1
N44325464: RE318.1 UE1.G2
N44325691: CE57.1 RE350.2
N44519702: PR936.1 PR948.1 PU901.30
N44583000: PQ1209.3 PR1226.2 PR1229.1
N44583529: PQ1209.2 PR1233.1
N44585173: PQ1218.2 PR1265.1
N44585176: PQ1218.3 PR1251.2 PR1260.1
N44590042: JNGFF2.25 RZ326.1
N44616404: PQ1220.5 PR1273.2 PR1289.1 PR1293.2
N44616413: PQ1220.6 PQ1221.4 PR1267.1 PR1289.2
N44617199: PQ1223.5 PR1274.2 PR1290.1 PR1294.2
N44618351: PQ1221.5 PR1263.1 PR1276.2
N44618356: PQ1221.2 PR1264.1 PR1275.2
N44618521: PQ1222.2 PR1292.2
N44621211: PR933.2 PR951.2 PU901.26
N44641625: JNGFF2.67 T225.1(TP-1)
N44686334: PQ1225.2 PR1277.2 PR1279.1
N44687883: PQ1227.2 PR1280.2 PR1282.1
N44737537: PQ1216.3 PR1246.1
N44759345: JESPI.8 RE375.1 RE560.1
N45172969: QZ3.1 RZ511.1
N45269992: RZ64.2 RZ65.2 UZ2.5
N45270557: CZ113.1 UZ2.10
N45874245: RT389.2 RT390.1 UT7.3
N45874265: CT90.1 RT111.2 UT7.5
N45903768: JNGFF2.58 RZ132.2
N46477010: CZ306.1 UZ41.6
N46814682: PH601.2 PR610.1 PR631.2
N46814700: PC627.1 PR632.2
N46814728: PH602.1 PR628.2
N46814746: PC627.2 PR638.2 PU602.8
N46814769: PC617.2 PR621.1
N46815156: PR620.2 PU602.1
N46815164: PC621.2 PR623.1
N46815166: PR621.2 PR622.2 PR623.2 PU602.5
N46815186: PC616.2 PR617.2 PU602.4
N46815188: PC614.2 PR617.1
N46815204: PR610.2 PU602.3
N46815214: PC613.2 PR613.2 PU602.2
N46816449: PC647.2 PR650.2
N46816463: PC629.2 PR639.1
N46816511: PH603.2 PR635.1 PR647.2
N46816791: PC630.1 PR640.1 PU602.20
N46816817: PC630.2 PR644.1
N46816821: PH605.1 PR657.2
N46816907: PC639.2 PR645.1
N46924944: PR920.2 PU901.21
N46924987: PR922.2 PU901.22
N46941563: CT86.1 RT104.1 RT395.2
N47324022: PC313.1 PU301.16 PU301.17
N47394352: PC307.2 PR308.1
N48142326: QV4.2 RV18.2
N48223124: RC436.2 UC1.F65 UC1.G65
N48247115: RC437.2 UC1.K52
N48250113: RC438.1 UC1.AK52
N48302079: QE12.1 RE94.1
N48610495: CZ56.1 RZ63.1
N48610537: RZ62.1 UZ12.27
N48704005: PL614.3 PR624.1
N48708800: QC6.1 RC433.2
N48708802: CC340.1 QC7.2 RC432.2 RC433.1
N49117945: PR932.1 PU901.27
N49118067: PQ1207.6 PR1209.1
N49204882: PL612.3 PR661.1
N49222948: PR687.2 PU610.1
N49223679: PR659.2 PU610.2
N49223737: PC655.2 PU610.7
N49223739: PR660.2 PU610.5
N49223741: PC655.1 PR660.1
N49225697: PR686.2 PU610.17
N49226542: PR692.2 PU613.1
N49226544: PR671.2 PU613.2
N49227484: PC671.2 PU613.7
N49227486: PR672.2 PU613.5
N49227488: PC671.1 PR672.1
N49228457: PR689.2 PU613.17
N49230528: PR1298.2 PU612.17
N49231011: PC663.1 PR665.1
N49231017: PR665.2 PU612.5
N49231019: PC663.2 PU612.7
N49231205: PR664.2 PU612.1
N49231242: PR1299.2 PU612.2
N49466989: QE17.1 RE546.2
N49466993: CE64.1 DE2.1 QE15.2 RE541.2 RE543.2 RE565.1
N50595384: PR946.1 PU903.4
N51741838: RT446.2 UT33.3
N51741841: RT444.2 UT33.1
N51744116: RT445.2 RT456.2 UT32.1
N51744150: RT448.2 UT32.3
N52410921: RE527.2 RE528.1 UE2.3
N52410927: RE500.2 RE501.1 UE2.1
N52410929: RE502.2 RE503.1 UE2.2
N119328643: PC938.1 PR930.1 PR931.2 PU901.25
N132000604: PC934.1 PR921.2
N132005053: PR917.3 PR938.2

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JEDP1 11 15; JHDMI1 14; JIR1 4; JKBTP1 4; JLED1 5 6; JNGFF1 6 16 17 19 20 21 22 25 26 27 28 31 32 34 59 61 65 67 68 71 73; JNGFF2 20 22 24 28 44 46 48 56 68; JNGFF3 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JSD1 16; JSIM1 4 6 8 9; JSPI1 4; JUSH1 2 17; LGA1 11; PD2 2; PRP1 4 5; PU100 10 15; PU102 10; PU200 18 19; PU301 9 10 12; PU401 4; PU402 4; PU503 2 6 7; PU610 6 13 16 19; PU612 6 13 16 19; PU613 6 13 16 19; PU901 13; RC22 2; RC27 2; RE518 2; RE550 2; RPC4 2; RPC5 2 4 5 7; RPE9 1; RT69 2; RT74 2; RT75 2; RT84 2; RT85 2; RT165 2; RT170 2; RT171 2; RT180 2; RT181 2; RT339 2; RT340 2; RT375 1; RT376 1; RT383 1; RT384 1; UA1 2 7 14 15 19 20 35 36; UC1 A3 A4 A11 A26 A27 A29 A31 A33 A36 A38 A40 A52 A65 A69 AB4 AB13 AB62 AC63 AD3 AD4 AE62 AE63 AF11 AF12 AF13 AG62 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK62 AK70 AL25 AL27 AL61 AL63 AM1 AM2 AM3 AM4 AM5 AN2 AN8 AP4 AP56 AR56 AT43 AU56 AU58 AU63 AW1 AW13 AW17 AW20 AW42 AW48 AW68 AW69 AY1 AY2 AY20 AY21 B2 B3 B11 B26 B27 B29 B31 B33 B36 B38 B40 B52 B69 B70 BA3 BA4 BA9 BA47 BA50 BB2 BB4 BB9 BB46 BB52 BB57 BB66 C2 C4 C8 C11 C12 C20 C27 C28 C29 C31 C32 C33 C36 C37 C38 C41 C54 C70 C71 D1 D3 D4 D5 D12 D20 D27 D28 D29 D31 D32 D33 D36 D37 D38 D41 D54 D71 E1 E2 E61 F6 F18 F52 F60 F61 G18 G61 H11 H63 J1 J4 J5 J68 J71 K45 K46 L6 M1 M2 M3 N9 N11 P1 P3 P62 V1 V2 V62 W12; UD1 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD2 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD3 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD4 A1 A2 A12 A13 B1 B13 C4 K9 R3 T1 T13 U1 U2 U12 U13; UD5 1; UE1 B8 B9; UE2 5 6 8 9 12 13 14 15 16; UE4 1; UE6 1; UE10 1; UI3 9 15; UR1 28 29; UT1 A23 B23 E18 V18 W19 Y19; UT7 2 6 7; UV24 3; UZ3 1 2 3 12 13 14; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; YC1 2 4; YC3 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 693 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 4414 vias
v3: diameter 0.254, hole 0.102, TOP to GND1, 1450 vias
v4: diameter 0.457, hole 0.203, GND1 to GND5, 1431 vias
v5: diameter 0.254, hole 0.102, GND5 to BOTTOM, 2367 vias
v6: diameter 0.406, hole 0.203, TOP to BOTTOM, 209 vias
v7: diameter 0.508, hole 0.254, TOP to BOTTOM, 35 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 12.5
  TOP w0.086: UD5.4 96.57,47.52 RD83.1 95.87,48.22 93.01,48.22 92.75,47.96 90.1,47.96 90.01,47.88 v1(90.01,45.06) 90.01,44.56 90.67,43.9 PR210.1
1.8V_OUT: length 7.9
  TOP w0.086: v1(76.52,49.72) 77.07,49.72
  TOP w0.254: PR515.1 82.06,49.13 82.08,49.12 PC515.1 v3(82.14,49.12)
  GND1 w0.254: v3(82.14,49.12) v4(81.65,49.12)
  IN1 w0.254: v2(77.74,48.55) 78.88,47.41 81.3,47.41 81.65,47.76 v4(81.65,49.12)
1.8V_PRIM_PWRGD: length 89.3
  TOP w0.086: UE1.L7 v2(263.82,56.24) ; v3(217.04,36.61) 217.04,35.85 v6(216.18,34.99) 214.34,33.15 208.15,33.15 207.71,32.71 207.71,31.98 PR517.1 208.75,30.95 209.72,30.95 209.87,30.79 209.87,29.4 209.76,29.28 PU501.5
  GND1 w0.086: v3(217.04,36.61) v4(217.52,36.61)
  IN1 w0.051: v2(263.82,56.24) 263.44,56.61 263.44,58.02 263.26,58.2 262.02,58.2 261.84,58.02 261.84,53.87 261.95,53.76 261.95,51.5 261.89,51.44 261.89,50.62 259.4,48.13 v4(258.76,48.13)
  IN2 w0.061: v4(217.52,36.61) 218.3,35.83 228.73,35.83 230.47,34.09 233.52,34.09 233.86,33.75 235.6,33.75 237.91,31.44 251.01,31.44 254.72,35.15 254.72,38.83 255.17,39.28 255.17,39.93 256.03,40.79 256.03,41.41 256.64,42.03 256.64,45.13 257.09,45.58 257.94,45.58 258.22,45.86 258.22,47 258.76,47.53 258.76,48.13 v4(258.76,48.13)
3.3V_ALS_EN#: length 4
  TOP w0.086: v1(234.54,60.66) RE521.2 v3(233.62,61.81)
  GND1 w0.086: v4(232.91,61.4) 233.32,61.81 v3(233.62,61.81)
  GND5 w0.086: v5(234,61.4) v4(232.91,61.4)
3.3V_ALW2: length 12.2
  TOP w0.086: RE57.1 RE58.1 250.09,66.62 253.22,66.62 254.09,65.74 256.12,65.74 257.1,64.77 v1(257.37,64.77) 258.2,64.77 259.15,63.81 UE1.B1
3.3V_CAM_EN#: length 113.3
  TOP w0.086: RC311.1 151.09,55.09 147.6,58.59 147.6,60.6 v1(147.31,60.89) 147.1,61.1 147.1,61.71 147.5,62.1 v2(147.54,62.1)
  IN1 w0.051: v4(228.06,37.45) 227.55,37.96 225.34,37.96 223.41,36.03 218.68,36.03 217.97,35.31 206.01,35.31 205.81,35.12 200.51,35.12 199.97,35.66 185.48,35.66 183.39,37.74 179.42,37.74 178.19,38.97 177.67,38.97 177.06,39.58 172.93,39.58 171.63,40.88 165.02,40.88 163.24,42.66 162.89,42.66 161.12,44.43 161.12,44.43 161.12,46 160.17,46.95 158.6,46.95 157.99,47.56 157.09,47.56 155.69,48.95 155.69,50.58 155.87,50.76 155.87,55.22 155.69,55.4 155.69,55.42 150.11,61.01 149.25,61.01 148.96,61.3 148.96,62.29 148.76,62.49 147.94,62.49 147.55,62.1 v2(147.54,62.1)
  GND5 w0.086: v4(228.06,37.45) 228.27,37.23 v5(228.27,36.31)
  BOTTOM w0.086: RZ380.1 231.13,35.82 228.75,35.82 v5(228.27,36.31)
  BOTTOM w0.254: UC1.AT15 v2(147.54,62.1)
3.3V_TS_EN: length 104.2
  TOP w0.086: RV323.1 183.38,39.84 183.79,40.24 184.17,40.24 v3(184.27,40.34) ; v2(263.85,57.84) 264.19,58.19 UE1.J7
  GND1 w0.086: v4(184.32,40.9) 184.27,40.85 v3(184.27,40.34) ; v3(259.88,52.79) v4(259.25,52.79)
  IN2 w0.061: v4(184.32,40.9) 184.33,40.89 188.44,40.89 189.21,40.13 191.24,40.13 191.97,40.85 209.94,40.85 211.71,39.08 219.95,39.08 220.87,38.16 221.76,38.16 222.72,39.12 233.28,39.12 236.67,35.73 239.39,35.73 240.7,34.42 249.08,34.42 249.18,34.32 250.24,34.32 252.67,36.75 252.67,37 253.32,37.65 253.32,41.6 255.52,43.8 255.52,46.73 257.37,48.59 257.37,51.47 258.46,52.56 259.02,52.56 v4(259.25,52.79) 259.42,52.96 259.42,53.84 260.1,54.53 262.06,54.53 262.6,55.08 262.6,57.21 262.81,57.41 263.42,57.41 v2(263.85,57.84)
3.3V_WWAN_EN: length 91.4
  TOP w0.086: UZ4.5 203.88,37.47 RZ40.2 204.54,36.81 205.19,36.81 205.93,37.56 207.72,37.56 v6(208.13,37.97) 208.44,38.27 210.62,38.27 215.51,43.16 216.43,43.16 v2(216.5,43.24) ; UE1.C6 v2(263.02,63.38)
  IN4 w0.051: v2(216.5,43.24) 216.58,43.32 218.13,43.32 218.8,43.99 225.06,43.99 229.52,48.45 230.69,48.45 233.47,51.23 233.47,54.64 235.65,56.82 235.65,60.31 236.67,61.32 236.67,62.84 237.72,63.89 243.4,63.89 244.9,65.39 244.9,66.32 246.64,68.06 246.64,69.13 246.85,69.35 v4(246.85,74.3)
  GND5 w0.086: v5(247.52,74.08) 247.48,74.16 247,74.36 v4(246.85,74.3)
  BOTTOM w0.086: v2(263.02,63.38) 261.83,64.57 261.83,65.1 261.08,65.85 258.26,65.85 255.66,68.45 252.65,68.45 251.3,69.79 250.44,69.79 247.52,72.72 v5(247.52,74.08)
3V5V_EN: length 56
  TOP w0.086: v2(76.75,46.13) 77.48,46.13 v1(77.86,45.75)
  IN1 w0.254: v2(54.78,71.97) 55.82,71.97 57.73,73.87 57.73,76.01 58.34,76.62 63.72,76.62 64.33,76.01 64.33,71.28 66.21,69.4 66.21,64.07 76.78,53.51 76.78,48.09 77.03,47.83 77.03,46.41 v2(76.75,46.13)
  BOTTOM w0.203: PU102.12 54.21,71.53 54.65,71.97 v2(54.78,71.97)
  BOTTOM w0.254: v2(76.75,46.13) 76.93,46.31 PC128.1 ; PC128.1 77.47,46.29 77.47,45.26 PR116.1 77.48,45.16 76.92,44.6 PU100.12 ; PC128.1 77.45,47.09 PR114.2
3V_FB: length 1.9
  BOTTOM w0.254: PU100.13 77.39,44.15 PC113.1
3V_SN:
  vias: v6(76.56,40.19)
3V_VIN:
  vias: v2(72.05,46.4) v2(72.64,46.43) v6(71.8,45.84)
5V_FB: length 1.9
  BOTTOM w0.203: PU102.13 54.27,71.08 54.67,71.48 55.23,71.48 PC127.1
5V_SN: length 1.6
  TOP w0.086: PR112.2 54.84,66.47 v1(54.93,66.56)
5V_VIN:
  vias: v1(50.45,71.42) v2(49.73,72.18) v2(49.73,71.55) v2(49.7,70.95)
+0.6V_DDR_VTT: length 20.1
  BOTTOM w0.305: CD64.1 CD56.1
  BOTTOM w0.508: RD51.1 v2(140.3,31.3) ; RD18.1 v2(124.04,31.37) ; RD15.1 v2(118.33,31.37) ; RD42.1 v2(128.74,31.3) ; RD43.1 v2(129.63,31.3) ; RD64.2 142.97,31.58 ; RD50.1 v2(139.41,31.3) ; RD30.2 v2(122.14,31.37) ; RD79.2 v2(120.23,31.37) ; RD68.2 v2(134.97,31.3) ; RD22.2 v2(112.61,31.37) ; RD20.1 v2(126.9,31.37) ; RD48.1 v2(137.63,31.3) ; RD66.2 v2(133.19,31.3) ; RD49.1 v2(138.52,31.3) ; RD23.2 v2(113.57,31.37) ; RD33.2 v2(121.19,31.37) ; RD45.1 v2(130.52,31.3) ; RD13.1 v2(117.38,31.37) ; RD14.1 v2(116.42,31.37) ; RD65.2 v2(134.08,31.3) ; RD16.1 v2(123.09,31.37) ; RD80.2 v2(119.28,31.37) ; RD47.1 v2(136.74,31.3) ; RD12.1 v2(115.47,31.37) ; RD11.1 v2(114.52,31.37) ; RD44.1 v2(131.41,31.3) ; RD67.2 v2(135.86,31.3) ; RD21.2 v2(111.66,31.37) ; RD46.1 v2(132.3,31.3) ; RD19.1 v2(125.95,31.37) ; RD17.1 v2(125,31.37)
  vias: v6(91.09,34.22)
+0.6VSP:
  vias: v2(87.8,43.14) v2(87.8,42.5) v6(88.69,41.61)
+0.9V_TBT_CIO: length 2.9
  TOP w0.203: CT38.1 34.74,59.5 v2(34.65,59.58)
  TOP w0.381: v2(34.65,59.58) 34.59,59.65 CT40.1 ; CT39.1 34.59,60.28 v2(34.64,60.23)
  BOTTOM w0.152: UT1.R8 34.33,60.54 v2(34.64,60.23)
  BOTTOM w0.203: UT1.R12 UT1.R11
+0.9V_TBT_DP: length 5.9
  TOP w0.254: 32.1,58.93 32.61,58.43 CT29.1
  TOP w0.305: v2(32.05,58.93) 32.1,58.93
  BOTTOM w0.203: UT1.T11 v2(35.3,59.58) UT1.V11 ; UT1.L12 32.38,58.6 v2(32.05,58.93) 32.38,59.25 UT1.L11 ; UT1.M8 v2(32.7,60.23) UT1.L8 ; UT1.M6 v2(32.7,60.88) UT1.L6 ; UT1.V12 v2(35.3,58.93) UT1.T12 ; v2(35.3,58.28) UT1.V13
+0.9V_TBT_LVR_OUT: length 4.9
  GND1 w0.381: v3(31.41,56.37) 30.75,56.37 v4(30.62,56.24)
  GND5 w0.381: v5(31.08,56) 30.86,56 v4(30.62,56.24)
  BOTTOM w0.203: UT1.J11 UT1.H11 31.07,59.25 v2(30.76,58.94) 30.76,56.58
+0.9V_TBT_PCIE: length 3.7
  BOTTOM w0.203: v2(32.7,55.68) UT1.L18 ; v2(32.7,55.68) UT1.L19 ; v2(32.7,55.68) 32.7,55.68 ; v2(32.7,55.68) UT1.M18 ; UT1.M13 v2(32.7,57.63) 32.7,57.63 UT1.M15 v2(32.7,56.98) ; UT1.N19 v2(33.35,55.68) UT1.N18
  vias: v2(32.7,56.33)
+0.9V_TBT_SVR: length 6.1
  TOP w0.102: CT54.1 28.86,56.38 v1(27.93,56.38)
  TOP w0.305: v2(32.05,59.57) 32.69,59.57
  TOP w0.381: CT53.1 32.69,59.57 v2(32.7,59.58)
  BOTTOM w0.152: 32.05,59.58 v2(32.05,59.57)
  BOTTOM w0.203: v2(30.1,58.28) 29.78,57.95 UT1.E13 ; v2(30.1,58.28) UT1.E12 ; v2(30.1,58.28) UT1.F13 ; v2(30.1,57.63) 30.43,57.31 UT1.F15 ; UT1.F11 30.11,58.93 v2(30.11,58.93) 30.11,58.93 UT1.F12
  BOTTOM w0.229: 31.73,59.9 UT1.J9 ; UT1.L9 32.38,59.9 ; v2(32.7,59.58) 33.03,59.9 UT1.M9
  vias: v4(26.17,69.07) v4(26.75,69.07) v4(26.78,68.49) v4(26.75,67.88) v5(25.72,68.6) v5(26.15,68.59) v5(26.15,68.21) v5(26.15,67.8)
+0.9V_TBT_USB: length 2.1
  TOP w0.381: CT32.1 34.8,55.94 CT33.1 34.66,56.62 v2(34.66,56.97)
  BOTTOM w0.254: UT1.R15 34.61,57.02 34.61,57.02 v2(34.66,56.97) 34.65,56.97 UT1.R16
+1.0V_AMPHYPLL: length 16.9
  TOP w0.254: v2(148.35,75.47) 148.9,76.02 CC264.1 147.87,77.21 147.87,81.16 147.59,81.44 147.59,82.6 v6(149.38,84.39) 151.06,86.06 CC219.1 151.87,87.93 RC169.2
  BOTTOM w0.254: UC1.L15 v2(148.35,75.47) UC1.K15
+1.0V_APLL: length 3.1
  TOP w0.508: LC2.2 149.89,73.39 CC323.1 148.76,73.15 CC314.1 148.44,72.16 148.33,72.16 v2(148.28,72.12)
  BOTTOM w0.254: v2(148.28,72.12) UC1.V15
+1.0V_APLLEBB: length 23.5
  TOP w0.254: CC325.1 145.1,73.18 v2(145.73,73.8) 146.14,74.21 CC218.1 ; RC310.2 154.58,87.48 154.02,86.91 152.58,86.91 v6(151.64,85.97) 148.02,82.36 148.02,81.49 148.21,81.3 148.21,77.72 149.43,76.51 v3(149.43,76.36)
  GND1 w0.254: v3(149.43,76.36) v4(149.43,75.67)
  IN2 w0.254: v4(149.43,75.67) 149.43,75.69 149.16,75.95 148.15,75.95 148.03,75.83 147.59,75.83 145.73,73.96 v2(145.73,73.8)
  BOTTOM w0.254: UC1.N18 v2(145.73,73.8)
+1.0V_CLK1: length 11.4
  TOP w0.508: RC302.2 157.37,79 156.73,79.64 150.99,79.64 v6(148.97,81.66) v2(148.53,82.1)
  BOTTOM w0.152: UC1.A14 148.33,81.91 v2(148.53,82.1)
+1.0V_CLK2: length 14.8
  TOP w0.254: 145.63,83.66 145.63,82.74 145.38,82.48 145.38,81.54 v6(146.01,80.91) 146.6,80.32 146.6,77.4 146.19,77 v2(145.64,77)
  TOP w0.508: RC170.2 CC220.1 146.42,86.9 145.63,86.11 145.63,83.66
  BOTTOM w0.254: UC1.K19 145.71,76.19 145.71,76.92 v2(145.64,77)
+1.0V_CLK3: length 18
  TOP w0.254: RC303.2 137.01,86.13 v6(138.46,84.68) 139.32,83.82 142.58,83.82 144.23,82.16 144.23,80.71 143.55,80.03 143.55,76.49 144.43,75.61 v2(144.43,75.47)
  BOTTOM w0.254: UC1.L21 v2(144.43,75.47)
+1.0V_CLK4: length 18.9
  TOP w0.254: v2(144.43,73.79) 145.56,74.92 145.56,75.96 144.23,77.28 144.23,79.74 144.92,80.43 144.92,82.98
  TOP w0.508: RC173.2 142.97,87.42 142.82,87.58 CC226.1 141.95,87.58 141.58,87.21 141.58,85.89 142.56,84.91 143,84.91 v6(143.96,83.94) 144.92,82.98
  BOTTOM w0.254: UC1.N20 v2(144.43,73.79)
+1.0V_CLK5: length 21.2
  TOP w0.254: RC52.2 143.72,73.87 v1(144.62,74.76) 144.87,75.02 144.87,75.26 v2(145.08,75.47) 145.08,75.95 143.89,77.14 143.89,79.89 144.58,80.57 144.58,82.32 144.12,82.78 144.12,82.94
  TOP w0.508: CC221.1 138.43,87.41 RC171.2 137.88,86.08 139.64,84.31 142.75,84.31 144.12,82.94
  BOTTOM w0.254: UC1.L19 v2(145.08,75.47)
+1.0V_CLK6: length 11.8
  TOP w0.508: RC300.2 159.09,78.99 CC216.1 158.24,79.48 157.45,80.27 151.3,80.27 v6(151.1,80.48) 150.44,81.14 v2(150.44,81.9)
  BOTTOM w0.254: v2(150.44,81.9) 150.55,81.9 150.81,81.64 UC1.A10
+1.0V_DTS: length 2.6
  TOP w0.508: v2(157.47,73.39) 157.47,73.92 RC301.2
  BOTTOM w0.203: v2(157.47,73.39) 157.25,73.17 UC1.T1
+1.0V_MPHYAON: length 21.2
  TOP w0.102: v2(156.81,76.13) 157.19,75.75 v1(158.26,75.75)
  TOP w0.508: v2(146.38,75.47) 146.45,75.4 CC203.1 ; RC299.2 156.77,76.09 v2(156.81,76.13)
  IN4 w0.254: v2(146.38,75.47) 146.38,75.2 147.21,74.38 148.48,74.38 148.88,73.97 148.88,73.31 148.76,73.19 148.76,72.7 149.09,72.37 154.88,72.37 156.81,74.3 v2(156.81,76.13)
  BOTTOM w0.254: v2(156.81,76.13) 156.53,75.85 155.84,75.85 UC1.L1 ; UC1.K17 v2(146.38,75.47)
+1.0V_MPHYGT: length 4.8
  TOP w0.508: RC310.1 154.14,89.05 153.5,88.41 RC169.1
  BOTTOM w0.254: v2(147.64,73.77) 147.64,73.95 147.38,74.21 UC1.N16 ; UC1.P15 148.04,73.41 148.04,73.44 148.3,73.69 v2(148.3,73.82) 148.3,73.89 148.01,74.18 UC1.N15 ; UC1.P16 147.36,73.39 147.05,73.7 v2(147.05,73.79) 147.05,73.87 UC1.N17
  vias: v2(155.62,90.26) v2(156.25,90.26) v2(156.89,90.26) v2(157.52,90.26) v2(158.16,90.26) v4(154.01,78.19) v4(154.01,77.56) v4(154.65,78.19) v4(154.65,77.56) v6(158.96,90.46)
+1.0V_PRIM: length 72.3
  TOP w0.508: RC301.1 158.59,74.47 158.3,74.76 v3(158.08,74.76) ; RC170.1 147.67,90.44 147.08,91.03 ; v2(146.38,71.28) 146.38,71.85 CC206.1 146.38,72.08 v2(146.38,72.95) ; RC302.1 157.14,77.79 157.14,77.44 v2(157.18,77.41) 157.23,77.35 158.56,77.35 159.12,77.91 RC300.1 ; CC335.1 150.92,73.62 LC2.1 ; 147.08,91.03 146.23,90.19 143.98,90.19 143.48,89.68 143.48,88.39 RC173.1 143.79,88.34 144.56,87.58 CC225.1 ; 147.08,91.03 144.26,93.85 138.57,93.85 137.88,93.15 RC171.1 RC303.1 136.26,89.08 v6(126.26,89.08) 125.8,89.08 125.26,89.62 v2(125.26,90.76) ; RC299.1 v3(155.74,77.49)
  GND1 w0.381: v4(150.81,73.93) 150.6,73.73 v3(150.6,73.33)
  GND1 w0.508: v3(158.08,74.76) v4(158.59,74.76) ; v3(155.74,77.49) 155.74,77.81 v4(155.55,78)
  IN2 w0.762: v2(172.78,81.49) 172.78,81.78 171.65,82.91 171.32,82.91 168.55,85.68 168.02,85.68 167.38,86.33 167.38,87.23 166.29,88.32 166.29,90.64 164.76,92.16
  GND5 w0.508: v4(66.54,90.81) 66.4,90.67 v5(66.4,89.63)
  BOTTOM w0.254: CZ105.1 170.93,81.9 170.93,80.75 170.94,80.74 170.94,80.73 171.18,80.49 ; UC1.AB17 146.54,70.24 146.38,70.44 UC1.Y18 146.15,70.98 v2(146.38,71.28) ; UZ19.2 171.2,80.25 ; v2(144.4,66.3) 144.76,65.84 UC1.AK20 ; UC1.AB20 v2(145.08,69.6) UC1.AB19 v2(145.73,69.6) ; UC1.P18 v2(146.38,72.95)
  vias: v2(57.94,65.18) v2(57.94,64.54) v2(57.9,63.91) v2(57.94,63.25) v2(58.52,64.9) v2(58.54,64.29) v2(58.57,63.65) v2(58.57,63.02) v2(159.25,93.94) v2(159.25,93.35) v2(159.25,92.77) v2(159.25,92.19) v2(159.83,93.94) v2(159.83,93.35) v2(159.83,92.77) v2(172.8,80.57) v2(172.81,79.66) v4(48.68,89.73) v4(49.17,89.4) v4(51.94,89.57) v4(57.07,92.16) v4(57.18,92.78) v4(57.7,93.18) v4(162.89,92.36) v4(163.68,92.37)
+1.0V_PRIM_CORE: length 4.6
  TOP w0.102: v2(171.37,39.02) v6(171.37,38.26)
  TOP w0.508: v2(143.55,71.44) 143.57,71.46 CC205.1
  BOTTOM w0.254: v2(145.1,68.79) 145.1,68.67 145.41,68.36 UC1.AF19 ; v2(145.73,68.76) 145.73,68.67 UC1.AF18 ; UC1.V20 144.68,71.62 144.18,71.62 UC1.V21 ; UC1.V21 v2(143.55,71.44) ; UC1.V21 v2(143.78,72.11)
  vias: v2(171.44,39.62) v2(171.8,38.62) v2(171.95,39.23)
+1.0V_PRIM_COREP: length 13.4
  TOP w0.254: PR423.2 155.66,28.06 156.35,27.36 160.82,27.36 161.84,26.35 v6(162.31,26.35) 165.96,26.35 166.57,26.96 v2(166.57,28.23)
  vias: v2(167.68,29.55) v2(168.27,29.55)
+1.0V_PRIM_XDP: length 22
  TOP w0.254: v2(63.57,92.85) 63.57,92.57 63.87,92.27 JXDP1.43
  GND1 w0.254: v3(63.57,88.48) 63.57,88.75 63.82,89.01 63.84,89.01 63.88,89.05 63.88,89.01 v4(63.89,89.01)
  IN2 w0.254: v2(74.39,92.79) 73.96,92.36 63.82,92.36 63.57,92.62 v2(63.57,92.85)
  GND5 w0.254: v5(63.58,89.49) 63.58,89.45 63.88,89.16 63.88,89.01 v4(63.89,89.01)
  BOTTOM w0.254: v2(74.39,92.79) 74.39,91.86 RC138.2 ; RC115.2 63.16,88.91 63.58,89.33 v5(63.58,89.49) ; v2(63.57,92.85) CC28.1 v1(63.57,90.32) 63.57,89.51 v5(63.58,89.49) ; v5(63.58,89.49) 64.03,89.49 64.15,89.62 RC216.2
+1.0V_SRAM: length 18.2
  TOP w0.102: v2(158.72,87.77) 159.24,87.77 v1(159.31,87.69)
  TOP w0.508: CC217.1 144.43,69.62 v2(144.43,68.76) ; v2(158.72,87.77) 158.6,87.65 RC309.2
  IN2 w0.508: v4(155.79,75.8) 155.79,77 157.77,78.98 157.77,85.76 158.72,86.7 v2(158.72,87.77)
  BOTTOM w0.254: UC1.T19 UC1.T20 144.74,72.53 144.49,72.28 v2(144.49,72.09) ; UC1.AF21 144.11,68.44 v2(144.43,68.76) 144.76,68.43 UC1.AF20
+1.0V_VCCST: length 337.2
  TOP w0.254: v3(73.32,90) 73.78,89.54 76.33,89.54 76.84,89.04 v3(76.84,87.03)
  TOP w0.508: 155.31,92.24 155.31,91.6 v6(154.47,90.76) 152.82,89.11 148.65,89.11 148.46,88.92 148.46,87.27 147.91,86.73 147.91,84.49 146.66,83.24 146.66,82.67 146,82 v2(146,81.94) 146,81.77 147.36,80.41 CC195.1 ; v2(177.53,81.54) 177.53,76.31 174.23,73.01 174.23,67.83 179.23,62.84 179.23,61.02 181.02,59.23 181.02,55.54 178.47,52.99 178.47,44.11 v2(178.8,43.78) ; v3(140.58,81.16) 140.58,81.6 139.78,82.41 138.59,82.41 137.21,83.79 134.65,83.79 130.09,88.35 118.85,88.35 v3(117.94,87.44) ; CC202.1 143.73,75.52 v2(143.78,75.47) ; v2(155.31,93.58) 155.31,92.41 ; RE90.1 v2(251.68,44.39)
  GND1 w0.254: v3(73.32,90) 72.71,90.61 v4(72.71,90.81) ; v3(76.84,87.03) 76.46,86.65 76.27,86.65 v4(76.27,86.65)
  GND1 w0.508: v4(268.19,46.29) 268.37,46.11 v3(268.65,46.11) ; v3(117.94,87.44) v4(117.34,87.44) ; v4(140.57,80.65) 140.57,81.15 v3(140.58,81.16)
  IN1 w0.508: v2(113.33,87.33) 113.43,87.44 v4(117.34,87.44)
  IN2 w0.508: v4(240.05,57.69) 241.52,59.17 248.07,59.17 248.71,58.53 251.38,58.53 251.88,58.02 251.88,56.5 251.4,56.02 251.4,44.67 v2(251.68,44.39) ; v2(177.53,81.54) 177.53,82.49 173.44,86.58 173.44,87.13 169.38,91.19 167.99,91.19 165.65,93.53 v4(163.92,93.53)
  IN3 w0.254: v4(73.75,92.85) 74.39,93.48 84.8,93.48 86.28,92 87.28,91 88.32,91 89.06,90.26 93.69,90.26 96.28,92.85 104.34,92.85 v2(105.12,92.06)
  IN3 w0.508: v4(140.57,80.65) 140.58,80.65 140.58,81.39 141.09,81.9 142.03,81.9 142.54,81.39 142.54,81.39 143.04,80.88 146.05,80.88 ; v4(240.05,57.69) 238.85,57.69 237,55.84 237,55.04 236.44,54.48 236.44,51.3 232.97,47.82 232.97,46.21 229.72,42.96 227.76,42.96 224.89,40.09 219.75,40.09 218.75,39.09 209.9,39.09 209.8,39.2 195.85,39.2 195.22,38.57 193.39,38.57 193.08,38.87 192.49,38.87 192,38.39 191.33,38.39 189.54,40.18 186.96,40.18 185.62,41.51 184.07,41.51 184.03,41.47 182.04,41.47 181.66,41.85 179.56,41.85 178.8,42.61 178.8,43.11 178.8,43.11 v2(178.8,43.78)
  IN4 w0.254: v4(73.75,92.85) 73.75,92.34 72.71,91.3 v4(72.71,90.81) ; v4(64.28,80.5) 64.08,80.3 61.04,80.3 60.79,80.55 60.79,81.96 62.04,83.22 64.41,83.22 65.71,84.51 74.14,84.51 v4(76.27,86.65)
  IN4 w0.381: v4(268.19,46.29) 268.19,47.03 v2(267.05,48.17)
  GND5 w0.254: v5(72.18,90) 72.18,90.03 72.71,90.56 v4(72.71,90.81) ; v4(64.28,80.5) v5(64.64,80.15)
  GND5 w0.508: v5(116.5,86.78) 116.5,86.83 117.11,87.44 v4(117.34,87.44) 117.62,87.44 v5(118.28,86.78)
  BOTTOM w0.152: UC1.A18 145.83,81.02 145.83,81.77 v2(146,81.94)
  BOTTOM w0.254: v5(72.18,90) 72.18,89.7 72.67,89.21 RC218.2 ; UC1.K20 144.71,75.93 144.15,75.93 UC1.K21 144.11,75.79 v2(143.78,75.47) ; RC71.2 111.37,88.12 107.43,92.06 v2(105.12,92.06) ; PR604.1 65.45,77.77 PR601.1 65.45,79.51 PC602.1 64.86,80.15 v5(64.64,80.15)
  BOTTOM w0.381: v2(267.05,48.17) 266.72,47.84 262.43,47.84 258.41,43.82 255.47,43.82 254.9,44.39 v2(251.68,44.39)
  BOTTOM w0.508: RC71.2 111.4,87.56 RC120.2 RC157.2 RC152.2 113.17,87.18 v2(113.33,87.33) ; v2(177.53,81.54) 177.53,81.93 RZ151.2 ; PR605.1 PR604.1
  vias: v2(155.95,93.58)
+1.0V_VCCST_C: length 1.3
  TOP w0.127: 156.82,93.28 v6(156.82,94.53)
+1.0V_VCCSTG: length 142.2
  TOP w0.254: 89.07,88.58 88.18,89.46 RC134.2 ; RC135.2 89.05,87.56
  TOP w0.508: v2(102.28,92.08) v6(99.41,92.08) 96.13,92.08 91.61,87.56 90.09,87.56 ; RC131.2 86.3,90.64 87.29,89.65 RC134.2 ; v2(143.32,81.8) 142.12,83 138.84,83 136.97,84.87 135.34,84.87 134.5,85.71 v3(134.5,87.61) 133.76,87.61 CC199.1
  GND1 w0.508: v3(134.5,87.61) v4(134.98,87.61)
  IN4 w0.508: v2(122.8,87.51) 124.54,89.25 124.54,93.12 126.12,94.7 131.05,94.7 131.66,94.1 131.66,89.51 132.47,88.71 133.8,88.71 134.89,87.61 v4(134.98,87.61) 136.8,87.61 137.47,88.29 137.47,93.28 138.9,94.7 144.65,94.7 149.43,89.92 153.88,89.92 155.19,88.62 171,88.62 174.23,85.39 174.23,82.75
  BOTTOM w0.254: UC1.A22 143.22,81.15 143.22,81.7 v2(143.32,81.8)
  BOTTOM w0.508: RC83.2 105.55,88.99 104.89,89.65 103.01,89.65 102.28,90.38 v2(102.28,92.08) 104.23,92.08 105.07,92.92 115.29,92.92 117.57,90.64 117.57,90.16 118.28,89.44 118.48,89.44 118.79,89.14 RC87.2 RC130.2 RC81.2 121.22,88.68 122.39,87.51 v2(122.8,87.51) 122.52,87.23 RC82.2
  vias: v2(174.99,82.41) v2(175.04,81.82)
+1.0V_VCCSTG_C:
  vias: v2(175.02,80.43)
+1.0V_VCCSTG_R: length 21.3
  TOP w0.254: RC143.1 135.89,86.61 v6(136.4,86.1) 139.03,83.47 142.44,83.47 143.89,82.02 143.89,81.21 143.64,80.96 142.44,80.96 142.17,80.69 142.17,79.49 143.21,78.45 v3(143.21,77.34)
  GND1 w0.254: v3(143.21,77.34) 143.21,76.98 142.99,76.77 v4(142.99,76.49)
  GND5 w0.254: v4(142.99,76.49) 143.57,76.49 143.65,76.41 v5(143.85,76.41)
  BOTTOM w0.254: v5(143.85,76.41) 143.95,76.27 144.51,76.27 144.83,76.54 144.93,77.09 145.04,77.16 UC1.G20
