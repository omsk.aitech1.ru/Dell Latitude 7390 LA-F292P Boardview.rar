# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ISH_I2C1_SCL: length 134.7
  GND1 w0.086: v4(247.69,70.93) 247.64,70.93 247.36,71.21 v3(247.21,71.21)
  IN1 w0.051: v2(243.22,65.31) 243.22,65.91 247.69,70.39 v4(247.69,70.93)
  IN2 w0.061: v4(237,60.36) 237.46,60.36 242.48,65.38 243.15,65.38 v2(243.22,65.31)
  IN3 w0.061: v4(164.2,72.42) 165.78,72.42 168.72,69.48 168.72,67.75 171.97,64.51 171.97,61.13 173.07,60.02 173.07,57.24 179.78,50.53 179.78,49.75 179.78,49.29 181.27,47.8 181.27,47.8 181.53,47.54 182.62,47.54 184.66,45.51 185.59,45.51 187.51,43.59 199.32,43.59 200.2,42.71 213.69,42.71 213.81,42.82 215.39,42.82 217.15,44.59 224.34,44.59 225.85,46.1 225.85,47.94 227.55,49.64 227.55,51.79 227.44,51.91 227.44,59.34 229.91,61.82 231.4,61.82 232.36,60.86 236.5,60.86 v4(237,60.36)
  GND5 w0.086: v4(237,60.36) 237.12,60.36 237.25,60.22 v5(237.25,59.9) ; v5(163.84,71.97) 163.84,72.07 v4(164.2,72.42)
  BOTTOM w0.076: UC1.N2 155.54,74.11 158.52,74.11 158.74,74.33 158.87,74.33
  BOTTOM w0.086: v5(237.25,59.9) 237.25,59.85 RZ138.1 ; v5(163.84,71.97) v1(162,71.97) 161.58,71.97 161.32,72.23 161.32,73.27 160.25,74.33 158.87,74.33
ISH_I2C1_SCL_EC: length 45.1
  TOP w0.086: UE1.F7 v2(263.82,60.98) ; RPE12.1 262.01,45.33 v3(262.23,45.56) ; v2(248.51,68.25) 248.37,68.25 248.12,68.49 v1(248.12,70.05) RE517.1
  GND1 w0.086: v4(262.56,46.26) 262.56,45.89 v3(262.23,45.56)
  IN1 w0.051: v2(263.82,60.98) 264.01,60.98 264.81,60.18 266.86,60.18 267.38,59.67 267.38,55.15 267.2,54.97 266.77,54.97 266.46,54.67 266.46,52.77 265.82,52.13 265.82,49.08 263.34,46.59 262.93,46.59 262.6,46.26 v4(262.56,46.26)
  BOTTOM w0.086: v2(248.51,68.25) 250.19,66.56 251.2,66.56 252.5,65.26 254.25,65.26 256.13,63.38 256.13,63.08 258.6,60.6 260.84,60.6 261,60.77 261,61.18 261.19,61.38 261.62,61.38 261.83,61.17 261.83,60.82 262.04,60.6 263.43,60.6 263.81,60.98 v2(263.82,60.98)
ISH_I2C1_SDA: length 136.4
  GND1 w0.086: v3(247.21,72.09) 247.21,72.04 247.69,71.56 v4(247.69,71.51)
  IN1 w0.051: v2(243.81,65.65) 243.81,66.05 248.28,70.52 248.28,70.93 v4(247.69,71.51)
  IN2 w0.061: v4(236.42,60.36) 236.95,59.83 237.37,59.83 242.36,64.81 243.35,64.81 243.81,65.27 v2(243.81,65.65)
  IN3 w0.061: v4(162.57,72.2) 162.76,72.01 164.03,72.01 171.65,64.38 171.65,61 172.76,59.89 172.76,57.11 179.46,50.4 179.46,49.88 179.46,49.88 179.46,49.16 180.96,47.67 181.4,47.23 182.49,47.23 184.53,45.19 185.46,45.19 187.38,43.27 190.58,43.27 191.49,42.36 213.79,42.36 213.94,42.51 216.44,42.51 217.52,43.59 219.19,43.59 219.87,44.27 224.47,44.27 226.17,45.97 226.17,46.23 226.17,47.81 227.87,49.51 227.87,53.48 229.72,55.33 229.72,56.58 229.05,57.25 228.61,57.25 227.75,58.1 227.75,59.21 230.01,61.47 231.31,61.47 232.23,60.55 236.23,60.55 v4(236.42,60.36)
  GND5 w0.086: v5(236.39,60.84) 236.39,60.44 236.42,60.41 v4(236.42,60.36) ; v5(162.57,72.86) v4(162.57,72.2)
  BOTTOM w0.076: 158.51,74.63 158.15,74.28 156.55,74.28 156.33,74.5 UC1.N1
  BOTTOM w0.086: 158.51,74.63 158.69,74.81 160.26,74.81 v1(161.27,73.8) 162.03,73.03 162.4,73.03 v5(162.57,72.86) ; v5(236.39,60.84) 236.44,60.84 236.83,61.23 RZ141.1
ISH_I2C1_SDA_EC: length 56.6
  TOP w0.086: v1(246.17,72.2) 246.77,72.8 247.31,72.8 248.01,72.09 RE516.1 248.76,72.09 v2(248.79,72.07) ; RPE12.2 261.26,45.73 261.4,45.86 262.37,45.86 262.53,45.71 v3(262.53,45.3) ; UE1.B6 v2(262.99,64.21)
  GND1 w0.086: v4(263.6,45.29) 263.6,45.29 263.6,45.29 263.59,45.3 v3(262.53,45.3)
  IN1 w0.051: v2(262.99,64.21) 263.1,64.21 263.6,64.71 268.34,64.71 268.92,64.13 269.36,64.13 270.01,63.48 270.01,60.6 272.19,58.42 272.19,54.41 269.77,51.99 268.41,51.99 267.84,51.41 267.84,49.54 267.21,48.91 267.03,48.91 265.63,47.5 265.63,46.5 265.36,46.24 264.41,46.24 263.6,45.43 263.6,45.29 v4(263.6,45.29)
  BOTTOM w0.086: v2(262.99,64.21) 262.47,64.21 262,64.68 262,65.18 261.15,66.02 258.46,66.02 255.82,68.66 252.78,68.66 251.41,70.03 250.82,70.03 v2(248.79,72.07)
ISH_I2C2_SCL: length 141.5
  TOP w0.086: v3(227.5,77.4) 228.24,77.4 RZ76.1
  GND1 w0.086: v4(227.96,77.61) 227.75,77.4 v3(227.5,77.4) ; v3(164.43,69.5) 164.43,68.98 v4(164.44,68.97)
  IN3 w0.061: v4(230.32,59.6) 231.5,58.41 231.5,56.12 229.5,54.11 229.5,50.57 229.32,50.39 229.32,48.22 224.74,43.64 221.32,43.64 220.51,42.83 217.65,42.83 216.7,41.88 214.2,41.88 214.05,41.73 191.23,41.73 190.32,42.64 187.12,42.64 185.2,44.56 181.61,44.56 178.83,47.34 178.83,50.14 172.13,56.84 172.13,59.63 171.02,60.74 171.02,64.12 165.59,69.55 165.02,69.55 v4(164.44,68.97)
  IN4 w0.051: v4(230.32,59.6) 229.35,60.56 229.35,62.21 231.08,63.94 231.08,64.73 230.22,65.59 227.65,65.59 226.46,66.78 226.46,76.44 227.63,77.61 v4(227.96,77.61) ; v4(164.44,68.97) 164.38,68.97 163.64,69.71 163.24,69.71 162.12,70.82 161.4,70.82 161.33,70.75 156.47,70.75 156.24,70.52 156.24,69.82 155.57,69.15 153.05,69.15 151.96,70.24 151.12,70.24 150.97,70.09 149.47,70.09 149.26,69.88 v2(149.26,69.73)
  BOTTOM w0.086: UC1.AD12 149.5,69.48 v2(149.26,69.73)
ISH_I2C2_SCL_R: length 3
  TOP w0.086: JNGFF2.40 231.52,78.9 231.48,78.88 230.28,77.68 RZ76.2
ISH_I2C2_SDA: length 143.7
  GND1 w0.086: v3(165.4,68.59) 165.29,68.69 v4(165.29,69.15) ; v3(228.52,76.79) 228.31,77 v4(227.93,77)
  IN3 w0.061: v4(165.29,69.15) 165.55,69.15 170.71,63.99 170.71,60.61 171.81,59.5 171.81,56.71 178.52,50.01 178.52,47.21 181.48,44.25 185.07,44.25 187.6,41.72 190.8,41.72 191.1,41.41 214.18,41.41 214.33,41.56 216.85,41.56 217.27,41.98 221.78,41.98 223.13,43.33 224.87,43.33 229.63,48.09 229.63,49.06 230.51,49.93 231.09,49.93 231.82,50.66 231.82,58.71 v4(230.32,60.21)
  IN4 w0.051: v4(165.29,69.15) 164.86,69.58 164.3,69.58 163.85,70.03 163.35,70.03 162.25,71.13 161.46,71.13 160.93,71.66 156.95,71.66 155.94,70.65 155.94,69.95 155.44,69.45 153.38,69.45 152.14,70.7 151.2,70.7 150.89,71 149.11,71 148.83,70.72 148.83,69.53 149.14,69.22 149.43,69.22 v2(149.89,69.69) ; v4(227.93,77) 226.77,75.83 226.77,66.91 227.78,65.9 230.34,65.9 231.39,64.86 231.39,63.81 229.66,62.08 229.66,60.87 v4(230.32,60.21)
  BOTTOM w0.086: UC1.AD11 150.15,69.43 v2(149.89,69.69)
ISH_I2C2_SDA_R: length 4
  TOP w0.076: 231.56,78.4 JNGFF2.42
  TOP w0.086: RZ77.2 229.95,76.79 v1(230.58,77.43) 231.56,78.4
ISH_UART0_CTS#: length 110.4
  GND1 w0.086: v4(240.05,40.73) 239.7,40.38 v3(239.41,40.38)
  IN2 w0.061: v4(240.05,40.73) 239.68,40.73 238.98,41.43 231.36,41.43 230.49,40.56 223.19,40.56 222.31,41.43 220.72,41.43 220.64,41.52 211.69,41.52 210.66,42.54 191.27,42.54 190.54,41.82 189.91,41.82 188.97,42.76 187.44,42.76 187.33,42.76 185.5,44.59 180.56,44.59 178.7,46.45 178.7,49.69 171.85,56.54 171.85,60.37 170.86,61.37 170.86,62.33 170.32,62.87 166.29,62.87 165.19,63.97 165.19,67.65 163.92,68.92 163.92,71.54 162.43,73.03 161.1,73.03 160.97,72.9 158.07,72.9 v2(157.39,72.22)
  BOTTOM w0.076: UC1.U4 154.45,72.24 155.37,72.24 155.49,72.12 155.86,72.12 155.87,72.12 156.39,71.97 157.14,71.97 v2(157.39,72.22)
ISH_UART0_CTS#_R: length 3.2
  TOP w0.076: JNGFF1.62 242.06,40.9
  TOP w0.086: RZ80.2 241.15,40.38 v1(241.24,40.47) 241.67,40.9 242.06,40.9
ISH_UART0_RTS#: length 106.9
  TOP w0.086: RZ81.1 239.41,39.26 v3(238.99,38.85)
  GND1 w0.086: v4(238.5,38.62) 238.73,38.85 v3(238.99,38.85)
  IN2 w0.061: v2(159.2,72.25) 159.58,71.87 160.06,71.87 160.15,71.78 161.17,71.78 162.91,70.04 162.91,69.15 164.71,67.35 164.71,63.91 166.13,62.49 168.54,62.49 171.41,59.62 171.41,55.42 178.32,48.5 178.32,46.3 180.4,44.22 185.34,44.22 187.17,42.38 188.82,42.38 189.76,41.44 190.69,41.44 191.42,42.17 210.48,42.17 212.26,40.39 216.4,40.39 217.15,41.14 220.48,41.14 220.57,41.06 222.06,41.06 223.02,40.1 237.02,40.1 v4(238.5,38.62)
  BOTTOM w0.076: UC1.U3 155.1,72.78 156.71,72.78 156.86,72.93 158.51,72.93 v2(159.2,72.25)
ISH_UART0_RTS#_R: length 2.8
  TOP w0.086: RZ81.2 240.67,39.43 240.95,39.15 v1(241.24,39.15) 241.28,39.15 JNGFF1.64
ISH_UART0_RXD: length 108.4
  TOP w0.086: v3(238.33,41.14) 239.41,42.22 RZ78.1
  GND1 w0.086: v3(238.33,41.14) v4(238.33,40.5)
  IN2 w0.061: v2(158.6,72.24) 159.2,71.64 159.97,71.64 160.16,71.44 160.16,70.55 161.43,69.28 162.46,69.28 164.49,67.26 164.49,63.87 166.05,62.31 168.41,62.31 171.18,59.53 171.18,55.37 178.14,48.42 178.14,46.22 180.33,44.03 185.26,44.03 187.1,42.19 188.74,42.19 189.68,41.25 190.77,41.25 191.5,41.98 210.41,41.98 212.18,40.21 216.48,40.21 217.23,40.95 220.4,40.95 220.49,40.87 221.93,40.87 222.92,39.87 233.69,39.87 235.3,38.26 237.38,38.26 v4(237.65,38.53)
  IN3 w0.097: v4(238.33,40.5) 237.83,40.5 237.51,40.18 237.51,38.67 v4(237.65,38.53)
  BOTTOM w0.076: v2(158.6,72.24) 158.08,72.75 157.04,72.75 156.79,72.51 UC1.U1
ISH_UART0_RXD_R: length 3.2
  TOP w0.076: 241.93,41.9 JNGFF1.58
  TOP w0.086: 241.93,41.9 241.29,41.9 v1(241.25,41.87) 240.74,41.87 RZ78.2
ISH_UART0_TXD: length 109.2
  GND1 w0.086: v3(239.41,41.33) 240.02,41.33 v4(240.05,41.36)
  IN2 w0.061: v4(240.05,41.36) 240.45,40.96 240.45,40.56 240.22,40.32 239.77,40.32 238.88,41.21 231.46,41.21 230.59,40.33 223.09,40.33 222.18,41.24 220.65,41.24 220.56,41.33 211.77,41.33 211.61,41.33 210.58,42.36 191.34,42.36 190.62,41.63 189.83,41.63 188.89,42.57 187.25,42.57 185.42,44.4 180.48,44.4 178.51,46.37 178.51,49.61 171.63,56.49 171.63,60.33 170.67,61.29 170.67,62.25 170.24,62.68 166.21,62.68 164.94,63.95 164.94,67.58 163.15,69.38 163.15,70.07 161.25,71.97 160.67,71.97 159.96,72.68 158.44,72.68 v2(157.99,72.23)
  BOTTOM w0.076: UC1.U2 155.71,72.29 155.89,72.29 155.91,72.28 156.12,72.22 156.76,72.22 157.11,72.58 157.64,72.58 v2(157.99,72.23)
ISH_UART0_TXD_R: length 4.4
  TOP w0.086: JNGFF1.60 242.46,41.33 RZ79.2 239.86,40.86 238.75,40.86 v1(238.45,40.56)
ISUMN_GT: length 44.2
  TOP w0.086: v1(78.17,72.02) 77.77,72.42 v2(77.77,72.6)
  TOP w0.203: v2(77.77,72.6) 77.68,72.69 PC642.2 ; PC642.2 PC646.2 PR656.2 ; PC642.2 77.7,73.28 PC645.1
  IN2 w0.203: v2(100.08,60.81) 100.08,62.2 99.24,63.04 89.76,63.04 88.41,64.39 86.2,64.39 85.43,63.61 82.88,63.61 81.46,65.03 78.31,65.03 78.11,65.24 78.11,71.24 77.61,71.73 77.61,72.45 v2(77.77,72.6)
  BOTTOM w0.203: PR640.2 PR644.2 77.92,72.75 v2(77.77,72.6)
  BOTTOM w0.254: PH605.2 100.08,62.56 v2(100.08,60.81) 100.08,59.19 100.88,58.39 PL612.2
ISUMN_IA: length 55.7
  TOP w0.203: 76.07,80.78 v2(76.57,81.29)
  TOP w0.254: v2(98.8,75.16) 99.38,75.74 PR666.2 ; PC641.1 76.07,81.18 75.81,81.44 PC638.1 75.17,81.42 74.36,81.42 74.35,81.41 74.32,81.43 PC624.2 74.5,81.64 v1(74.5,82.47) 74.02,82.96 PR632.1 73.48,82.86 73.48,82.21 73.43,82.16 73.43,82.11 PC626.2 PR633.2
  GND1 w0.203: v3(94.04,69.82) v4(94.04,69.34)
  IN3 w0.203: v4(94.04,69.34) 94.04,69.44 95.38,70.78 95.38,73.98 97.11,75.71 98.4,75.71 98.8,75.32 v2(98.8,75.16)
  IN4 w0.203: v4(94.04,69.34) 94.35,69.65 94.35,80.11 93.16,81.3 77.89,81.3 77.37,80.78 77.08,80.78 v2(76.57,81.29)
  BOTTOM w0.203: PR638.1 73.85,82.07 PC635.1 73.86,82.18 74.31,82.64 76.12,82.64 76.57,82.18 v2(76.57,81.29) ; PH602.2 98.8,73.17 v2(98.8,75.16)
ISUMN_VSA: length 51
  TOP w0.254: v2(94.14,52.17) 94.14,52.49 94.61,52.97 v1(96.97,52.97) 97.52,52.97 v2(97.63,52.85)
  IN1 w0.203: v2(97.63,52.85) 97.19,53.3 96.08,53.3 94.91,54.47 89.03,54.47 88.8,54.23 78.54,54.23 74.29,58.49 74.29,68.6 72.19,70.7 v2(71.67,70.7)
  BOTTOM w0.254: PC644.1 69.97,70.57 PR641.2 68.85,70.75 PR636.2 68.85,71.45 PC637.2 PC633.2 70.88,71.45 70.88,71.45 PR643.1 71.67,71.27 v2(71.67,70.7) ; PH604.2 97.92,53.14 v2(97.63,52.85) ; v2(94.14,52.17) 94.57,51.74 PL614.2
ISUMP_GT: length 39.5
  TOP w0.102: v2(77,72.6) 77,72.32 v1(76.6,71.92)
  TOP w0.203: PR653.2 75.47,74.63 76.07,74.63 v2(76.14,74.71) 76.32,74.71 76.69,75.08 PR656.1 ; v2(77,72.6) 77,73.06 PC642.1
  TOP w0.254: PC642.1 PC646.1 PR656.1 ; v2(99.01,62.19) PR661.2 99.97,62.87 PR657.1
  IN2 w0.203: v2(99.01,62.19) 98.49,62.71 89.57,62.71 88.22,64.05 86.34,64.05 85.56,63.28 82.74,63.28 81.32,64.7 78.16,64.7 77.78,65.09 77.78,71.1 77.28,71.59 77.28,72.32 v2(77,72.6)
  BOTTOM w0.203: v2(76.14,74.71) 75.72,75.13 PU602.19
ISUMP_IA: length 54.9
  TOP w0.086: v3(91.8,70.37) v1(90.07,70.37)
  TOP w0.203: PR658.2 73.31,80.06 v2(73.07,80.3) 73.02,80.35 73.02,80.5 72.59,80.93 72.59,81.14 PR633.1 PC626.1 73.41,80.69 73.57,80.52 PC624.1
  TOP w0.254: PR667.1 99.76,77.67 v3(99.6,77.51)
  GND1 w0.203: v3(99.6,77.51) 99.45,77.66 v4(99.07,77.66) ; v3(91.8,70.37) v4(91.8,69.69)
  IN3 w0.203: v4(99.07,77.66) 98.59,77.66 95.05,74.12 95.05,70.99 93.29,69.24 92.28,69.24 91.83,69.69 v4(91.8,69.69)
  IN4 w0.203: v4(91.8,69.69) 92.21,69.69 93.87,71.36 93.87,79.76 92.79,80.84 78.01,80.84 77.6,80.44 74.77,80.44 74.73,80.48 73.33,80.48 73.15,80.3 v2(73.07,80.3)
  BOTTOM w0.203: PU602.7 72.89,79.86 73.07,80.04 v2(73.07,80.3)
ISUMP_VSA: length 48.5
  TOP w0.086: v2(71.52,73.01) 71.43,73.01 v1(70.79,72.37)
  GND1 w0.254: v3(99.12,55.03) v4(98.63,55.03)
  IN1 w0.203: v2(71.52,73.01) 71.52,72.7 72.79,71.43 73.47,71.43 74.59,70.32 74.59,58.62 78.67,54.54 88.67,54.54 88.9,54.77 95.04,54.77 96.21,53.6 97.34,53.6 v4(97.77,54.03) 98.63,54.89 v4(98.63,55.03)
  GND5 w0.254: v5(98.25,54.03) v4(97.77,54.03)
  BOTTOM w0.203: PU602.27 71.69,73.56 71.62,73.49 71.62,73.11 v2(71.52,73.01) 71.52,72.38 PR643.2 70.88,72.36 70.88,72.36 PC633.1
  BOTTOM w0.254: PC637.1 PC633.1
ITP_PMODE: length 102.5
  TOP w0.086: v2(62.53,87.26) 62.57,87.3 62.57,87.42 62.97,87.82 JXDP1.46
  IN3 w0.061: v2(151.22,78.9) 150.87,79.24 150.27,79.24 147.18,82.33 140.94,82.33 139.66,81.06 137.85,81.06 137.7,81.22 132.49,81.22 132.04,80.76 127.6,80.76 126.04,82.32 119.94,82.32 119.47,82.79 118.25,82.79 117.71,82.24 112.1,82.24 110.45,83.89 105.68,83.89 104.46,82.67 78.33,82.67 76.49,84.51 69.32,84.51 67.39,82.58 v4(64.28,82.58)
  GND5 w0.086: v5(63.47,83.09) 63.47,83.09 63.55,83.17 63.97,83.17 64.28,82.86 v4(64.28,82.58)
  BOTTOM w0.086: v5(63.47,83.09) 63.41,83.09 63.29,83.22 v1(63.29,83.47) 63.29,83.58 63.16,83.71 62.85,83.71 62.35,84.22 62.35,86.37 63.17,87.19 63.17,87.63 RC115.1 62.98,87.64 62.6,87.26 v2(62.53,87.26) ; v2(151.22,78.9) 151.35,78.9 UC1.E8
JTAG_CLK: length 52.2
  TOP w0.086: v2(265.37,63.43) 265.37,63.39 UE1.C8
  IN3 w0.061: v2(265.37,63.43) 265.02,63.79 262.07,63.79 261.82,63.53 261.82,63.23 261.56,62.98 261.21,62.98 261,62.77 261,61.5 260.9,61.4 260.24,61.4 258.87,60.03 257.99,60.03 256.82,58.86 256.82,58.34 254.04,55.56 252.04,55.56 251.22,54.75 251.22,41.84 252.85,40.22 252.85,36.62 251.03,34.81 v2(250.18,34.81) 249.42,34.04 249.14,34.04 247.97,32.88 v4(247.97,32.82)
  GND5 w0.127: v5(247.71,31.58) 247.71,32.12 247.97,32.38 v4(247.97,32.82)
  BOTTOM w0.086: JDEG1.4 243.53,30.28 243.73,30.49 243.93,30.49 244.47,31.03 245.25,31.03 245.58,30.7 247.24,30.7 247.71,31.17 v5(247.71,31.58)
JTAG_RST#: length 16.1
  TOP w0.086: v2(273.94,64.9) v6(274.73,65.69) 275.35,66.3 CE30.1 RE65.1 RE63.1 278.83,66.3 JTAG1.1 ; v2(272.92,60.44) 272.92,59.7 272.64,59.42 270.65,59.42 270.29,59.78 269.02,59.78 UE1.G13
  IN4 w0.069: v2(273.94,64.9) 274.53,64.32 274.53,61.83 273.14,60.44 v2(272.92,60.44)
JTAG_TDI: length 50.5
  TOP w0.086: v2(266.18,60.97) 266.18,61.01 UE1.E9
  IN3 w0.061: v4(249.44,32.77) 250.46,32.77 251.41,33.72 251.91,33.72 253.77,35.58 253.77,40.75 252.64,41.89 252.64,45.05 252.04,45.65 252.04,48.53 252.85,49.34 252.85,49.91 253.03,50.08 253.03,53.6 254.02,54.59 255.97,54.59 256.48,55.1 257.14,55.1 257.9,55.86 257.9,57.69 259.25,59.04 260.8,59.04 261.03,59.27 261.03,59.75 261.16,59.88 261.78,59.88 262.17,60.27 263.05,60.27 263.31,60.54 265.75,60.54 v2(266.18,60.97)
  GND5 w0.127: v5(249.32,31.63) 249.34,31.66 249.34,32.68 v4(249.44,32.77)
  BOTTOM w0.086: v5(249.32,31.63) 249.27,31.58 RPE7.1 248.71,31.07 247.92,30.29 246.99,30.29 246.82,30.11 v1(246.59,30.11) 245.54,30.11 245.11,30.54 244.75,30.54 244.53,30.32 JDEG1.2
JTAG_TDO: length 48.4
  TOP w0.086: UE1.F6 v2(263.02,60.98)
  IN3 w0.061: v4(247.24,32.61) 247.47,32.38 248.72,32.38 249.03,32.69 249.03,32.94 249.42,33.33 250.75,33.33 251.33,33.91 251.84,33.91 253.55,35.63 253.55,40.71 252.45,41.81 252.45,44.97 251.85,45.57 251.85,53.41 252.5,54.05 253.21,54.05 253.94,54.78 255.68,54.78 256.81,55.91 256.81,57.11 259.12,59.42 259.58,59.42 260.26,60.1 261.69,60.1 262.12,60.54 262.57,60.54 v2(263.02,60.98)
  GND5 w0.127: v4(247.24,32.61) 247.24,32.58 247.06,32.39 247.06,31.73 v5(247.21,31.58)
  BOTTOM w0.086: JDEG1.5 243.03,30.19 243.6,30.77 243.92,30.77 244.43,31.28 245.29,31.28 245.53,31.04 v1(245.7,31.04) 246.31,31.04 246.85,31.58 v5(247.21,31.58)
JTAG_TMS: length 49.9
  TOP w0.086: UE1.C5 v2(262.22,63.38)
  IN3 w0.061: v4(248.56,32.78) 248.56,32.78 249.33,33.55 250.71,33.55 251.25,34.1 251.76,34.1 253.33,35.67 253.33,40.67 252.26,41.73 252.26,44.89 251.67,45.49 251.67,54.56 252.22,55.12 255.75,55.12 256.62,55.99 256.62,57.46 257.26,58.1 257.26,58.68 258.28,59.7 259.54,59.7 260.17,60.32 261.59,60.32 261.84,60.57 261.84,62.82 262.22,63.2 v2(262.22,63.38)
  GND5 w0.127: v5(248.21,31.58) 248.38,31.75 248.38,32.08 248.56,32.25 v4(248.56,32.78)
  BOTTOM w0.086: v5(248.21,31.58) 248.21,31.08 247.62,30.49 245.45,30.49 245.17,30.77 244.63,30.77 244.03,30.16 JDEG1.3
KB_DET#: length 87
  TOP w0.086: RC288.1 165.88,87.26 v2(165.88,86.83) 164.89,85.84 v1(163.12,85.84) 161.72,85.84 160.04,84.16 154.65,84.16 v2(154.17,83.68)
  IN2 w0.061: v4(183.92,49.67) 183.23,49.67 182.71,50.2 182.71,50.48 182.71,50.9 178.3,55.31 178.3,58.45 175.97,60.78 175.97,66.12 175.86,66.23 175.86,73.19 173.09,75.95 173.09,77.25 170.71,79.64 170.71,82.41 168.32,84.79 167.32,84.79 165.88,86.24 v2(165.88,86.83)
  GND5 w0.086: v5(183.79,49.06) 183.92,49.19 v4(183.92,49.67) ; v5(181.78,36.2) 181.59,36.42 v5(181.1,36.91)
  BOTTOM w0.086: v2(154.17,83.68) 153.11,82.62 152.89,82.62 152.19,81.92 152.19,80.68 152.34,80.53 152.34,80.22 152.05,79.93 UC1.D8 ; JKBTP1.1 182.25,35.73 v5(181.78,36.2) ; v5(183.79,49.06) 183.53,48.8 181.28,48.8 177.36,44.88 177.36,43.27 178.45,42.17 178.45,41.26 177.59,40.4 177.59,39.45 177.89,39.15 179.64,39.15 181.1,37.69 v5(181.1,36.91)
LAN_WAKE#: length 155.8
  TOP w0.086: v2(256.23,53.32) 256.5,53.59 257.14,53.59 257.9,54.35 257.9,54.36 v1(257.93,54.39) 257.94,54.39 258.93,55.38 259.41,55.38 259.76,55.73 259.76,55.83 260.17,56.24 260.62,56.24 UE1.L3
  GND1 w0.086: v3(156.13,48.73) 156.34,48.73 156.62,49.01 v4(157.07,49.01)
  IN1 w0.051: v2(148.44,64.63) 147.99,64.18 147.99,63.36 148.53,62.82 149.27,62.82 149.8,62.3 149.8,61.55 156.02,55.33 156.02,50.62 156.57,50.07 156.57,49.5 v4(157.07,49.01) 157.07,48.94 157.51,48.5 158.83,48.5 161.27,46.06 161.27,44.5 162.96,42.81 163.3,42.81 165.08,41.03 171.97,41.03 173.27,39.73 177.13,39.73 177.73,39.12 178.28,39.12 179.48,37.93 183.44,37.93 185.56,35.81 200.03,35.81 200.57,35.27 205.75,35.27 205.95,35.47 217.9,35.47 218.64,36.2 223.34,36.2 227.27,40.12 228.27,40.12 229.33,41.18 v4(229.33,41.46)
  IN2 w0.061: v4(248.58,62.72) 248.58,62.37 247.69,61.48 244.53,61.48 243.92,60.87 241.06,60.87 237.91,57.72 237.91,55 237.3,54.39 237.3,51.73 232.71,47.13 232.71,44.84 v4(229.33,41.46)
  GND5 w0.127: v4(248.58,62.72) 248.61,62.7 v5(248.61,62.21)
  BOTTOM w0.086: v2(148.44,64.63) 147.99,65.04 UC1.AM15 ; v5(248.61,62.21) 248.61,62 250.55,60.05 252.04,60.05 254.19,57.91 254.19,55.3 256.16,53.32 v2(256.23,53.32)
LCD_CBL_DET#: length 81.2
  TOP w0.086: RC287.1 173.53,39.89 v3(174.08,40.45) v1(173.56,40.45)
  GND1 w0.086: v3(174.08,40.45) 174.16,40.37 174.74,40.37 v4(174.97,40.14)
  IN2 w0.061: v4(208.68,38.59) 208.68,38.59 208.53,38.59 207.4,39.72 195.97,39.72 194.05,37.8 190.74,37.8 190.54,37.6 186.88,37.6 186.76,37.72 178.89,37.72 178.31,38.3 177.16,38.3 175.32,40.14 v4(174.97,40.14) 174.68,40.14 169.74,45.08 167.78,45.08 165.78,47.09 165.78,49.13 162.87,52.04 161.86,52.04 160.09,53.81 160.09,54.82 154.52,60.38 154.52,62.94 153.43,64.03 153.43,66.86 153.97,67.4 153.97,68 154.24,68.28 v4(154.24,68.64)
  GND5 w0.086: v4(208.68,38.59) 208.68,39.34 v5(208.58,39.44) ; v4(154.24,68.64) 154.51,68.91 v5(154.51,69.19)
  BOTTOM w0.117: JEDP1.40 208.75,39.27 v5(208.58,39.44)
LCD_TST: length 78.9
  TOP w0.086: UE1.M2 260.09,55.81 259.76,55.48 259.76,54.61 259.38,54.24 258.23,54.24 257.38,53.38 256.89,53.38 256.43,52.92 255.81,52.92 v1(255.64,53.08) 255.55,53.17 v2(254.98,53.17)
  GND1 w0.086: v3(252.9,63.97) 253.64,63.97 v4(253.66,63.99)
  IN2 w0.061: v2(254.98,53.17) 254.26,53.89 254.26,58.25 253.28,59.23 253.28,61.58 253.51,61.81 253.51,62.66 253.24,62.92 253.24,63.57 v4(253.66,63.99) 254.65,63.99 254.74,64.08 254.74,65.48 253.99,66.23 252.19,66.23 251.71,66.7 247.33,66.7 245.89,65.26 245.89,64.79 243.63,62.53 241.14,62.53 237.64,59.03 237.64,58.98 236.83,58.17 236.83,55.45 236.22,54.84 236.22,51.77 231.31,46.85 230.58,46.85 226.79,43.06 226.79,41.69 226.33,41.23 223.09,41.23 222.52,41.81 220.88,41.81 v4(220.26,42.42)
  GND5 w0.086: v4(220.26,42.42) 220.26,42.42 220.26,42.43 220.03,42.2 v5(220.03,41.94)
  BOTTOM w0.086: v5(220.03,41.94) 220.03,41.77 219.6,41.33 218.23,41.33 216.75,39.86 JEDP1.24
LCD_VCC_TEST_EN: length 67.1
  TOP w0.086: DV3.2 235.84,29.42 v1(237.15,28.11) 237.15,27.44 v2(237.15,27.44) ; UE1.E1 v2(259.02,61.78)
  IN4 w0.051: v2(237.15,27.44) 237.54,27.05 242.04,27.05 242.57,27.59 254.24,27.59 254.8,28.15 255.87,28.15 256.96,29.24 256.96,40.37 259.64,43.05 259.64,46.43 260.14,46.92 260.14,47.3 260.24,47.41 260.24,52.82 258.59,54.47 258.59,54.77 259.66,55.84 262.42,55.84 262.65,56.07 262.65,56.4 262.88,56.63 263.24,56.63 263.42,56.8 263.42,57.24 263.62,57.44 263.99,57.44 264.24,57.69 264.24,59.84 263.92,60.16 263.06,60.16 262.9,60.32 260.48,60.32 v2(259.02,61.78)
LED_MASK#: length 11.8
  TOP w0.086: UE1.A12 268.19,64.83 268.47,65.11 268.6,65.11 v2(268.65,65.16) ; RE21.1 265.02,73.84 v2(265.09,73.77)
  IN1 w0.051: v2(268.65,65.16) 268.37,65.44 268.37,66.59 267.25,67.71 267.25,70.77 265.07,72.96 265.07,73.74 v2(265.09,73.77)
LG1_ISL9538: length 12.3
  IN3 w1.016: 51.39,39.92 51.36,39.95 51.36,41.06 52.43,42.12 52.43,47.7
  IN4 w1.016: 46.97,49.59 49.94,49.59
  GND5 w0.086: v4(45.79,49.4) 45.75,49.36 v5(45.27,49.36) ; v5(45.27,49.77) 45.52,49.77 v4(45.74,49.98)
  vias: v1(45.72,49.54) v2(52.3,39.13) v2(52.8,38.65) v4(50.91,49.27) v4(50.91,48.69)
LG2_ISL9538: length 14
  TOP w0.086: v2(65.28,49.73) v1(64.76,49.73)
  IN3 w1.016: 65.77,48.15 65.77,45.98 63.54,43.76 62.76,43.76 61.94,42.95 57.62,42.95 56.27,41.59
  vias: v2(53.31,39.68) v2(53.76,39.28) v2(65.28,49.15)
LID_CL#: length 280.2
  TOP w0.086: v2(121.35,94.45) 121.23,94.57 115.44,94.57 114.87,94 108,94 v6(107.41,93.41) UZ1.3 ; RZ514.1 271.77,84.03 269.18,81.44 v2(267.81,81.44) ; v2(249.12,78.57) 248.52,77.97 247.51,77.97 246.28,79.2 DZ104.1 ; v2(270.45,47.51) 270.18,47.51 269.75,47.94 268.94,47.94 267.55,49.33 RE26.1
  IN2 w0.061: v4(168.22,90.36) 168.62,90.76 169.11,90.76 173.03,86.84 173.03,86.41 175.74,83.7 175.74,79.66 177.39,78.01 177.39,66.69 177.48,66.6 177.48,65.12 178.18,64.41 178.18,60.52 179.68,59.02 179.68,55.89 185.18,50.38 186.82,50.38 188.28,48.92 190.11,48.92 191.96,47.07 200.43,47.07 200.43,47.07 201.11,47.07 201.11,47.07 201.16,47.07 202.14,46.09 208.76,46.09 209.48,46.81 212.09,46.81 213.02,47.75 213.19,47.75 216.03,47.75 216.68,47.1 216.68,46.47 216.99,46.15 219.02,46.15 222.33,49.46 222.99,49.46 226.71,53.18 226.71,59.51 228.28,61.09 229.1,61.09 229.33,61.32 229.33,61.79 233.49,65.94 236.32,65.94 238.04,67.66 241.07,67.66 242.77,69.36 242.77,70.69 245.15,73.07 245.15,75.38 246.67,76.9 247.44,76.9 v2(249.12,78.57) 250.64,77.05 252.97,77.05 255.25,74.77 258.68,74.77 259.58,73.87 262.88,73.87 v4(263.47,74.46) 263.47,76.39 267.81,80.73 v2(267.81,81.44)
  IN3 w0.061: v4(168.22,90.36) 167.4,91.17 155.31,91.17 154.45,90.31 148.58,90.31 143.87,95.02 121.93,95.02 v2(121.35,94.45)
  IN4 w0.051: v4(263.47,74.46) 263.47,74.29 267.97,69.79 268.95,69.79 272.09,66.66 272.09,61.92 271.71,61.54 271.71,60.61 273.55,58.77 273.55,58.24 276.04,55.74 276.04,51.42 275.79,51.18 274.6,51.18 270.93,47.51 v2(270.45,47.51)
LID_CL#_NB_C: length 157.8
  TOP w0.086: v2(248.51,78.57) 248.51,78.85 248.79,79.13 249.37,79.13 249.6,79.36 RC504.2 v1(250.54,79.59)
  IN3 w0.061: v4(152.06,61.05) 152.47,60.64 154.65,60.64 156.3,58.99 161.82,58.99 164.01,61.17 169.09,61.17 170.98,59.27 170.98,55.66 175.3,51.34 176.08,51.34 177.77,49.65 177.77,46.9 181.17,43.49 184.76,43.49 187.28,40.96 190.49,40.96 191.28,40.17 216.96,40.17 217.73,40.94 222.16,40.94 223.54,42.32 225.29,42.32 229.49,46.52 230.52,46.52 233.02,49.02 233.02,53.63 235.3,55.92 235.47,55.92 239.77,60.22 250.03,60.22 250.32,59.93 251.72,59.93 252.24,60.44 252.24,62.44 v4(252.54,62.75)
  GND5 w0.086: v5(152.38,60.65) 152.06,60.97 v4(152.06,61.05) ; v5(252.65,63.28) 252.54,63.18 v4(252.54,62.75)
  BOTTOM w0.086: v5(252.65,63.28) 251.51,64.42 251.51,64.84 251.3,65.04 250.15,65.04 243.7,71.49 243.7,79.14 244.33,79.77 246.34,79.77 247.54,78.57 v2(248.51,78.57)
LID_CL#_NB_D: length 3.4
  TOP w0.086: v1(246.99,78.95) 247.78,79.74 DZ104.2 248.16,80.48 RZ512.1 RC504.1
LID_CL#_TAB_C: length 165.5
  TOP w0.086: v2(250.35,81.2) 250.11,81.44 RC505.2
  IN3 w0.061: v4(252.96,62.29) 252.42,61.75 252.42,60.37 251.46,59.4 248.45,59.4 248.12,59.72 239.91,59.72 236.57,56.39 236.57,55.22 236.03,54.68 236.03,51.5 230.68,46.15 230.36,46.15 224.72,40.5 217.82,40.5 217.04,39.72 191.19,39.72 190.33,40.59 187.13,40.59 185.79,41.92 183.9,41.92 183.86,41.88 182.21,41.88 181.83,42.26 179.74,42.26 179.21,42.78 179.21,42.94 179.21,43.95 176.72,46.44 176.72,49.27 175.66,50.33 174.88,50.33 171.37,53.85 167.6,53.85 166.14,52.39 165.41,52.39 163.32,54.48 160.22,54.48 154.9,59.8 152.75,59.8 151.6,60.95 151.6,63.99 151.35,64.25 150.82,64.25 150.66,64.09 150.66,63.29 150.35,62.98 149.21,62.98 148.9,63.29 148.9,63.62 v4(148.48,64.04)
  GND5 w0.086: v5(148.9,63.76) 148.62,64.04 v4(148.48,64.04) ; v5(253.1,62.8) 252.96,62.66 v4(252.96,62.29)
  BOTTOM w0.086: v5(253.1,62.8) v1(252.6,62.8) 251.93,63.46 251.93,63.56 251.3,64.2 250.66,64.2 243.46,71.4 243.46,79.24 244.25,80.04 249.4,80.04 250.35,80.98 v2(250.35,81.2)
LID_CL#_TAB_D: length 34.7
  TOP w0.102: v2(270.53,82.05) 270.51,82.05 v1(269.71,81.25)
  TOP w0.508: RC505.1 248.2,81.44 DZ105.2 247.36,81.37 v2(247.36,80.96) ; RZ513.1 276.52,83.78 275.73,82.99 271.47,82.99 v2(270.53,82.05)
  IN4 w0.508: v2(247.36,80.96) 247.55,80.96 249.7,83.1 268.13,83.1 269.18,82.05 v2(270.53,82.05)
LID_CL_SIO#: length 6
  TOP w0.086: CE8.1 RE26.2 267.5,50.47 RE25.2 268.04,52.41 268.04,53.57 267.39,54.22 UE1.N11
LID_CL_SIO_TAB#: length 288.9
  TOP w0.086: UE1.E12 268.56,61.78 269.13,61.78 269.28,61.63 271.04,61.63 RE5.1 271.24,61.38 271.82,60.79 v3(271.87,60.79) ; v2(253.43,75.19) 252.6,75.19 251.63,76.16 251.63,77.52 251.39,77.76 247.38,77.76 245.31,79.84 v1(245.31,80.04) 245.31,80.37 246.32,81.39 DZ105.1 246.92,82.42 248.59,82.42 RZ515.1
  GND1 w0.117: v4(272.13,61.22) 272.13,61.17 271.87,60.92 v3(271.87,60.79)
  IN3 w0.061: v2(83.99,91.32) 83.99,91.04 84.39,90.64 86.17,90.64 87.87,88.94 102.64,88.94 104.39,90.69 105.56,90.69 106.76,91.88 108.24,91.88 108.84,91.28 115.38,91.28 115.68,91.58 122.42,91.58 124.78,93.94 128.97,93.94 129.49,93.94 130.3,93.13 130.3,92.43 133.21,89.52 136.32,89.52 137.53,90.73 137.53,93.35 138.45,94.27 143.82,94.27 148.34,89.74 156.28,89.74 156.36,89.82 163.14,89.82 163.99,88.97 172.43,88.97 175.3,86.1 175.3,86.09 176.59,84.8 176.6,84.8 177.23,84.16 177.23,82.23 176.93,81.93 176.93,80.46 177.45,79.94 177.45,79.1 177.3,78.95 177.3,67.38 177.3,65.25 178.22,64.34 178.22,60.58 180.55,58.25 180.55,56.14 185.74,50.95 188.92,50.95 190.21,49.66 190.44,49.66 192.74,47.36 200.89,47.36 201.76,46.49 201.94,46.49 201.94,46.49 202.02,46.49 208.79,46.49 210.64,48.33 212.41,48.33 214.88,50.8 217.72,50.8 218.11,50.41 221.67,50.41 225.11,53.85 225.11,60.37 224.75,60.73 224.75,64.05 226.61,65.91 227.02,65.91 232.47,65.91 232.89,65.49 236.9,65.49 237.23,65.15 239.59,65.15 240.91,66.48 240.91,66.79 243.08,68.95 243.08,69.81 244.14,70.87 247.16,70.87 247.59,70.44 249.8,70.44 252.18,72.82 252.18,73.38 253.46,74.66 253.46,75.17 v2(253.43,75.19)
  IN4 w0.051: v2(253.43,75.19) 253.46,75.22 263.35,75.22 264,74.57 264,74 268.04,69.96 269.02,69.96 272.26,66.73 272.26,65.75 272.29,65.71 272.29,61.61 272.15,61.48 272.15,61.25 v4(272.13,61.22)
  BOTTOM w0.086: v2(83.99,91.32) 83.99,91.66 83.86,91.78 82.34,91.78 82.23,91.68 80.58,91.68 UZ28.3
LINE1_L: length 3.5
  TOP w0.381: 270.96,36.47 271.25,36.76 v1(271.25,37.8) 271.25,38.3 272.06,39.11 CA43.1
LINE1_R: length 2.6
  TOP w0.381: CA44.1 272.13,37.77 271.75,37.39 271.75,36.33 v1(271.33,35.92)
LOM_CABLE_DETECT#: length 6
  TOP w0.086: UE1.D2 259.82,62.58 259.21,62.58 258.53,63.27 258.37,63.27 v1(258.02,63.62) 257.81,63.83 256.6,63.83 256.32,64.12 255.34,64.12 RE505.1
LPSA_PROTECT#: length 2.1
  TOP w0.086: PT1.1 38.31,84.6 38.17,84.74 38.17,85.94 PR1230.2
LPSB_PROTECT#: length 13
  BOTTOM w0.086: PT2.1 39.68,40.32 43.26,40.32 44.61,38.98 44.61,33.7 PR1266.2
LPSS_UART2_RXD: length 5
  TOP w0.086: RC330.1 160.19,67.01 RC402.1 158.99,68.21 v2(158.99,68.61)
  BOTTOM w0.086: UC1.AD1 156.34,68.53 156.43,68.61 v2(158.99,68.61)
LPSS_UART2_TXD: length 12
  TOP w0.086: RC331.1 159.61,68.42 v2(159.61,68.61)
  BOTTOM w0.086: UC1.AD2 155.61,68.53 155.93,68.85 158.47,68.85 158.69,69.07 159.25,69.07 159.61,68.71 v2(159.61,68.61) 161.76,68.61 v1(162.18,68.2) 163.42,66.95 163.42,66.42 RC403.1
LX1_ISL9538: length 22.8
  IN1 w1.016: 50.94,39.87 50.94,40.89 53.64,43.58 53.64,51.53 54.4,52.29 ; 46.68,57.86 47.53,57.86 48.11,58.44 52.14,58.44 53.64,56.94 53.64,55.79
  vias: v1(54.08,53.3) v2(46.03,57.22) v2(46.61,57.22) v2(51.1,38.57) v2(51.1,37.93) v2(54.3,53.86) v2(54.77,53.46)
LX2_ISL9538: length 21.2
  TOP w0.086: v2(67.51,54.25) v1(68.06,54.25)
  IN1 w1.016: 66.82,55.28 65.31,55.28 64.67,54.64 64.67,54.22 62.05,51.6 62.05,48.3 v4(61.84,48.09) v4(61.21,47.46) 54.97,41.22 54.16,41.22
  vias: v2(52.52,40.6) v2(52.95,40.19) v2(64.67,47.88) v2(64.67,47.24) v2(66.91,54.27) v5(60.62,48.14) v5(61.22,48.14)
LX_1.8VALW: length 1.7
  TOP w0.117: v1(214.66,25.89) 214.1,26.45 214.1,27.39
LX_1V_PRIM: length 1.3
  BOTTOM w0.086: PR409.1 161.96,26.72 v1(161.92,26.68)
LX_3V: length 4.3
  BOTTOM w0.086: v6(70.52,42.02) 71.49,41.04 71.54,41.04
  BOTTOM w0.203: PU100.6 73.18,45.28 73.3,45.17 73.3,43.37 73.42,43.24 73.42,42.99
  vias: v2(71.59,41.59) v2(72.18,41.59) v2(72.76,41.59)
LX_5V: length 6
  TOP w0.086: PC114.2 52.81,67.52 53,67.33 v1(53.59,67.33)
  TOP w0.508: v2(51.86,66.63) 51.86,67.08 PC114.2 ; PR112.1 v2(51.22,64.98)
  BOTTOM w0.254: 51.41,70.04 51.41,72.14 51.34,72.22 PU102.6
LX_DDR: length 1.3
  TOP w0.117: v1(81.89,34.76) PC205.2
  vias: v2(84.24,37.04) v2(84.88,37.04)
M2_DEVSLP: length 238.9
  TOP w0.076: JNGFF3.38 25.1,12.62
  TOP w0.086: v2(142.08,27.61) 142.47,27.21 145.68,27.21 147.82,29.35 151.14,29.35 154.43,32.64 156.06,32.64 163.07,39.66 163.07,41.55 160.25,44.38 160.25,47.45 162.53,49.73 162.53,52.97 162.42,53.08 162.42,54.03 162.58,54.19 162.58,59.93 162.58,60.63 164.7,62.76 167.1,62.76 167.88,63.54 167.88,67.48 168.89,68.49 168.89,75.1 v2(169.18,75.4) ; v3(23.87,23.92) 23.87,22.82 23.72,22.67 v6(23.72,21.55) 23.72,15.12 RN37.2 24.55,14 25.1,13.46 25.1,12.62
  GND1 w0.086: v3(23.87,23.92) v4(23.87,23.41)
  IN3 w0.061: v2(142.08,27.61) 140.6,29.08 116.5,29.08 115.63,28.21 112.13,28.21 109.23,31.12 94.96,31.12 93.91,32.16 91.65,32.16 88.54,35.28 88.54,37.67 87.05,39.16 87.05,40.87 84.84,43.08 73.89,43.08 73.34,43.63 71.09,43.63 68.57,41.11 68.57,36.78 67,35.21 63.8,32.01 58.83,32.01 58.28,31.46 51.87,31.46 50.88,32.44 37.57,32.44 34.7,29.57 29.68,29.57 28.53,28.42 28.53,25.84 27.5,24.81 26.76,24.81 25.99,24.04 24.49,24.04 v4(23.87,23.41)
  BOTTOM w0.086: UC1.J3 155.11,76.21 156.27,76.21 156.58,76.51 157.98,76.51 158.21,76.29 161.51,76.29 162.22,77 164.76,77 166.36,75.4 v2(169.18,75.4)
M2280_PCIE_SATA#: length 249.1
  TOP w0.086: v2(134.01,27.39) 134.92,26.48 145.85,26.48 148.08,28.71 151.63,28.71 v6(152.86,29.94) 154.83,31.91 156.23,31.91 163.71,39.39 163.71,41.82 160.89,44.64 160.89,46.35 163.63,49.09 163.63,53.07 163.27,53.43 163.27,53.68 163.43,53.84 163.43,60.28 165.05,61.9 167.47,61.9 169.35,63.78 169.35,67.18 170.07,67.9 170.07,74.19 173.25,77.36 173.25,82.01 171.47,83.79 171.47,84.93 170.1,86.3 v2(170.1,86.95) 170.11,86.97 RPC4.1
  IN3 w0.061: v4(18.27,13.23) 18.27,17.23 23.83,22.79 24.54,22.79 25.54,23.8 26.05,23.8 26.86,24.61 27.56,24.61 28.72,25.76 28.72,28.34 29.76,29.39 34.83,29.39 37.63,32.19 50.82,32.19 51.74,31.27 58.41,31.27 58.92,31.78 63.85,31.78 65.68,33.62 69.75,33.62 71.85,31.52 79.98,31.52 80.38,31.92 86.54,31.92 87.08,31.39 87.4,31.39 87.74,31.72 88.46,31.72 88.73,31.99 89.05,31.99 89.32,31.72 91.83,31.72 92.62,30.93 109.15,30.93 112.06,28.03 115.71,28.03 116.58,28.89 132.51,28.89 v2(134.01,27.39)
  GND5 w0.086: v5(18.8,13.23) v4(18.27,13.23)
  BOTTOM w0.076: 156.61,80.27 156.35,80.02 155.82,80.02 155.74,79.94 155.74,79.71 155.19,79.16 155.19,78.9 154.18,77.9 UC1.G4
  BOTTOM w0.086: v5(18.8,13.23) 17.54,13.23 17.35,13.42 JNGFF3.69 ; v2(170.1,86.95) 169.95,87.1 169.7,87.1 169.7,87.1 169.25,87.1 168.56,87.1 168.54,87.08 168.04,87.08 167.17,86.22 164.84,86.22 159.73,81.11 157.45,81.11 156.61,80.27
M3042_DEVSLP: length 129.1
  IN2 w0.061: JNGFF2.38 231.43,79.4 230.53,78.5 230.53,70.35 229.7,69.52 229.7,69.36 229.7,66.77 230.36,66.11 230.36,64.68 v2(230.35,64.68) ; v2(222.79,48.07) 222.67,48.07 219.54,44.93 216.3,44.93 215.41,44.05 212.46,44.05 211.61,44.9 201.59,44.9 200.92,45.57 190.52,45.57 190.06,45.11 188.16,45.11 185.48,47.79 183.08,47.79 182.78,48.09 182.06,48.09 180.98,49.17 180.98,50.94 177.08,54.84 177.08,57.98 174.78,60.28 174.78,65.52 167.93,72.37 165.39,72.37 163.75,74.02 162.99,74.02 161.08,75.93 v4(159.81,75.93)
  GND5 w0.086: v5(159.63,76.62) 159.63,76.11 v4(159.81,75.93)
  BOTTOM w0.076: 158.23,76.69 157.13,76.69 156.82,76.76 156.69,76.76 156.55,76.7 156.42,76.7 156.19,76.76 156.19,76.76 156.06,76.76 155.84,76.69 UC1.J2
  BOTTOM w0.086: v2(230.35,64.68) 229.77,65.26 226.46,65.26 226,64.8 226,52.72 223.28,50 223.28,48.56 v2(222.79,48.07) ; v5(159.63,76.62) 158.31,76.62 158.23,76.69
M3042_PCIE#_SATA: length 192.3
  TOP w0.086: RC551.1 168.83,86.95 v2(169.21,86.57) ; UE1.J12 268.22,58.21 268.65,58.63 269.59,58.63 v2(270.71,57.51)
  IN2 w0.061: v4(255.99,72.19) 255.48,72.69 254.51,72.69 253.65,71.83 249.29,71.83 247.86,70.4 244.15,70.4 243.37,69.63 243.37,69.11 242.71,68.44 242.71,67.1 241.74,66.13 240.56,66.13 239.87,65.44 238.12,65.44 236.57,63.88 234.83,63.88 232.4,61.45 232.4,60.58 230.83,59 230.83,58.86 229.71,57.74 228.4,57.74 227.53,56.87 227.53,52.76 227.28,52.51 227.28,51.11 226.33,50.16 224.94,50.16 223.41,48.63 222.66,48.63 219.34,45.32 216.08,45.32 215.79,45.6 212.72,45.6 212.39,45.27 201.75,45.27 200.77,46.25 191.47,46.25 189.62,48.1 187.94,48.1 186.6,49.45 184.96,49.45 178.86,55.55 178.86,58.69 177.37,60.18 177.37,64.05 176.66,64.76 176.66,66.26 176.53,66.39 176.53,77.41 173.79,80.16 173.79,82 171.39,84.4 171.39,84.81 170.39,85.81 169.97,85.81 v2(169.21,86.57)
  IN4 w0.051: v2(270.71,57.51) 270.55,57.51 269.47,58.6 269.47,60.8 271.07,62.4 271.07,66.47 268.6,68.94 267.62,68.94 264.01,72.55 259.96,72.55 258.82,71.41 256.77,71.41 v4(255.99,72.19)
  BOTTOM w0.076: 157.17,78.24 156.47,77.54 156.44,77.53 156.12,77.53 155.91,77.58 155.89,77.59 155.7,77.59 155.57,77.54 155.2,77.54 154.65,77.23 UC1.H3
  BOTTOM w0.086: v2(169.21,86.57) 168.68,86.05 168.68,84.26 168.18,83.75 165.59,83.75 v1(164.18,82.34) 163.79,81.95 163.79,81.67 160.36,78.24 157.17,78.24 ; RC552.1 272.25,60.36 270.71,58.81 v2(270.71,57.51)
MASK_SATA_LED#: length 57.3
  TOP w0.086: QZ2.5 254.28,88.11 253.89,88.5 253.89,89.06 253.28,89.67 250.36,89.67 249.04,88.35 v1(249.04,88.04) 251.49,85.59 251.49,84.07 250.88,83.46 250.88,79.45 v2(249.98,78.55) ; UE1.L6 263.35,56.61 263.06,56.32 v2(263.06,56.24)
  BOTTOM w0.086: v2(249.98,78.55) 249.98,77.35 249.75,77.12 245.97,77.12 245.23,76.39 245.23,72.91 244.51,72.19 244.51,71.33 250.37,65.47 251.48,65.47 253.23,63.72 255.18,63.72 255.7,63.21 255.7,61.98 258.67,59.01 262.4,59.01 262.6,58.81 262.6,56.7 v2(263.06,56.24)
ME_FWP: length 100.3
  TOP w0.086: UE1.G12 268.36,59.81 268.8,59.37 270.1,59.37 v2(270.15,59.32) ; v3(205.53,32.04) 205.53,32.38 v1(207.01,33.87) RC221.2 208.5,34.35 v2(208.27,34.58)
  GND1 w0.086: v4(206.16,31.33) 206.16,31.4 v3(205.53,32.04)
  IN4 w0.051: v4(252.27,38.08) 253.36,36.99 253.36,33.35 250.87,30.86 238.12,30.86 235.27,33.72 234.06,33.72 233.63,34.15 232.34,34.15 229.98,31.79 226.15,31.79 225.49,32.45 218.83,32.45 218.44,32.07 210.69,32.07 210.02,31.39 208.98,31.39 208.69,31.1 206.39,31.1 v4(206.16,31.33)
  GND5 w0.127: v5(252.32,38.56) 252.32,38.13 v4(252.27,38.08)
  BOTTOM w0.086: SW1.3 208.23,34.53 v2(208.27,34.58) ; v5(252.32,38.56) 252.35,38.6 252.35,41.98 253.81,43.44 258.56,43.44 262.58,47.46 268.12,47.46 270.38,49.72 270.38,56.04 270.12,56.3 270.12,59.29 v2(270.15,59.32)
ME_FWP_SW: length 71.7
  TOP w0.086: v2(208.96,34.6) 209.42,34.15 RC221.1 209.42,33.63 209.15,33.36 207.12,33.36 206.38,32.62 206.38,32.31 205.25,31.18 205.25,29.97 v1(204.87,29.59) 204.47,29.19 204.47,27.58 v2(204.41,27.52) ; v3(158.43,45.62) 158.54,45.73 RC223.1
  GND1 w0.086: v3(158.43,45.62) 158.63,45.41 v4(158.63,44.74)
  IN4 w0.051: v2(204.41,27.52) 203.31,26.42 194.11,26.42 193.42,27.11 188.35,27.11 187.97,26.73 187.75,26.51 179.85,26.51 179.44,26.92 178.06,26.92 177.54,27.44 175.85,27.44 174.09,29.2 170.62,29.2 169.4,30.43 169.4,31.41 168.98,31.82 168.45,31.82 165.61,34.66 164.22,34.66 162.3,36.58 162.3,42.1 161.52,42.88 161.52,42.89 160.98,43.43 159.75,43.43 158.63,44.54 v4(158.63,44.74)
  BOTTOM w0.086: v2(208.96,34.6) 209.06,34.6 SW1.2
ME_RESET#: length 2.4
  BOTTOM w0.086: UC12.2 175.9,77.6 176.02,77.72 RC227.1 RC225.1
ME_SUS_PWR_ACK: length 140.4
  TOP w0.086: UE1.B13 269.77,63.81 270.1,63.48 v2(270.55,63.48) ; RC74.1 RC444.1
  GND1 w0.086: v4(158.21,49.03) 157.83,49.03 v3(157.65,48.85)
  IN1 w0.051: v4(158.21,49.03) 158.73,49.03 161.57,46.19 161.57,44.69 163.07,43.19 164.27,43.19 166.08,41.37 172.88,41.37 173.49,40.76 176.34,40.76 177.8,39.3 178.47,39.3 179.65,38.12 183.49,38.12 184.91,36.7 187.23,36.7 187.97,35.96 200.12,35.96 200.64,35.44 205.7,35.44 205.88,35.62 217.8,35.62 218.55,36.37 221.08,36.37 223.42,38.71 225.16,38.71 226.88,40.43 228.04,40.43 228.83,41.22 228.83,41.63 v4(229.3,42.1)
  IN2 w0.061: v4(252.93,65.67) 252.32,65.67 252.04,65.39 250.44,65.39 247.74,62.7 245.43,62.7 243.82,61.09 240.97,61.09 237.72,57.84 237.72,55.12 237.08,54.48 237.08,51.77 232.4,47.09 232.4,45.19 v4(229.3,42.1)
  IN3 w0.061: v4(252.93,65.67) 253.33,65.26 254.73,65.26 254.86,65.39 261.43,65.39 261.76,65.71 265.12,65.71 266.16,64.68 268,64.68 268.81,63.86 270.17,63.86 v2(270.55,63.48)
ME_SUS_PWR_ACK_R: length 19.7
  TOP w0.086: RC444.2 157.97,49.5 v2(157.77,49.5) 157.77,49.74 v1(158,49.97)
  IN1 w0.051: v4(149.37,63.44) 149.37,63.42 150.14,62.64 150.14,61.7 156.38,55.46 156.38,51.98 157.8,50.56 157.8,49.52 v2(157.77,49.5)
  GND5 w0.086: v5(148.9,63.11) 149.04,63.11 v4(149.37,63.44)
  BOTTOM w0.086: UC1.AR13 v5(148.9,63.11)
MEC_XTAL1: length 8.5
  TOP w0.086: YE1.1 255.16,69.72 255.25,69.63 CE28.1 255.43,67.94 255.43,67.38 255.52,67.29 255.52,66.99 255.74,66.76 256.25,66.76 v1(256.99,66.02) 257.27,65.73 258.26,65.73 UE1.A1
MEC_XTAL2: length 3.3
  TOP w0.086: RE290.2 CE29.1 256.11,69.62 256.2,69.72 YE1.2
MEC_XTAL2_R: length 5.3
  TOP w0.086: RE290.1 257.03,66.82 257.52,66.33 259.27,66.33 UE1.A3
MEM_CONFIG0: length 9.6
  BOTTOM w0.076: 157.12,63.31 156.5,63.31 156.31,63.5 156.03,63.5 UC1.AP2
  BOTTOM w0.086: RC388.2 162.75,61.17 161.74,61.17 RC393.1 160.75,61.14 160.75,61.7 159.4,63.05 157.37,63.05 157.12,63.31
MEM_CONFIG1: length 9.5
  BOTTOM w0.076: 157.13,62.89 157.01,63.01 156.36,63.01 UC1.AP1
  BOTTOM w0.086: RC389.2 162.89,60.13 161.71,60.13 RC394.1 160.44,60.43 160.44,61.66 159.41,62.7 v1(158.48,62.7) 157.32,62.7 157.13,62.89
MEM_CONFIG2: length 9.6
  BOTTOM w0.076: v1(157.56,63.59) 157.48,63.66 156,63.66 155.59,63.5 155.3,63.5 UC1.AP3
  BOTTOM w0.086: v1(157.56,63.59) 157.88,63.26 159.64,63.26 RC395.1 161.71,62.16 162.67,62.16 RC390.2
MEM_CONFIG3: length 9.4
  BOTTOM w0.076: UC1.AN3 154.51,63.9 154.83,64.22 157.65,64.22
  BOTTOM w0.086: 157.65,64.22 157.83,64.22 158.22,63.83 v1(159.09,63.83) 159.93,63.83 160.08,63.68 RC396.1 161.27,63.68 161.76,64.17 162.49,64.17 RC391.2
MEM_CONFIG4: length 8.2
  BOTTOM w0.086: UC1.AN1 157.7,63.89 158.09,63.5 159.78,63.5 160.19,63.1 v1(160.3,63.1) 160.85,63.1 RC397.1 161.7,63.2 162.5,63.2 RC392.2
MEM_INTERLEAVED: length 12.4
  TOP w0.086: RC371.1 164.61,73.11 v1(164.39,73.33) 164.1,73.62 163.16,73.62 162.65,73.11 RC372.1 162.52,73.06 160.97,73.06 v3(160.92,73.11)
  GND1 w0.086: v3(160.92,73.11) 160.92,72.5 v4(160.85,72.42)
  GND5 w0.086: v4(160.85,72.42) 160.8,72.37 v5(160.36,72.37)
  BOTTOM w0.076: 159.45,73.95 156.9,73.95 156.54,73.58 156.03,73.58 155.75,73.63 UC1.P2
  BOTTOM w0.086: v5(160.36,72.37) 160.36,73.38 159.78,73.95 159.45,73.95
MEM_SMBCLK: length 20.6
  TOP w0.086: v3(159.75,73.9) 159.75,73.85 160.16,73.44 161.03,73.44 161.36,73.77 162.8,73.77 RC12.1
  GND1 w0.086: v4(160.24,73.36) 160.24,73.42 v3(159.75,73.9) ; v4(154.68,76.29) 154.54,76.43 v3(153.77,76.43)
  IN1 w0.051: v4(160.24,73.36) 160.24,73.26 159.63,72.65 157.14,72.65 156.5,73.29 153.44,73.29 v2(153.04,72.89)
  IN3 w0.061: v2(153.04,72.89) 153.04,72.84 153.43,72.45 154.81,72.45 155.24,72.88 155.24,75.78 154.73,76.29 v4(154.68,76.29)
  BOTTOM w0.086: UC1.R7 152.75,73.17 v2(153.04,72.89)
MEM_SMBDATA: length 15
  TOP w0.086: v2(152.4,72.89) 152.06,73.23 152.06,74.43 151.87,74.62 QC2.3 ; v3(159.78,74.55) v6(159.78,75.33) 159.78,75.39 160.2,75.8 RC14.1
  GND1 w0.086: v4(160.24,74.38) 160.07,74.55 v3(159.78,74.55)
  IN1 w0.051: v2(152.4,72.89) 153.03,73.52 156.76,73.52 157.32,72.96 159.45,72.96 159.83,73.34 159.83,73.97 v4(160.24,74.38)
  BOTTOM w0.086: v2(152.4,72.89) 152.1,73.19 UC1.R8
MPHYP_PWR_EN: length 3.2
  TOP w0.086: RC387.1 150.59,65.6 v2(150.31,65.31) 149.95,65.31 149.29,64.65 v1(148.93,64.65)
  BOTTOM w0.086: v2(150.31,65.31) 150.55,65.06 UC1.AM10
MSCLK: length 57.4
  TOP w0.086: UE1.H10 v2(266.96,58.64)
  IN3 w0.061: v2(266.96,58.64) 266.59,59.01 265.02,59.01 264.25,58.25 263.64,58.25 263.42,58.02 263.42,57.64 263.21,57.44 262.83,57.44 262.63,57.24 262.63,56.85 262.4,56.63 262.04,56.63 261.82,56.4 261.82,56.04 261.59,55.81 261,55.81 259.3,54.11 258.11,54.11 256.71,52.71 256.71,51.57 256.48,51.34 255.49,51.34 254.42,50.28 254.42,47.19 255.42,46.19 255.42,43.91 256,43.34 256,39.9 254.79,38.7 254.79,35.26 250.86,31.33 246.43,31.33 245.79,31.97 v4(245.79,32.32)
  GND5 w0.086: v5(245.13,31.96) 245.43,31.96 v4(245.79,32.32)
  BOTTOM w0.086: RE30.1 240.38,32.89 240.12,32.64 240.12,29.3 240.38,29.04 242.31,29.04 242.53,29.26 JDEG1.6 242.53,30.41 243.19,31.07 v1(243.76,31.07) 244.24,31.56 244.72,31.56 v5(245.13,31.96)
MSDATA: length 50.9
  TOP w0.086: UE1.G9 265.43,59.44 v2(265.37,59.44)
  IN3 w0.061: v4(244.75,33.61) 244.75,33.33 245.18,32.9 245.97,32.9 246.39,32.47 246.93,31.93 250.2,31.93 251.58,33.31 252.04,33.31 254.22,35.5 254.22,38.93 255.43,40.14 255.43,42.37 253.82,43.98 253.82,50.61 255.47,52.26 255.47,53.25 256.05,53.83 256.97,53.83 258.32,55.18 258.74,55.18 260.22,56.65 261.61,56.65 261.84,56.88 261.84,57.18 262.12,57.46 262.45,57.46 262.63,57.64 262.63,58.02 262.83,58.23 263.19,58.23 263.42,58.45 263.42,58.94 263.54,59.06 264.41,59.06 264.79,59.44 v2(265.37,59.44)
  GND5 w0.086: v5(245.13,32.85) 244.75,33.23 v4(244.75,33.61)
  BOTTOM w0.086: v5(245.13,32.85) 245.12,32.85 RE86.1 243.73,31.45 242.79,31.45 v1(242.32,30.98) 242.03,30.69 JDEG1.7
MUX1_FLIP_SEL_R: length 3.3
  BOTTOM w0.076: 34.62,70.29 33.97,70.94 33.97,71.28 UT5.B2
  BOTTOM w0.086: 34.62,70.29 34.92,70.29 35.65,69.56 RT69.1
MUX2_FLIP_SEL_R: length 5.4
  BOTTOM w0.086: RT165.1 21.89,41.56 21.99,41.46 22.85,41.46 23.77,42.38 v1(24.19,42.38) 26.48,42.38 UT11.B2
MW_1: length 1.5
  TOP w0.086: RE550.1 253.35,77.18 UE2.10
MW_2: length 3.9
  TOP w0.086: v1(252.98,75.61) RE518.1 255.28,76.67 255.37,76.58 UE2.11
NB_MODE#: length 54.6
  TOP w0.086: v2(245.29,66.15) 245.79,66.66 245.79,69.18 243.49,71.47 v1(243.49,72.16) 243.49,72.63 243.27,72.84 243.27,79.7 243.71,80.14 243.71,82.43 246.6,85.31 RC507.2 246.99,86.11 247.57,86.69 248.53,86.69 QC3.1 249.39,85.82 RC508.1 ; v2(265.35,57.84) 264.99,58.2 UE1.J8
  IN2 w0.061: v2(245.29,66.15) 246.32,66.15 247.11,66.94 251.79,66.94 252.28,66.45 254.08,66.45 256.53,64.01 256.53,63.44 v2(256.53,63.43)
  BOTTOM w0.086: v2(265.35,57.84) 264.73,58.46 264.73,59.81 264.28,60.26 264.28,61.21 264.09,61.4 261.98,61.4 261.83,61.55 261.83,61.93 261.59,62.18 261.22,62.18 261,61.96 261,61.58 260.82,61.4 258.27,61.4 256.53,63.14 v2(256.53,63.43)
NB_MODE#_D: length 168.9
  TOP w0.086: v2(249.17,59.83) v1(249.17,62.34) 249.17,63.18 246.07,66.28 246.07,69.2 243.92,71.34 243.92,72.74 243.55,73.12 243.55,79.1 245.67,81.23 245.67,82.14 246.32,82.79 247.95,82.79 RC506.2 249.36,84.2 QC3.3 250.12,84.61 RC508.2
  IN3 w0.061: v2(249.17,59.83) 248.96,60.03 239.9,60.03 236.35,56.48 236.35,55.32 235.84,54.81 235.84,51.58 230.6,46.33 230.29,46.33 224.67,40.71 217.77,40.71 217,39.95 191.24,39.95 190.41,40.78 187.21,40.78 185.87,42.11 183.82,42.11 183.78,42.07 182.29,42.07 181.91,42.45 179.81,42.45 179.4,42.86 179.4,44.03 176.91,46.52 176.91,49.35 175.74,50.52 174.96,50.52 171.44,54.03 167.52,54.03 166.07,52.58 165.49,52.58 163.37,54.71 160.31,54.71 154.81,60.21 152.9,60.21 v4(152.89,60.22)
  GND5 w0.086: v4(152.89,60.22) 152.87,60.21 152.58,60.21 v5(152.37,60)
  BOTTOM w0.076: v5(152.37,60) 152.69,59.67 152.69,58.84 153.33,58.2 153.81,58.2
  BOTTOM w0.086: 153.81,58.2 155.08,56.93 161.33,56.93 RC349.1 163.67,59.27 164.31,59.27 164.53,59.48 164.53,61.2 RC509.1
NB_MUTE#: length 37.2
  TOP w0.086: UE1.A4 v2(261.42,64.98) ; DA8.1 257.4,38.5 RA48.1 257.4,39.9 257.24,40.06 255.5,40.06 255.31,40.24 v3(255.29,40.24)
  GND1 w0.086: v4(254.78,40.52) 255.03,40.52 255.29,40.27 v3(255.29,40.24)
  IN1 w0.051: v4(254.86,57.21) 255.1,56.97 255.1,54.17 255.49,53.78 255.49,47.76 254.04,46.31 254.04,43.23 254.32,42.95 254.32,40.98 v4(254.78,40.52)
  IN3 w0.061: v2(261.42,64.98) 260.46,64.98 260.1,64.63 259.25,64.63 258.68,65.2 256.23,65.2 254.65,63.63 254.65,61.38 255.03,60.99 255.03,57.39 v4(254.86,57.21)
NGFF_CONFIG_0: length 82.8
  TOP w0.086: v2(263.81,51.19) 263.81,50.85 264.71,49.95 265.24,49.95 265.4,50.1 RPE9.3 265.4,53.17 v1(265.62,53.38) 266.08,53.85 266.08,54.72 UE1.N9
  IN2 w0.061: v2(238.16,91.67) 237.41,92.43 230.36,92.43 229.46,91.53 229.46,91.07 229.22,90.83 229.22,84.21 229.14,84.02 v2(229.02,83.91)
  BOTTOM w0.086: v2(238.16,91.67) 239.23,90.6 240.44,90.6 241.34,89.71 241.34,68.7 245.99,64.04 247.41,64.04 251.15,60.31 252.34,60.31 254.68,57.97 254.68,55.79 258.09,52.37 259.71,52.37 260.29,51.79 260.29,51.11 260.6,50.81 261.13,50.81 261.51,51.19 v2(263.81,51.19) ; v2(229.02,83.91) 229.21,83.72 229.38,83.65 JNGFF2.21
NGFF_CONFIG_1: length 87.6
  TOP w0.086: UZ29.9 225.98,63.54 224.86,64.66 v1(224.86,64.88) 224.86,66.81 226.97,68.92 v2(227.5,68.92) ; RE562.1 266.13,52.37 266.13,53.07 267,53.93 v2(267,55.43) 266.62,55.81 UE1.M10
  IN3 w0.061: v2(267,55.43) 267.05,55.43 267.56,54.92 268.77,54.92 269.97,56.12 269.97,57.97 270.78,58.78 270.78,61.44 272.1,62.76 272.1,65.47 269.61,67.95 269.61,70.01 267.02,72.6 267.02,73.92 265.06,75.89 253.13,75.89 251.55,74.31 248.65,74.31 247.79,73.45 245.92,73.45 242.51,70.04 242.51,69.18 240,66.67 237.73,66.67 237.18,66.11 233.06,66.11 232.7,66.47 230.47,66.47 228.02,68.92 v2(227.5,68.92)
  BOTTOM w0.086: JNGFF2.69 229.16,71.65 227.5,69.99 v2(227.5,68.92)
NGFF_CONFIG_2: length 79.2
  TOP w0.086: v2(249.19,73.4) 249.19,73.1 v1(249,72.91) ; RPE9.2 265.9,50.7 266.18,50.99 266.31,50.99 v2(266.54,51.22) 266.44,51.22 265.9,51.75 265.9,53.14 266.59,53.83 UE1.N10
  IN1 w0.051: v2(249.19,73.4) 249.18,73.39 249.18,71.18 244.54,66.54 244.54,65.5 243.76,64.73 237.03,64.73 236.47,64.17 236.11,64.17 235.42,64.86 232.66,64.86 229.26,68.25 229.26,69.19 v2(228.49,69.96)
  BOTTOM w0.086: v2(228.49,69.96) 228.68,70.15 JNGFF2.75 ; v2(266.54,51.22) 266.84,51.22 269.22,53.59 269.22,60.26 270.99,62.03 270.99,65.63 267.16,69.46 263.46,69.46 263.05,69.87 262.54,69.87 261.97,70.44 261.97,71.4 261.25,72.12 259.13,72.12 257.85,73.4 v2(249.19,73.4)
NGFF_CONFIG_3: length 78.7
  TOP w0.086: RPE9.4 v1(264.9,52.17) v2(264.9,53.32) ; UE1.F4 v2(261.42,60.98)
  IN1 w0.051: v2(228.01,82.61) 228.19,82.43 228.19,82.08 230.45,79.82 230.45,72.2 229.44,71.19 229.44,68.31 232.73,65.03 240.68,65.03 241.33,65.67 242.05,65.67 243.12,66.74 243.12,67.16 243.91,67.95 244.16,67.95 244.85,68.64 244.85,69.22 245.56,69.94 v2(246.47,69.94)
  BOTTOM w0.086: v2(264.9,53.32) 264.42,53.8 264.42,59.55 263.65,60.32 261.96,60.32 261.6,60.68 261.6,60.8 v2(261.42,60.98) 261.21,60.78 261.21,60.66 260.95,60.4 258.27,60.4 255.91,62.76 255.91,63.29 255.27,63.93 253.31,63.93 251.57,65.68 250.5,65.68 246.47,69.71 v2(246.47,69.94) ; v2(228.01,82.61) 228.01,83.4 227.3,84.11 227.3,87.72 228.52,88.93 229.07,88.93 229.36,88.65 JNGFF2.1
NRB_BIT: length 11.7
  TOP w0.086: v2(152.11,62.72) 152.11,62.71 152.11,60.41 156.16,56.36 v1(157,56.36) 157.65,55.71 RC186.1
  BOTTOM w0.086: UC1.AR7 152.51,63.11 v2(152.11,62.72)
NTC_GT: length 2.8
  BOTTOM w0.203: PU602.15 75.57,76.73 75.89,77.05 76.09,77.05 76.4,77.35 76.4,77.69 PR635.2
NVME_LED#: length 7.6
  TOP w0.086: v2(28.59,13.17) 28.24,13.52 RN100.1 v1(27.28,14.36)
  IN1 w0.051: v2(28.59,13.17) 28.97,13.55 31.29,13.55 32.1,12.73 JNGFF3.10
ONE_DIMM#: length 13.9
  TOP w0.086: RC268.1 RC267.1 v1(158.54,55.41) 156.74,57.21 156.56,57.21 152.52,61.25 152.52,63.77 152.17,64.12 v2(152.17,64.12)
  BOTTOM w0.086: v2(152.17,64.12) 152.2,64.12 UC1.AP7
OTG_ID1: length 3.6
  BOTTOM w0.076: 31.96,76.08 31.96,75.78 UT5.E10
  BOTTOM w0.086: 31.96,76.08 31.96,76.71 32.52,77.26 33.28,77.26 33.75,77.73 RT74.1
OTG_ID2: length 5.9
  BOTTOM w0.076: UT11.E10 30.98,43.87 31.49,43.87
  BOTTOM w0.086: 31.49,43.87 31.62,43.87 32.78,42.71 v1(33.18,42.71) 34.05,42.71 35.14,41.61 RT170.1
OTGEN/CMIN: length 5
  TOP w0.117: v1(55.39,30.1) 55.81,30.51 PR960.2
  TOP w0.203: PR960.2 55.59,31.2 55.59,32.52 55.08,33.03 PR919.2 55.34,33.33 PU901.20
P_SENSOR_ACK#_R: length 3.3
  TOP w0.086: Q1.3 240.95,76.91 RZ344.2 240.96,77.43 RZ326.2 v1(240.96,79.28)
P_SENSOR_ACT#_EC: length 2.6
  TOP w0.086: UE1.F13 270.08,60.61 v1(270.36,60.34) 270.79,59.9 RE509.2
