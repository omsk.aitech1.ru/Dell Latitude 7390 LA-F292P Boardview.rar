# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTB_TX1P_C: length 30.5
  TOP w0.156: JUSBC2.A2 8.81,70.32 arc(9,70.36) 9.15,70.47 10.35,71.67 arc(10.62,71.84) 10.93,71.91 12.45,71.91 arc(12.74,71.96) DT22.1 13.24,71.89 arc(13.29,71.85) 13.35,71.84 14.25,71.84 arc(14.48,71.8) 14.67,71.67 14.84,71.49 arc(14.97,71.32) 15.05,71.11 15.15,70.67 arc(15.19,70.55) 15.25,70.45 arc(15.81,70.03) 16.47,69.8 18.02,69.5 arc(18.32,69.39) 18.59,69.2 18.95,68.83 arc(19.15,68.6) 19.32,68.35 21.49,64.67 21.76,64.17 arc(21.99,63.61) 22.06,63.01 22.06,59.16 arc(22.2,58.46) 22.6,57.87 22.97,57.49 arc(23.64,56.51) 23.87,55.34 23.87,54.9 arc(23.94,54.72) 24.12,54.64 24.35,54.64 arc(24.49,54.7) v2(24.56,54.83)
  BOTTOM w0.156: v2(24.56,54.83) 24.58,54.82 24.6,54.82 24.75,54.66 arc(24.8,54.63) 24.86,54.62 24.93,54.62 arc(25.06,54.67) 25.11,54.8 CT159.2
TBTB_TX2N: length 2.9
  BOTTOM w0.076: 27.16,56.44 27.18,56.44 27.22,56.4 27.58,56.4 27.77,56.48 27.77,56.48 arc(27.86,56.53) 27.96,56.55 28.02,56.55 arc(28.17,56.52) 28.3,56.43 UT1.B17
  BOTTOM w0.156: 27.16,56.44 26.08,56.44 arc(25.87,56.48) CT162.1
TBTB_TX2N_C: length 24.5
  TOP w0.156: JUSBC2.B3 6.19,66.57 arc(6.49,66.52) v2(6.74,66.35) ; v2(20.84,61.21) 20.73,61.09 arc(20.62,61.02) 20.49,60.99 19.83,60.99 arc(19.22,61.12) 18.7,61.46 17.77,62.39 17.46,62.7 arc(17.2,62.87) 16.91,62.93 16.46,62.93 arc(16.27,62.97) 16.11,63.08 v2(16.08,63.11)
  BOTTOM w0.156: v2(20.84,61.21) 20.84,61.19 20.96,61.07 arc(21.04,61.02) 21.14,61 arc(21.69,60.78) 21.91,60.23 21.91,59.57 arc(22.09,58.68) 22.59,57.93 23.68,56.84 arc(24.06,56.59) 24.49,56.5 24.69,56.5 24.87,56.5 arc(25,56.53) CT162.2 ; v2(16.08,63.11) 15.98,63.01 arc(15.89,62.95) 15.79,62.93 15.6,62.93 arc(15.44,62.96) 15.3,63.05 14.18,64.17 arc(13.91,64.35) 13.6,64.41 13.29,64.41 arc(13.23,64.43) 13.18,64.46 DT35.1 12.85,64.49 arc(12.75,64.42) 12.62,64.4 9.84,64.4 arc(9.61,64.45) 9.41,64.58 8.09,65.9 arc(7.79,66.1) 7.44,66.17 7.17,66.17 arc(6.94,66.22) v2(6.74,66.35)
TBTB_TX2P: length 2.9
  BOTTOM w0.076: 27.16,56.21 27.18,56.21 27.22,56.25 27.61,56.25 27.61,56.24 27.63,56.23 arc(27.68,56.19) 27.72,56.15 arc(27.79,56.1) 27.87,56.09 28.04,56.09 arc(28.15,56.2) 28.04,56.3 UT1.A17
  BOTTOM w0.156: 27.16,56.21 26.08,56.21 arc(25.95,56.18) 25.84,56.11 CT161.1
TBTB_TX2P_C: length 24.5
  TOP w0.156: v2(6.74,65.76) 6.71,65.76 6.7,65.78 6.64,65.78 6.62,65.8 arc(6.31,66) JUSBC2.B2 ; v2(16.08,62.52) 16.11,62.55 arc(16.27,62.66) 16.46,62.7 16.91,62.7 arc(17.11,62.65) 17.29,62.54 18.53,61.29 arc(19.13,60.9) 19.83,60.76 20.51,60.76 arc(20.69,60.72) v2(20.84,60.62)
  BOTTOM w0.156: v2(20.84,60.62) 20.86,60.64 arc(20.99,60.73) 21.14,60.76 arc(21.52,60.61) 21.67,60.23 21.67,59.57 arc(21.87,58.59) 22.43,57.76 23.52,56.67 arc(23.96,56.37) 24.49,56.26 24.69,56.26 arc(24.81,56.24) 24.9,56.17 CT161.2 ; v2(16.08,62.52) 15.99,62.62 arc(15.91,62.67) 15.81,62.69 15.6,62.69 arc(15.35,62.74) 15.13,62.88 14.01,64.01 arc(13.82,64.13) 13.6,64.18 13.38,64.18 arc(13.26,64.15) 13.15,64.08 DT34.1 12.99,63.93 arc(12.74,64.1) 12.43,64.16 9.84,64.16 arc(9.52,64.23) 9.24,64.41 7.92,65.74 arc(7.72,65.86) 7.5,65.91 7.1,65.91 arc(6.91,65.87) v2(6.74,65.76)
TBTB_USB2_RBIAS: length 1.2
  GND1 w0.086: v4(31.41,54.95) 31.41,54.35 v3(31.45,54.31)
  GND5 w0.086: v4(31.41,54.95) 31.41,55.02 v5(31.08,55.35)
TBTB_USB20_N: length 63.6
  IN1 w0.062: v2(25.52,48.8) 25.52,48.73 25.67,48.57 27.44,48.57 27.61,48.75 27.61,49.21 27.02,49.8 25.12,49.8 25.06,49.74 25.06,48.73 24.92,48.58 24.35,48.58 24.2,48.73 24.2,50.53 24.39,50.72 26.39,50.72 26.45,50.78 26.45,51.22 26.38,51.28 24.39,51.28 24.24,51.43 24.24,52 24.39,52.14 27.16,52.14 27.31,52 27.31,51.08 27.37,51.02 27.82,51.02 27.88,51.08 27.88,53 28.02,53.15 28.59,53.15 28.74,53 28.74,51 28.8,50.94 29.25,50.94 29.31,51 29.31,53.1 29.45,53.25 30.02,53.25 30.17,53.1 30.17,51.03 30.23,50.97 30.68,50.97 30.74,51.03 30.74,53.1 30.88,53.25 31.45,53.25 31.6,53.1 31.6,51 31.66,50.94 32.01,50.94 32.17,51.09 32.17,53.08 32.34,53.25 32.88,53.25 33.03,53.1 33.03,52.34 33.09,52.28 33.54,52.28 33.6,52.34 33.6,52.45 33.74,52.6 34.44,52.6 34.59,52.45 34.59,51.15 34.65,51.09 36,51.09 36.06,51.15 36.06,51.62 36,51.69 35.3,51.69 35.16,51.83 35.16,52.45 35.3,52.6 36.42,52.6 36.48,52.66 36.48,53.1 36.42,53.17 34.21,53.17 34.07,53.31 34.07,54.96 34,55.03 33.56,55.03 33.5,54.96 33.5,53.95 33.37,53.82 32.78,53.82 32.64,53.97 32.64,54.96 32.57,55.03 32.13,55.03 32.07,54.96 32.07,53.97 31.92,53.82 29.85,53.82 29.7,53.97 29.7,54.78 v2(29.44,55.04)
  BOTTOM w0.088: UT1.D20 29.1,54.73 29.1,54.91 29.23,55.04 v2(29.44,55.04) ; v2(25.52,48.8) 25.67,48.65 25.9,48.65 RT408.2
TBTB_USB20_P: length 63.6
  IN1 w0.062: v2(30.09,55.03) 29.85,54.78 29.85,54.03 29.91,53.97 31.86,53.97 31.92,54.03 31.92,55.02 32.07,55.17 32.63,55.17 32.78,55.02 32.78,54.03 32.84,53.97 33.31,53.97 33.35,54.01 33.35,55.02 33.5,55.17 34.06,55.17 34.21,55.02 34.21,53.37 34.27,53.31 36.48,53.31 36.62,53.16 36.62,52.6 36.48,52.45 35.36,52.45 35.3,52.39 35.3,51.89 35.36,51.83 36.06,51.83 36.2,51.68 36.2,51.09 36.06,50.94 34.59,50.94 34.44,51.09 34.44,52.39 34.38,52.45 33.8,52.45 33.74,52.39 33.74,52.28 33.6,52.14 33.03,52.14 32.88,52.28 32.88,53.04 32.82,53.11 32.4,53.11 32.31,53.01 32.31,51.03 32.07,50.8 31.6,50.8 31.45,50.94 31.45,53.04 31.39,53.11 30.94,53.11 30.88,53.04 30.88,50.97 30.74,50.82 30.17,50.82 30.02,50.97 30.02,53.04 29.96,53.11 29.51,53.11 29.45,53.04 29.45,50.94 29.31,50.8 28.74,50.8 28.59,50.94 28.59,52.94 28.53,53.01 28.08,53.01 28.02,52.94 28.02,51.02 27.88,50.87 27.31,50.87 27.16,51.02 27.16,51.94 27.1,52 24.45,52 24.39,51.94 24.39,51.49 24.45,51.43 26.44,51.43 26.59,51.28 26.59,50.72 26.45,50.57 24.45,50.57 24.34,50.47 24.34,48.79 24.41,48.73 24.86,48.73 24.92,48.79 24.92,49.8 25.06,49.95 27.08,49.95 27.76,49.27 27.76,48.69 27.5,48.43 25.73,48.43 v2(25.52,48.22)
  BOTTOM w0.088: v2(30.09,55.03) 29.78,54.71 UT1.E20 ; RT407.2 25.92,48.4 25.7,48.4 v2(25.52,48.22)
TDI_XDP: length 32.1
  TOP w0.086: UC8.5 85.73,88.22 86.03,88.51 RC229.1 86.38,88.2 86.23,88.05 86.05,88.05 85.84,87.84 v3(85.84,87.77)
  GND1 w0.086: v3(59.97,88.48) 59.97,88.92 v4(60.11,89.06) ; v4(86.15,87.26) 86.15,87.33 85.84,87.64 v3(85.84,87.77)
  IN4 w0.051: v4(86.15,87.26) 86.15,87.61 85.54,88.22 82.11,88.22 80.53,89.8 68.54,89.8 68.38,89.95 65.83,89.95 65.51,90.27 63.43,90.27 63.14,89.98 61.02,89.98 v4(60.11,89.06)
TDO_XDP: length 31.3
  TOP w0.086: v3(61.17,88.48) 61.17,86.57 CC306.1 ; UC8.2 86.27,86.72 v3(86.38,86.61)
  GND1 w0.086: v4(85.55,87.24) 85.55,87.22 86.17,86.61 v3(86.38,86.61) ; v3(61.17,88.48) 61.17,88.74 v4(61.48,89.05)
  IN4 w0.051: v4(61.48,89.05) 61.61,88.92 62.67,88.92 63.64,89.89 65.38,89.89 65.68,89.59 68.24,89.59 68.39,89.44 80.36,89.44 81.93,87.87 85.21,87.87 85.55,87.52 v4(85.55,87.24)
TDOCK_BATLOW#: length 3.6
  GND1 w0.086: v3(31.28,65.69) 30.56,64.97 v4(30.56,64.93)
  GND5 w0.086: v5(31.01,64.5) 30.57,64.93 v4(30.56,64.93)
  BOTTOM w0.076: UT1.F2 30.32,63.2 30.49,63.37 30.49,64.07 30.47,64.09 30.47,64.4 30.57,64.5 v5(31.01,64.5)
TEST_EN: length 2.5
  BOTTOM w0.086: RT36.1 29.52,65.46 29.79,65.19 29.79,63.99 29.81,63.98 UT1.E1
TEST_PWRGD: length 2.6
  BOTTOM w0.076: 39.08,61.91 39.06,61.88 38.42,61.88 38.24,62.06 37.87,62.06 UT1.AB5
  BOTTOM w0.086: RT37.1 39.49,62.32 39.08,61.91
THERMDA: length 0.5
  BOTTOM w0.086: UT1.AC23 UT1.AB23
THERMTRIP1#: length 3.9
  TOP w0.086: UE1.B12 268.67,64.29 269.53,64.29 269.75,64.51 v1(270.36,64.51) 270.78,64.09 270.78,63.92 RE301.1
THERMTRIP2#: length 19
  TOP w0.086: UE1.H3 v2(260.62,58.64) ; v2(256.23,50.73) 256.66,50.3 256.66,49.26 v1(256.2,48.8) 255.31,47.91 QE4.1 256.18,46.78 CE36.1 RE69.2
  IN2 w0.061: v2(260.62,58.64) 260.47,58.64 260.09,59.01 259.3,59.01 257.52,57.24 256.98,57.24 255.83,56.09 255.83,51.13 v2(256.23,50.73)
TOUCH_SCREEN_DET#: length 58.6
  IN2 w0.061: v4(194.53,39.25) 194.53,39.29 193.91,39.91 193.2,39.91 192.85,39.56 188.98,39.56 188.43,40.11 182.37,40.11 182.17,39.91 182.17,39.91 181.94,39.68 181.56,39.3 179.53,39.3 178.96,39.88 177.82,39.88 176.23,41.46 176.23,42.35 174.23,44.35 174.23,47.67 169.15,52.75 168.41,52.75 167.44,53.72 165.73,53.72 163.03,56.41 163.03,56.71 162.39,57.36 161.31,57.36 160.75,57.92 v2(160.78,57.92)
  GND5 w0.086: v5(194.53,38.77) v4(194.53,39.25)
  BOTTOM w0.076: UC1.AY5 153.48,60.04 153.92,59.61 153.92,59.17 154.1,58.99 154.5,58.99 154.72,58.77 154.72,58.56 154.88,58.4 155.23,58.4 155.44,58.19
  BOTTOM w0.086: JTS1.10 193.9,39.88 194.07,39.71 194.07,38.41 RV305.1 ; RV305.1 194.53,38.41 v5(194.53,38.77) ; RV305.1 RV8.1 ; v2(160.78,57.92) 160.75,57.92 160.71,57.88 155.75,57.88 155.44,58.19
TOUCH_SCREEN_PD#: length 82.2
  TOP w0.086: v3(187.9,45.14) 187.55,45.14 185.62,43.21 185.62,42.1 186.81,40.9 188.13,40.9 188.85,40.18 v3(188.85,39.43) ; RC272.1 166.97,87.26 v2(166.56,86.85) 165.15,85.44 161.93,85.44 160.16,83.68 v2(154.77,83.68)
  GND1 w0.086: v3(187.9,45.14) 188.56,45.81 v4(188.56,45.83) ; v3(188.85,39.43) 188.85,38.95 v4(188.73,38.82)
  IN2 w0.061: v2(166.56,86.85) 166.56,86.04 167.62,84.98 168.4,84.98 170.89,82.48 170.89,79.72 173.28,77.33 173.28,76.03 176.09,73.23 176.09,66.28 176.16,66.21 176.16,60.86 178.48,58.53 178.48,55.39 182.9,50.98 182.9,50.4 182.9,50.28 183.15,50.02 183.72,50.02 183.76,50.06 184.08,50.06 184.13,50.01 184.13,50.01 184.88,49.26 186.52,49.26 186.98,48.8 186.98,47.18 188.33,45.83 v4(188.56,45.83)
  GND5 w0.086: v4(188.73,38.82) 188.56,38.99 v5(188.56,39.43)
  BOTTOM w0.086: JTS1.3 188.3,39.69 v5(188.56,39.43) ; v2(154.77,83.68) 153.43,82.34 152.86,82.34 152.61,82.09 UC1.A7
TOUCHPAD_INTR#: length 170
  TOP w0.086: RE318.2 253.33,59.66 254.02,58.97 254.02,56.93 252.04,54.95 252.04,49.92 v2(252.42,49.54) ; RPC5.1 162.98,65.74 162.22,64.98 162.22,62.52 160.95,61.25 160.95,58.99 160.34,58.38 160.34,57.41 v2(160.39,57.36) 160.8,56.95 v1(160.8,55.52) 160.8,53.21 159.83,52.24 159.83,48.14 159.4,47.71 159.4,47.2 v3(159.51,47.09)
  GND1 w0.086: v4(159.86,46.53) 159.86,46.74 v3(159.51,47.09)
  IN4 w0.051: v4(159.86,46.53) 161.88,46.53 163.78,44.63 164.64,44.63 165.44,43.83 165.44,41.08 166.69,39.84 167.58,39.84 168.5,38.92 168.5,37.5 170.32,35.68 170.59,35.68 172.45,33.82 174.11,33.82 174.64,33.28 v4(174.64,32.85) 177.32,32.85 178.65,31.51 179.83,31.51 180.3,31.05 187.34,31.05 188.11,30.28 195.02,30.28 195.09,30.21 195.43,30.21 195.57,30.35 205.14,30.35 205.86,29.64 206.44,29.64 207.41,28.67 211.34,28.67 213.67,31 218.88,31 219.27,31.39 224.97,31.39 225.76,30.59 231.54,30.59 232.01,31.06 235.96,31.06 237.23,29.8 251.81,29.8 252.32,30.31 253.08,30.31 254.55,31.78 254.55,38.96 253.98,39.53 253.98,41.45 253.17,42.26 253.17,48.79 v2(252.42,49.54)
  GND5 w0.086: v5(174.54,33.44) 174.54,32.95 v4(174.64,32.85)
  BOTTOM w0.076: UC1.BA5 153.53,59.24 153.99,58.78 153.99,58.67 154.25,58.4 154.57,58.4 154.8,58.18 155.01,58.18
  BOTTOM w0.086: v2(160.39,57.36) 160.11,57.64 155.55,57.64 155.01,58.18
  BOTTOM w0.117: JKBTP1.16 174.75,33.87 174.54,33.66 v5(174.54,33.44)
TP_DISABLE#: length 119.3
  TOP w0.086: v2(252.44,46.85) 252.39,46.85 251.88,47.35 251.88,48.47 251.33,49.03 251.33,55.28 251.78,55.74 251.78,58.13 251.49,58.42 v1(250.84,58.42) 249.28,58.42 248.43,59.27 246.3,59.27 246.04,59.52 246.04,61.17 245.52,61.7 UE10.4 243.82,61.7 RE555.1
  IN4 w0.051: v4(193.57,31.2) 193.59,31.17 195.6,31.17 195.96,30.82 205.32,30.82 206.05,30.09 209.58,30.09 210.94,31.46 218.69,31.46 219.08,31.84 225.23,31.84 225.97,31.11 231.33,31.11 231.8,31.57 236.18,31.57 237.49,30.25 251.13,30.25 254.04,33.17 254.04,38.75 253.47,39.32 253.47,41.24 252.66,42.05 252.66,46.63 v2(252.44,46.85)
  GND5 w0.086: v5(193.25,30.78) 193.25,30.88 v4(193.57,31.2)
  BOTTOM w0.086: JKBTP1.11 177.25,34.43 178.07,33.61 184.44,33.61 185.64,32.42 188.11,32.42 188.99,31.53 191.74,31.53 192.49,30.78 v5(193.25,30.78)
TP_DISABLE#_EC: length 19.1
  TOP w0.086: v2(248.38,60.61) 247.95,61.05 UE10.2 ; v2(255.59,56.41) 255.59,56.14 RE529.1 256.38,56.22 259.53,56.22 259.92,56.61 UE1.L2
  IN1 w0.051: v2(248.38,60.61) 249.85,60.61 250.26,61.02 250.26,61.6 250.44,61.78 252.01,61.78 254.75,59.03 254.75,57.92 255.59,57.08 v2(255.59,56.41)
  BOTTOM w0.086: v2(248.38,60.61) v1(249.18,60.61)
TPM_GPIO0: length 2.1
  BOTTOM w0.086: RZ112.2 171.86,41.74 v1(171.86,41.75) UZ12.29
TPM_GPIO4: length 1.2
  BOTTOM w0.086: UZ12.13 164.71,42.25 T283.1
TPM_LPM#: length 2.1
  BOTTOM w0.086: UZ12.3 168.88,38.84 169.21,38.52 v1(169.21,38.38) 169.21,37.52 RZ363.2
TPM_PIRQ#: length 32.5
  TOP w0.086: v3(151.26,64.35) 151.26,64.96 RC561.1
  GND1 w0.086: v3(151.26,64.35) v4(151.26,64.84)
  IN1 w0.051: v4(151.26,64.84) 151.6,65.19 152.71,65.19 152.99,64.91 152.99,64.07 152.62,63.7 152.62,61.05 153.62,60.05 153.62,59.08 156.99,55.71 156.99,55.21 156.99,55.2 156.99,54.52 162.46,49.04 v4(162.46,48.42)
  GND5 w0.086: v5(161.74,48.22) 161.94,48.42 v4(162.46,48.42)
  BOTTOM w0.086: v5(161.74,48.22) 161.74,47.05 162.41,46.37 164.45,46.37 RZ69.2 164.52,45.86 165.22,45.16 166.5,45.16 166.54,45.12 166.72,45.12 166.88,44.96 UZ12.18
TPM_PIRQ#_R: length 2.3
  TOP w0.086: RC560.2 151.83,63.76 152.08,63.52 v2(152.08,63.32) v1(151.68,62.92)
  BOTTOM w0.086: v2(152.08,63.32) 151.64,63.76 UC1.AP8
TRST#_XDP: length 24.6
  GND1 w0.086: v3(82.33,87.22) 82.27,87.15 82.27,86.74 v4(82.26,86.74) ; v3(60.57,88.48) 60.57,88.85 v4(60.8,89.08)
  IN4 w0.051: v4(60.8,89.08) 61.32,88.56 62.84,88.56 63.8,89.52 65.25,89.52 65.53,89.24 68.09,89.24 68.24,89.09 80.19,89.09 82.26,87.02 v4(82.26,86.74)
TS_EN: length 4.7
  TOP w0.254: RV326.2 183.1,40.8 RV323.2 ; UZ41.3 184.83,40.45 v1(184.56,40.73) 184.54,40.75 RV323.2 ; RV306.2 182.01,40.75 RV323.2
TS_I2C_SCL: length 68.7
  TOP w0.086: v1(154.64,71.17) 153.96,71.85 v2(153.96,71.87)
  IN2 w0.061: v4(190.26,38.59) 189.64,39.22 187.77,39.22 187.42,39.56 186.87,39.56 186.29,38.98 179.41,38.98 178.83,39.56 177.69,39.56 175.91,41.33 175.91,42.22 173.91,44.22 173.91,47.54 169.02,52.43 168.28,52.43 167.31,53.4 165.6,53.4 164.4,54.6 162.27,54.6 160,56.87 160,57.96 161.33,59.29 161.33,60.92 162.17,61.76 162.17,66.23 162.02,66.38 160.74,66.38 159.91,67.2 157.13,67.2 156.89,67.44 156.89,67.98 156.63,68.24 156.63,68.8 155.67,69.77 155.67,70.94 154.74,71.87 v2(153.96,71.87)
  GND5 w0.086: v5(191.13,38.44) 190.97,38.59 v4(190.26,38.59)
  BOTTOM w0.076: v2(153.96,71.87) 153.82,71.87 UC1.U6
  BOTTOM w0.086: RV99.1 191.13,37.56 v5(191.13,38.44) 191.13,39.66 190.7,40.09 JTS1.6
TS_I2C_SDA: length 64.2
  GND1 w0.086: v3(189.1,38.05) 189.41,38.36 v4(189.41,38.5)
  IN2 w0.061: v4(189.41,38.5) 189.35,38.44 188.55,38.44 188.21,38.77 187.32,38.77 187.09,38.54 179.22,38.54 178.65,39.12 177.5,39.12 175.43,41.19 174.8,41.19 170.04,45.95 169.58,45.95 166.84,48.69 166.84,49.22 156.02,60.04 156.02,66.57 155.29,67.31 155.29,67.92 155.73,68.37 155.73,68.97 153.97,70.74 153.97,71.06 v2(153.17,71.87)
  GND5 w0.086: v5(189.59,37.94) 189.59,38.32 v4(189.41,38.5)
  BOTTOM w0.076: UC1.U7 v2(153.17,71.87)
  BOTTOM w0.086: JTS1.5 189.9,39.73 190.25,39.38 CV54.1 190.25,37.75 190.67,37.33 RV98.1 190.31,36.66 189.59,37.38 v5(189.59,37.94)
TS_INT#: length 75.6
  GND1 w0.086: v3(192.92,39.71) 193.18,39.71 v4(193.64,39.25)
  IN2 w0.061: v4(193.64,39.25) 193.23,38.84 192.78,38.84 191.97,38.03 190.65,38.03 190.43,37.81 186.96,37.81 186.86,37.91 178.96,37.91 178.38,38.49 177.24,38.49 175.17,40.56 174.54,40.56 169.83,45.27 167.86,45.27 165.97,47.17 165.97,49.21 162.95,52.23 161.93,52.23 160.28,53.88 160.28,54.9 154.79,60.38 154.79,62.95 153.62,64.12 153.62,66.78 154.15,67.32 154.15,67.89 154.65,68.39 154.65,68.84 153.63,69.86 152.74,69.86 151.63,70.98 151.09,70.98 150.43,71.64 150.43,71.93 149.91,72.45 149.01,72.45 148.46,73 v4(148.1,73)
  GND5 w0.086: v4(193.64,39.25) 193.64,39.38 v5(193.36,39.66) ; v5(148.76,72.91) 148.67,73 v4(148.1,73)
  BOTTOM w0.086: UC1.N12 149.19,74.09 149.19,73.08 149.02,72.91 v5(148.76,72.91) ; v1(193.74,39.28) v5(193.36,39.66) 191.81,39.66 191.5,39.97 JTS1.7
TYPEC_CON_SEL1: length 39.4
  IN4 w0.051: v4(154.54,70.86) 154.75,70.86 156.52,72.63 159.62,72.63 159.68,72.69 159.92,72.69 160.65,71.97 161.92,71.97 v4(162.06,71.83)
  GND5 w0.086: v4(154.54,70.86) 154.22,71.18 v5(154.18,71.18) ; v4(162.06,71.83) 162.14,71.75 v5(162.14,71.35)
  BOTTOM w0.086: v5(162.14,71.35) 162.76,71.35 v1(163.07,71.04) 163.21,70.9 165.21,70.9 165.69,71.38 165.69,72.36 165.83,72.5 174.76,72.5 175.46,71.8 175.46,69.06 173.72,67.32 170.01,67.32 168.83,66.13 168.83,64.61 168.34,64.13 RC555.1 168.98,63.01 RC556.1
TYPEC_CON_SEL2: length 41.7
  IN4 w0.051: v4(155.31,70.06) 155.31,70.97 156.15,71.82 161.39,71.82 161.93,71.28 162.33,71.28 162.84,70.77 163.45,70.77 v4(163.49,70.72)
  GND5 w0.086: v5(154.83,69.86) 155.1,69.86 v4(155.31,70.06) ; v4(163.49,70.72) 163.49,70.78 v5(163.91,71.2)
  BOTTOM w0.086: RC554.1 168.36,61.53 168.34,61.54 RC553.1 169.17,62.23 169.55,62.61 169.55,64.36 169.04,64.87 169.04,66.05 170.1,67.1 173.8,67.1 175.67,68.97 175.67,71.89 174.85,72.72 168.32,72.72 167.59,73.44 166.29,73.44 v1(166,73.15) 165.48,72.63 165.48,71.47 165.12,71.11 163.99,71.11 v5(163.91,71.2)
TYPEC_ID: length 7.3
  TOP w0.086: RE343.1 255.11,60.92 CE62.1 255.44,61.25 255.44,61.68 255.85,62.09 257.14,62.09 257.42,61.81 v1(257.92,61.81) 258.41,61.81 259.17,61.05 259.75,61.05 UE1.F2
UART_MISO: length 7.1
  TOP w0.086: v3(31.98,71.61) 31.92,71.61 v1(31.42,71.12) 31.13,70.82 31.13,70.32 RT346.2 30.6,70.03 30.31,69.74 30.31,68.76 RT82.1 31.76,67.31 RT83.2
  GND1 w0.086: v3(31.98,71.61) v4(31.98,72.11)
  GND5 w0.086: v5(31.72,71.53) 31.98,71.79 v4(31.98,72.11)
UART_MISO_R: length 55.4
  TOP w0.086: v3(32.88,69.12) RT178.1 RT344.1 RT346.1
  GND1 w0.086: v4(32.97,68.64) 32.96,68.65 32.96,69.03 v3(32.88,69.12)
  IN3 w0.061: v4(26.26,43.49) 26.14,43.61 24.44,43.61 24.06,43.23 24.06,41.31 26.59,38.78 35.01,38.78 36.92,40.69 36.92,43.11 36.67,43.37 36.67,46.22 37.35,46.9 37.89,46.9 39.46,48.46 39.46,50.46 38.04,51.87 38.04,54.74 38.19,54.89 38.19,59.63 37.53,60.29 37.53,64.02 36.12,65.43 36.12,66.9 35.5,67.51 35.5,67.75 35.25,68 33.61,68 v4(32.97,68.64)
  GND5 w0.086: v4(26.26,43.49) 26.6,43.49 v5(26.73,43.62)
UART_MOSI: length 9.8
  TOP w0.086: v2(32.58,72.17) 32.58,71.46 v1(32.8,71.24) 33.09,70.95 33.82,70.95 RT81.1 34.84,70.06 35.63,69.27 RT345.2 35.63,69.07 34.78,68.23 RT83.1
  BOTTOM w0.086: v2(32.58,72.17) 32.58,71.88 UT5.E2
UART_MOSI_R: length 55.4
  TOP w0.086: RT178.2 33.73,69.17 RT343.1 v3(34.71,69.17)
  GND1 w0.086: v3(34.71,69.17) 34.71,69 35.04,68.67 v4(35.03,68.67)
  IN3 w0.061: v4(26.23,44.08) 25.95,43.8 24.36,43.8 23.87,43.31 23.87,43.15 23.87,41.23 26.51,38.59 35.09,38.59 37.77,41.28 37.77,42.53 37.01,43.29 37.01,46.3 37.43,46.71 37.97,46.71 39.64,48.39 39.64,50.54 38.23,51.95 38.23,54.66 38.38,54.81 38.38,59.71 37.72,60.37 37.72,64.1 36.3,65.51 36.3,66.97 35.69,67.59 35.69,67.83 34.99,68.52 34.99,68.61 35.04,68.67 v4(35.03,68.67)
  GND5 w0.086: v5(26.73,44.12) 26.28,44.12 v4(26.23,44.08)
UG1_ISL9538: length 26.9
  IN1 w1.016: 51.35,36.78 51.34,36.79 50.34,36.79 49.5,37.63 49.5,38.08 48.65,38.93 48.65,40.87 52.24,44.46 52.24,54.67 50.41,56.5 47.22,56.5
  vias: v2(52.49,37.46) v2(52.5,36.87) v4(45.94,55.79) v4(45.95,56.37) v5(45.46,56.38) v5(45.62,56.74)
UG2_ISL9538: length 19.7
  TOP w0.086: v2(66.23,54.25) v1(66.23,53.73)
  IN1 w1.016: 55.95,40.09 55.95,40.1 58.73,42.88 61.94,42.88 63.42,44.36 63.42,51.38 65.44,53.41
  vias: v2(54.83,39.9) v2(55.26,39.48) v2(65.64,54.25)
UIM_CLK: length 106.9
  IN4 w0.051: JNGFF2.32 231.66,80.9 230.18,82.38 230.18,90.44 231.52,91.78 237.28,91.78 237.91,91.14 240.07,91.14 240.37,90.85 arc(240.94,90.5) 241.6,90.38 245.63,86.35 269.89,86.35 273.62,82.63 273.62,77.88 277.27,74.22 277.27,72.31 279.22,70.36 279.22,67.72 283.22,63.73 283.22,62.16 285.33,60.05 285.33,52.97 285.84,52.45 285.84,47.96 v2(285.13,47.25)
  BOTTOM w0.086: v2(285.13,47.25) JSIM1.3 284.05,48.23 283.51,47.68 282.11,47.68 280.48,46.06 280.48,44.89 CZ38.1
UIM_DATA: length 111.6
  IN4 w0.051: v2(286.68,57.26) 285.68,58.27 285.68,60.2 283.57,62.31 283.57,63.87 279.57,67.87 279.57,70.51 277.62,72.45 277.62,74.36 273.96,78.02 273.96,82.77 270.04,86.7 245.79,86.7 241.77,90.71 arc(241.03,90.86) 240.4,91.3 239.54,92.16 231.41,92.16 229.84,90.59 229.84,82.25 231.67,80.42 232.71,80.42 JNGFF2.34
  BOTTOM w0.117: RZ335.2 CZ39.1 285.01,58.66 v1(285.13,58.66) 285.86,58.66 286.07,58.45 286.07,57.87 v2(286.68,57.26) 287.46,56.48 288.13,56.48 291.58,53.04 293.34,53.04 298.15,48.23 JSIM1.7
UIM_RESET: length 103.4
  IN4 w0.051: v2(244.04,86.27) 244.3,86 269.75,86 273.27,82.48 273.27,77.73 276.93,74.07 276.93,72.17 278.87,70.22 278.87,67.58 282.87,63.58 282.87,62.02 284.98,59.91 284.98,52.82 285.46,52.34 285.46,51.16 285.07,50.77 v4(284.65,50.77)
  GND5 w0.127: v4(284.65,50.77) v5(285.15,50.77)
  BOTTOM w0.076: 231.44,81.59 231.63,81.4 JNGFF2.30
  BOTTOM w0.086: v2(244.04,86.27) 244.04,87.56 240.61,90.99 240.12,90.99 238.96,92.16 237.58,92.16 236.77,91.35 231.41,91.35 230.47,90.41 230.47,89.42 231.08,88.81 231.08,87.56 231.28,87.36 231.28,81.75 231.44,81.59 ; v1(280.14,50.28) 280.53,50.67 280.53,51.01 280.15,51.38 CZ40.1 280.58,51.42 281.23,50.77 JSIM1.2 v5(285.15,50.77)
UPD1_HPD: length 13.5
  TOP w0.086: RE553.2 261.87,46.74 261.95,46.82 DZ107.2 262.61,46.82 262.61,47.19 263.24,47.81 v3(263.47,47.81) ; UE1.K7 v2(263.82,57.04)
  GND1 w0.086: v4(263,48.05) 263,48.01 263.17,47.84 263.44,47.84 v3(263.47,47.81)
  IN1 w0.051: v4(263,48.05) 263.54,48.59 263.54,49.79 264.29,50.54 264.29,56.57 v2(263.82,57.04)
UPD1_SMBCLK: length 297
  TOP w0.086: RPE12.3 260.76,45.03 v3(260.55,44.81) ; UE1.C3 v2(260.62,63.38) ; RT150.1 27.02,38.44 26.92,38.44 26.02,37.54 QT2.1 27.03,37.44 v2(27.22,37.25)
  GND1 w0.086: v3(260.55,44.81) 260.6,44.87 v4(260.6,45.31)
  IN1 w0.051: v4(169.36,27.85) 169.82,27.39 170.2,27.39 170.87,28.07 172.19,28.07 173.71,29.58 180.04,29.58 182.07,27.56 195.16,27.56 195.76,26.95 228.45,26.95 229.54,28.05 233.57,28.05 234.58,27.05 241.81,27.05 242.54,27.77 250.49,27.77 251,27.27 253.34,27.27 254.45,28.38 254.45,29.19 256.96,31.71 256.96,38.08 258.28,39.4 258.28,40.93 260.19,42.83 260.19,44.9 v4(260.6,45.31)
  IN4 w0.051: v2(260.62,63.38) 260.23,62.99 260.23,60.84 260.61,60.46 263.01,60.46 263.06,60.41 263.92,60.41 264.41,59.92 264.41,57.06 263.98,56.63 263.64,56.63 263.42,56.4 263.42,56.02 263.28,55.88 262.77,55.88 262.63,55.74 262.63,55.18 262.18,54.73 262.18,51.79 261.75,51.35 261.75,51.14 260.99,50.38 260.99,47.29 260.79,47.09 260.79,46.67 260.25,46.14 260.25,45.5 260.44,45.31 v4(260.6,45.31) ; v4(169.36,27.85) 169.26,27.75 166.03,27.75 164.62,29.16 160.72,29.16 157.74,32.14 125.2,32.14 124.88,32.46 95.53,32.46 95.17,32.82 92.37,32.82 90.23,34.96 90.23,40.18 89.65,40.75 89.65,42.25 87.63,44.28 80.95,44.28 80.52,44.71 80.41,44.82 78.28,44.82 77.77,44.31 75.73,44.31 74.82,45.22 73.95,45.22 73.37,44.64 70.18,44.64 68.84,43.29 65.02,43.29 63.4,41.66 59.79,41.66 59.27,42.19 54.19,42.19 53.49,42.88 51.57,42.88 51.11,42.43 48.36,42.43 46.46,40.52 37.28,40.52 36.21,39.46 34.38,39.46 33.34,38.41 32.83,38.41 31.94,37.52 27.5,37.52 v2(27.22,37.25)
  BOTTOM w0.086: v2(27.22,37.25) 27.55,36.92 27.55,36.5 v1(27.94,36.1)
UPD1_SMBDAT: length 296.5
  TOP w0.086: UE1.B4 v2(261.42,64.18) ; QT2.4 27.56,36.14 27.37,35.95 27.37,35.34 RT151.1 26.97,35.34 26.97,35.67 v2(26.69,35.95) ; v3(261.09,46.14) 260.72,46.14 260.26,45.68 RPE12.4
  GND1 w0.086: v3(261.09,46.14) 260.88,46.14 v4(260.63,45.89)
  IN1 w0.051: v4(260.63,45.89) 259.89,45.14 259.89,42.96 257.96,41.04 257.96,39.53 256.64,38.21 256.64,31.84 254.13,29.33 254.13,28.52 253.19,27.57 251.12,27.57 250.62,28.08 236.29,28.08 235.89,27.67 234.4,27.67 233.72,28.36 229.42,28.36 228.91,27.85 222.12,27.85 221.53,27.26 207.19,27.26 206.27,28.18 203.93,28.18 203.27,27.52 195.62,27.52 195.28,27.86 182.19,27.86 180.15,29.9 173.57,29.9 172.06,28.38 170.55,28.38 v4(169.99,27.82)
  IN4 w0.051: v2(26.69,35.95) 26.71,35.95 27.98,37.22 32.07,37.22 32.96,38.11 33.47,38.11 34.51,39.15 36.34,39.15 37.4,40.22 46.59,40.22 48.49,42.12 51.24,42.12 51.7,42.58 53.37,42.58 54.06,41.88 59.14,41.88 59.66,41.36 60.2,41.36 63.6,41.36 65.23,42.99 68.96,42.99 70.31,44.33 73.49,44.33 74.08,44.92 74.69,44.92 75.61,44 77.92,44 78.43,44.51 80.28,44.51 80.39,44.41 80.82,43.98 87.5,43.98 89.35,42.13 89.35,40.62 89.92,40.05 89.92,34.81 92.23,32.5 95.04,32.5 95.4,32.14 124.75,32.14 125.06,31.82 157.6,31.82 160.59,28.84 164.49,28.84 165.9,27.42 169.69,27.42 169.99,27.72 v4(169.99,27.82) ; v2(261.42,64.18) 261,63.77 261,60.75 261.15,60.6 263.96,60.6 264.58,59.98 264.58,56.35 264.08,55.84 263.64,55.84 263.44,55.63 263.44,55.3 262.7,54.56 262.7,51.88 262.06,51.23 262.06,51.01 261.29,50.25 261.29,47.17 261.09,46.96 261.09,46.35 v4(260.63,45.89)
UPD1_SMBINT#: length 302.7
  TOP w0.086: v1(30.88,35.81) 30.74,35.67 v2(29.99,35.67) 29.99,36.35 RT156.1 ; UE1.F10 v2(266.96,60.98)
  GND1 w0.117: v3(258.92,66.84) 258.92,66.87 258.61,67.17 v4(258.61,67.26)
  IN1 w0.051: v4(170.88,27.33) 170.88,27.12 171.07,26.92 171.72,26.92 173.56,28.76 176.15,28.76 176.46,28.45 179.86,28.45 181.22,27.1 194.97,27.1 195.59,26.48 228.64,26.48 229.74,27.58 233.35,27.58 234.37,26.55 241.97,26.55 242.73,27.31 250.3,27.31 250.81,26.81 253.58,26.81 254.94,28.18 254.94,28.99 257.46,31.5 257.46,34.14 258.96,35.65 258.96,40.74 260.89,42.68 260.89,44.55 261.9,45.55 262.61,45.55 263.34,46.29 263.47,46.29 266.13,48.95 266.13,51.42 268.1,53.38 268.1,54.68 269.08,55.66 269.08,58.46 266.96,60.58 v2(266.96,60.98)
  IN2 w0.061: v2(266.96,60.98) 266.96,61.16 266.69,61.43 265.94,61.43 265.79,61.58 265.79,64.85 263.69,66.96 261.59,66.96 261.24,67.31 258.67,67.31 v4(258.61,67.26)
  IN4 w0.051: v4(170.88,27.33) 170.11,26.56 162.29,26.56 160.74,28.11 160.29,28.11 158.16,30.23 110.44,30.23 109.3,31.37 95.11,31.37 94.73,31.75 91.97,31.75 89.21,34.51 89.21,39.76 88.64,40.33 88.64,40.8 87.72,41.72 87.48,41.72 85.93,43.27 73.57,43.27 73.21,43.62 70.6,43.62 67.42,40.43 59.58,40.43 58.84,41.17 53.77,41.17 53.07,41.87 51.99,41.87 51.54,41.41 48.79,41.41 47.38,40.01 47.38,37.44 47.03,37.09 46.45,37.09 45.31,38.24 42.38,38.24 41.89,38.73 38.91,38.73 38.46,38.29 34.87,38.29 33.83,37.25 33.32,37.25 31.74,35.67 v2(29.99,35.67)
UPD1_SMBINT#_R: length 18
  TOP w0.086: v2(37.53,85.07) 37.29,85.07 36.72,85.65 RT60.2 RT68.1 v1(35.42,86.67)
  IN1 w0.051: v2(37.53,85.07) 37.53,82.28 35.4,80.15 35.4,77.75 35.86,77.29 35.86,74.34 35.68,74.16 v4(35.33,74.16)
  GND5 w0.086: v5(35.17,73.69) 35.33,73.85 v4(35.33,74.16)
  BOTTOM w0.076: UT5.B6 33.97,73.28 34.35,73.28 34.49,73.41
  BOTTOM w0.086: v5(35.17,73.69) 34.76,73.69 34.49,73.41
UPD1_SMBUS_CLK_Q: length 31
  TOP w0.086: v1(35.13,89.73) QT1.6 36.18,89.2 36.72,88.66 RT67.1 36.72,87.69 v3(36.7,87.66) 35.68,87.66 RT375.2
  GND1 w0.086: v4(36.13,87.35) 36.45,87.66 v3(36.7,87.66) ; v3(26.97,69.73) 26.97,69.79 v4(26.63,70.12)
  IN2 w0.061: v4(26.63,70.12) 28.09,70.12 28.26,69.95 28.96,69.95 29.59,70.59 29.59,71.37 30.85,72.63 31.74,72.63 32.66,73.54 v4(32.78,73.54)
  IN3 w0.061: v4(36.13,87.35) 34.54,85.76 34.54,79.05 33.18,77.69 33.18,75.51 33.65,75.04 33.65,73.73 33.43,73.52 32.81,73.52 v4(32.78,73.54)
  GND5 w0.086: v4(32.78,73.54) 32.81,73.52 33.33,73.52 33.72,73.12 v5(33.72,73.03)
UPD1_SMBUS_DAT_Q: length 37.8
  TOP w0.086: QT1.3 v3(38.08,91.03)
  GND1 w0.086: v4(35.46,71.73) 35.48,71.74 v3(36.57,71.74) ; v3(38.08,91.03) 37.98,91.03 v4(37.62,90.67) ; v4(28.2,69.26) 28.2,69.39 v3(27.86,69.73)
  IN1 w0.051: v4(35.46,71.73) 35.46,71.75 36.16,72.45 36.16,77.41 35.7,77.87 35.7,80.02 36.87,81.19 38.32,81.19 38.65,81.52 38.65,83.3 37.99,83.96 37.99,85.99 37.43,86.55 37.43,90.48 v4(37.62,90.67)
  IN2 w0.061: v4(28.2,69.26) 28.53,69.59 33.27,69.59 34.31,70.62 34.31,71.68 34.37,71.74 35.45,71.74 v4(35.46,71.73)
  GND5 w0.086: v5(36.49,71.71) 35.48,71.71 v4(35.46,71.73)
  BOTTOM w0.076: 34.43,73.03 UT5.A5
  BOTTOM w0.086: 34.43,73.03 34.6,73.19 34.87,73.19 35.03,73.03 v1(35.56,73.03) 36.04,73.03 RT59.2 36.47,71.74 v5(36.49,71.71)
UPD2_HPD: length 12.6
  TOP w0.086: v1(252.76,50.33) 253.09,50 DZ106.2 254.37,50.62 254.37,53.3 254.88,53.81 256.97,53.81 257.34,54.19 257.34,55.28 RE554.2 257.05,56 259.19,56 UE1.M1
UPD2_SMBCLK: length 306.3
  TOP w0.086: v1(38.61,88.45) 38.88,88.18 v3(38.88,87.99) 38.73,87.84 38.24,87.84 38.02,87.62 RT58.1 37.63,87.77 38.08,88.21 QT1.1 ; RE303.1 251.12,68.67 v2(251.03,68.75) ; UE1.D7 v2(263.82,62.58)
  GND1 w0.086: v3(38.88,87.99) 39.39,87.99 v4(39.41,88.02)
  IN2 w0.061: v4(257.59,67.73) 257.69,67.62 257.69,66.48 258.24,65.92 259.17,65.92 259.83,66.58 260.36,66.58 261.84,65.09 261.84,64.49 262.6,63.73 262.6,63.22 262.86,62.96 263.44,62.96 v2(263.82,62.58)
  IN3 w0.061: v4(257.59,67.73) 257.24,68.08 253.63,68.08 252.95,68.75 v2(251.03,68.75) 249.87,67.59 247.45,67.59 241.89,62.03 238.93,62.03 238.4,61.49 237.14,61.49 235.7,62.93 234.32,62.93 233.92,62.52 228.86,62.52 228.2,61.86 228.2,61 226.81,59.61 226.81,53.15 221.47,47.8 214.19,47.8 211.18,44.79 201.31,44.79 201.31,44.79 201.06,44.79 200.18,45.67 192.03,45.67 190.08,47.62 188.16,47.62 186.52,49.25 185.04,49.25 178.81,55.48 178.81,57.24 175.42,60.62 175.42,67.13 173.14,69.41 173.14,78.69 173.51,79.06 173.51,79.37 173.51,79.37 173.51,79.95 173.51,79.96 173.51,82.13 171.98,83.65 170.88,83.65 169.61,84.92 160.43,84.92 157.6,87.75 157.22,87.75 157.14,87.67 147.18,87.67 147,87.84 141.06,87.84 139.42,86.2 131.04,86.2 129.44,87.8 125.59,87.8 124.79,88.6 106.59,88.6 106.59,88.6 106.33,88.6 105.71,87.97 104.61,87.97 102.88,86.24 80.99,86.24 78.66,88.58 77.77,88.58 70.73,88.58 70.33,88.17 70.2,88.05 66.36,88.05 65.45,87.14 63.8,87.14 63.46,86.79 60.73,86.79 58.37,84.44 51.7,84.44 49.98,86.15 48.48,86.15 47.15,87.49 43.17,87.49 43.1,87.55 43.1,88.82 43.04,88.88 42.92,88.88 42.86,88.82 42.86,87.55 42.8,87.49 42.68,87.49 42.62,87.55 42.62,88.82 42.56,88.88 42.43,88.88 42.37,88.82 42.37,87.55 42.31,87.49 42.19,87.49 42.13,87.55 42.13,89.66 42.07,89.72 41.95,89.72 41.89,89.66 41.89,87.55 41.82,87.49 41.7,87.49 41.64,87.55 41.64,89.66 41.58,89.72 41.46,89.72 41.4,89.66 41.4,87.55 41.34,87.49 41.21,87.49 41.15,87.55 41.15,89.71 41.09,89.77 40.97,89.77 40.91,89.71 40.91,87.55 40.85,87.49 39.95,87.49 v4(39.41,88.02)
UPD2_SMBDAT: length 320.7
  TOP w0.086: QT1.4 36.38,91.03 37.36,92.01 42.16,92.01 v1(42.51,91.66) 43.12,91.04 v2(43.12,90.79) ; UE1.E7 v2(263.82,61.78) ; RE302.1 254.11,71.84 v2(254.34,71.61)
  IN1 w0.051: v2(36.75,85.05) 37.15,85.45 37.15,90.76 37.58,91.19 42.72,91.19 v2(43.12,90.79)
  IN2 w0.061: v2(254.34,71.61) 253.54,70.81 253.54,68.86 253.89,68.51 256.21,68.51 257.29,67.42 257.29,66.34 259.83,63.8 259.83,63.25 260.09,63 260.82,63 261.02,62.81 261.02,62.37 261.18,62.2 263.12,62.2 263.54,61.78 v2(263.82,61.78)
  IN3 w0.061: v2(254.34,71.61) 254.34,71.41 252.22,69.29 248.7,69.29 247.38,67.97 246.3,67.97 244.9,66.57 244.9,65.48 243.28,63.86 241.44,63.86 240.3,62.72 237.33,62.72 236.56,63.49 231.33,63.49 230.71,62.87 228.46,62.87 227.3,61.71 227.3,60.54 226.49,59.74 226.49,53.28 221.33,48.12 214.06,48.12 211.05,45.1 201.44,45.1 201.19,45.1 200.31,45.98 192.16,45.98 190.21,47.93 188.29,47.93 186.65,49.57 185.17,49.57 179.12,55.61 179.12,57.37 175.73,60.75 175.73,67.26 173.45,69.54 173.45,78.56 173.82,78.93 173.82,79.19 173.82,79.24 173.83,79.24 173.83,80.08 173.82,80.09 173.82,82.66 173.82,83.47 173.33,83.96 172.42,83.96 170.6,85.77 160.02,85.77 157.73,88.07 157.09,88.07 157.01,87.98 147.31,87.98 147.13,88.16 140.93,88.16 139.29,86.51 131.17,86.51 129.57,88.11 125.74,88.11 124.93,88.93 106.2,88.93 105.56,88.29 104.48,88.29 102.75,86.56 84.39,86.56 83.29,87.65 80.64,87.65 79.26,89.02 66.51,89.02 65.31,87.82 60.6,87.82 60.14,87.36 60.14,86.65 58.24,84.75 51.83,84.75 50.11,86.47 48.61,86.47 44.29,90.79 v2(43.12,90.79)
  BOTTOM w0.086: v2(36.75,85.05) 36.75,81.31 38.29,79.77 38.29,77.52 38.02,77.25 38.02,73.24 RT59.1
UPD2_SMBINT#: length 291.2
  TOP w0.086: RT60.1 37.95,85.4 37.95,84.53 37.97,84.52 37.97,84.51 38.24,84.24 39.9,84.24 v2(40.15,84.49) ; UE1.F5 v2(262.22,60.98) ; v2(261.31,71.05) 261.28,71.03 RE91.1
  IN2 w0.061: v4(256.84,67.28) 257.07,67.05 257.07,65.5 260.41,62.16 260.81,62.16 260.99,61.98 260.99,61.63 261.27,61.35 261.84,61.35 262.21,60.98 v2(262.22,60.98)
  IN3 w0.061: v2(261.31,71.05) 261.18,70.93 261.18,69 259.97,67.79 258.51,67.79 258.01,67.28 v4(256.84,67.28) 256.69,67.14 247.45,67.14 242.02,61.71 239.06,61.71 238.53,61.18 233.98,61.18 232.98,62.17 229.01,62.17 228.52,61.68 228.52,60.87 227.12,59.48 227.12,53.01 221.59,47.48 214.32,47.48 211.31,44.47 200.93,44.47 200.05,45.35 191.46,45.35 190.42,46.39 187.21,46.39 186.32,47.27 185.57,47.27 182.77,50.07 182.77,51.07 178.49,55.35 178.49,57.1 174.88,60.72 174.88,67.23 172.82,69.28 172.82,78.82 173.19,79.19 173.19,79.5 173.2,79.5 173.2,79.82 173.19,79.83 173.19,82 171.85,83.34 170.75,83.34 169.48,84.61 160.3,84.61 157.47,87.44 157.35,87.44 157.27,87.35 147.05,87.35 146.87,87.53 141.19,87.53 139.55,85.88 130.91,85.88 129.31,87.48 125.46,87.48 124.66,88.28 106.46,88.28 105.84,87.66 104.74,87.66 103.01,85.93 80.86,85.93 78.53,88.26 77.9,88.26 70.86,88.26 70.64,88.04 70.64,88.04 70.33,87.73 66.49,87.73 65.58,86.82 63.93,86.82 63.59,86.48 60.86,86.48 58.5,84.12 51.57,84.12 49.96,85.73 45.01,85.73 43.4,84.12 40.52,84.12 v2(40.15,84.49)
  BOTTOM w0.086: v1(39.84,83.96) 40.15,84.26 v2(40.15,84.49)
UPD2_SMBINT#_R: length 7.3
  TOP w0.086: v1(30.95,37.28) RT156.2 RT164.1 28.52,37.74 28.52,40.5 v2(28.62,40.6)
  BOTTOM w0.076: UT11.B6 28.97,41.88 28.97,41.33
  BOTTOM w0.086: v2(28.62,40.6) 28.97,40.95 28.97,41.33
UPD2_SMBUS_CLK_Q: length 16.5
  TOP w0.086: QT2.6 28.06,37.58 RT150.2 28.01,38.62 RT384.2 28.01,40.66 v2(28.02,40.67)
  IN3 w0.061: v2(28.02,40.67) 28.21,40.86 28.21,42.75 27.71,43.24 27.71,44.42 27.08,45.05 26.61,45.05 26.13,45.54 25.86,45.54 23.97,47.43 v4(23.97,47.58)
  GND5 w0.086: v4(23.97,47.58) 23.97,48.19 v5(24.27,48.5)
  BOTTOM w0.076: UT11.B5 28.23,41.96 28.33,41.87 28.33,41.87 28.47,41.72 28.47,41.42
  BOTTOM w0.086: 28.47,41.42 28.47,41.14 28.02,40.69 v2(28.02,40.67) 27.97,40.62 RT163.1
UPD2_SMBUS_DAT_Q: length 10.3
  TOP w0.086: RT383.2 RT151.2 26.26,35.9 QT2.3 25.27,36.89 25.16,36.89 RT189.1 25.7,37.88 25.7,37.88 26.01,38.2 26.01,39.67 v1(26.13,39.79) 26.48,40.14 v2(26.92,40.14)
  BOTTOM w0.086: UT11.A5 28.17,41.62 26.92,40.37 v2(26.92,40.14) 26.92,39.54 RT162.1
USB2_ID: length 2.8
  TOP w0.086: v1(154.17,66.43) 154.24,66.43 RC337.1 v3(155.08,67.27)
  GND1 w0.086: v4(154.68,67.57) 154.71,67.57 155.01,67.27 v3(155.08,67.27)
  GND5 w0.086: v5(155.16,67.47) 154.78,67.47 v4(154.68,67.57)
  BOTTOM w0.086: UC1.AG3 154.9,67.21 v5(155.16,67.47)
USB2_VBUSSENSE: length 2.6
  TOP w0.086: RC338.1 154.52,68.24 v1(154.2,67.92) 153.83,67.55 v2(153.56,67.55)
  BOTTOM w0.086: v2(153.56,67.55) 153.83,67.55 UC1.AG4
USB3_PRX_C_DTX_N4: length 2.7
  TOP w0.088: UR1.5 276.72,57.39 276.52,57.59 275.96,57.59 275.72,57.83 275.72,58.1 275.59,58.23 275.45,58.23 CR14.2
USB3_PRX_C_DTX_P4: length 2.7
  TOP w0.088: UR1.4 276.69,57.79 276.67,57.76 276.04,57.76 275.89,57.91 275.89,58.17 275.66,58.4 275.45,58.4 CR13.2
USB3_PRX_DTX_N1: length 193.7
  TOP w0.088: v2(283.25,70.82) 282.98,70.55 282.31,70.55 282.14,70.72 DI4.9 DI4.1 280.66,70.72 280.48,70.54 277.19,70.54 275.97,71.76 273.34,71.76 v2(273.08,72.03)
  IN1 w0.062: JUSB1.5 288.55,72.2 288.44,72.09 286.59,72.09 285.03,70.53 283.54,70.53 v2(283.25,70.82) ; v4(222.23,45.72) 221.98,45.47 221.98,45.36 221.05,44.43 219.7,44.43 219.09,43.82 219.09,43.31 217.04,41.26 186.96,41.26 184.02,44.2 180.54,44.2 178.78,45.96 178.78,46.97 171.57,54.18 171.57,59.84 170.36,61.06 170.36,64.95 166.46,68.84 166.46,70.75 164.27,72.94 163.58,72.94 160.16,76.36 157.26,76.36 156.76,76.86 153.93,76.86 153.38,77.4 152.23,77.4 151.94,77.11 151.36,77.11 v2(151.19,76.94)
  IN4 w0.062: v2(273.08,72.03) 273.08,71.76 273.14,71.7 273.24,71.7 273.38,71.56 273.49,71.56 273.6,71.67 273.6,72.17 272.78,72.99 272.45,72.99 270.25,75.19 270.25,76.23 267.78,78.7 254.33,78.7 253.85,79.18 248.41,79.18 246.45,77.23 246.16,77.23 243.49,74.56 243.49,66.96 242.43,65.89 240.33,65.89 239.65,65.22 237.17,65.22 236.91,64.96 236.12,64.96 235.71,64.54 235.71,64.19 233.97,62.46 233.97,61.65 233.54,61.22 233.54,59.39 232.15,58 232.15,55.71 230.76,54.33 230.15,54.33 227.2,51.37 227.2,50.56 226.24,49.6 225.21,49.6 222.68,47.08 222.43,47.08 221.79,46.44 221.79,46.17 221.85,46.11 222.2,46.11 222.26,46.05 222.26,45.75 v4(222.23,45.72)
  BOTTOM w0.076: v2(151.19,76.94) 151.23,76.95 151.63,76.7 UC1.H8
USB3_PRX_DTX_N2: length 108.7
  TOP w0.088: v2(228.94,58.96) 229.14,59.16 229.14,59.17 229.14,59.66 228.98,59.82 UZ29.18 ; v2(182.6,45.37) 182.83,45.61 182.83,45.89 183.48,46.54 188.49,46.54 188.59,46.65 188.59,46.77 v2(188.41,46.95)
  IN4 w0.062: v2(188.41,46.95) 188.62,47.17 188.62,47.5 188.77,47.65 189.87,47.65 191.75,45.78 208.6,45.78 209.69,46.87 211.7,46.87 214.74,49.91 217.84,49.91 218.35,50.43 222.06,50.43 226.69,55.05 226.69,56.04 228.21,57.57 228.51,57.57 229.15,58.21 229.15,58.74 v2(228.94,58.96) ; v2(182.6,45.37) 182.82,45.6 182.82,45.86 182.63,46.05 180.46,46.05 176.67,49.84 176.67,53.96 174.12,56.51 174.12,61.65 173.5,62.27 173.5,62.95 172.03,64.42 172.03,66.1 168.32,69.81 165.83,69.81 162.7,72.94 161.53,72.94 160.7,73.77 159.76,73.77 159.53,74 158.34,74 157.8,74.53 157.8,75.86 156.99,76.67 153.87,76.67 153.76,76.79 153.39,76.79 153.25,76.65 153.25,76.53 v2(153.03,76.31)
  BOTTOM w0.076: v2(153.03,76.31) 153,76.29 152.84,76.29 UC1.J6
USB3_PRX_DTX_N3: length 202.3
  IN1 w0.062: v2(150.26,76.23) 150.26,76.29 150.01,76.54 149.92,76.54 149.54,76.16 143.88,76.16 143.26,76.78 143.26,77.51 143.32,77.58 143.32,78.67 143.88,79.23 143.88,83.45 140.88,86.45 131.5,86.45 130.15,87.81 124.58,87.81 123.31,89.08 112.65,89.08 111.68,90.05 93.62,90.05 92.3,88.73 88.13,88.73 86.93,89.93 81.05,89.93 80.53,89.42 63.67,89.42 62.51,88.26 56.75,88.26 55.87,87.38 50.66,87.38 47.01,83.73 45.6,83.73 42.72,80.84 41.35,80.84 39.46,78.95 39.46,78.34 37.66,76.54 37.66,70.66 37.83,70.49 37.83,51.43 37.4,50.99 37.4,49.65 35.78,48.03 35.78,44.74 33.52,42.48 32.61,42.48 30.64,40.51 30.64,35.49 25.01,29.85 25.01,29.3 23.94,28.22 23.94,27.89 24.02,27.81 24.19,27.81 24.28,27.71 v2(24.28,27.42)
  BOTTOM w0.076: v2(150.26,76.23) 150.32,76.25 UC1.J10
  BOTTOM w0.088: JUSB2.5 12.45,21.41 12.54,21.5 13.81,21.5 14.67,22.36 14.95,22.36 15.11,22.2 DI1.1 DI1.9 16.59,22.2 16.61,22.22 17.23,22.22 17.27,22.18 17.86,22.18 17.9,22.22 18.41,22.22 18.42,22.23 18.61,22.23 19.09,22.71 20.09,22.71 24.14,26.76 24.14,27.27 v2(24.28,27.42)
USB3_PRX_DTX_N4: length 194.9
  GND1 w0.088: v3(274.15,57.84) 274.15,58.14 274.24,58.23 274.4,58.23 v4(274.61,58.02)
  IN1 w0.062: v4(223.48,45.07) 223.4,44.98 223.4,44.23 222.99,43.82 219.91,43.82 219.64,43.56 219.64,43.1 216.78,40.24 212.49,40.24 212.1,40.63 186.85,40.63 183.82,43.67 180.08,43.67 174.1,49.65 174.1,50.52 171.04,53.58 171.04,59.61 169.21,61.44 169.21,65.36 165.93,68.64 165.93,69.24 162.97,72.19 162.97,72.37 162.36,72.98 161.85,72.98 161.01,73.82 161.01,74.76 160.43,75.35 156.2,75.35 155.96,75.1 154.41,75.1 154.06,75.45 151.09,75.45 150.65,75.9 150.65,77.42 150.49,77.58 150.11,77.58 149.73,77.95 149.73,78.45 149.92,78.64 150.05,78.64 v2(150.27,78.86)
  IN4 w0.062: v4(274.61,58.02) 274.33,58.3 274.21,58.3 274.06,58.45 274.06,59.62 275.05,60.61 275.05,65.52 273.52,67.04 272.72,67.04 271.9,67.86 271.9,72.07 269.54,74.43 269.54,75.17 268.01,76.69 268.01,77.33 267.57,77.77 257.25,77.77 256.9,77.41 255.83,77.41 255.31,77.93 249.19,77.93 247.96,76.7 246.39,76.7 245.37,75.68 245.37,72.82 244.78,72.24 244.78,67.43 242.06,64.71 237.39,64.71 235.85,63.18 235.85,62.01 234.05,60.21 234.05,58.51 232.72,57.18 232.72,55.5 232.43,55.2 232.43,53.78 230.93,52.28 228.9,52.28 227.71,51.1 227.71,50.16 223.92,46.37 223.37,46.37 223.15,46.15 223.15,45.36 223.2,45.32 223.34,45.32 223.48,45.17 v4(223.48,45.07)
  BOTTOM w0.076: UC1.E10 v2(150.27,78.86)
USB3_PRX_DTX_P1: length 193.7
  TOP w0.088: v2(273.08,71.31) 273.36,71.59 275.9,71.59 277.12,70.37 280.51,70.37 280.66,70.21 DI4.2 DI4.8 282.16,70.21 282.33,70.38 282.98,70.38 v2(283.25,70.11)
  IN1 w0.062: v2(151.17,77.64) 151.47,77.64 151.53,77.57 151.53,77.31 151.59,77.25 151.88,77.25 152.17,77.55 153.44,77.55 153.99,77 156.82,77 157.32,76.5 160.22,76.5 163.64,73.09 164.33,73.09 166.61,70.81 166.61,68.9 170.5,65.01 170.5,61.12 171.72,59.9 171.72,54.24 178.93,47.03 178.93,46.02 180.6,44.35 184.08,44.35 187.02,41.4 216.98,41.4 218.95,43.37 218.95,43.88 219.64,44.58 220.99,44.58 221.83,45.42 221.83,45.54 v4(221.65,45.72) ; JUSB1.6 288.55,71.81 288.42,71.94 286.65,71.94 285.09,70.38 283.53,70.38 v2(283.25,70.11)
  IN4 w0.062: v4(221.65,45.72) 221.65,46.5 222.37,47.22 222.62,47.22 225.15,49.74 226.18,49.74 227.06,50.62 227.06,51.43 230.09,54.47 230.7,54.47 232,55.77 232,58.06 233.4,59.45 233.4,61.28 233.83,61.71 233.83,62.52 235.56,64.25 235.56,64.6 236.06,65.1 236.85,65.1 237.11,65.37 239.59,65.37 240.27,66.04 242.37,66.04 243.35,67.02 243.35,74.62 246.1,77.37 246.39,77.37 248.35,79.33 253.91,79.33 254.39,78.84 267.84,78.84 270.39,76.29 270.39,75.25 272.51,73.14 272.84,73.14 273.74,72.23 273.74,71.61 273.55,71.42 273.18,71.42 v2(273.08,71.31)
  BOTTOM w0.076: UC1.G8 v2(151.17,77.64)
USB3_PRX_DTX_P2: length 108.7
  TOP w0.088: v2(188.99,46.95) 188.76,46.72 188.76,46.57 188.56,46.37 183.55,46.37 183,45.82 183,45.55 v2(183.18,45.37) ; v2(229.52,58.96) 229.32,59.16 229.32,59.24 229.31,59.24 229.31,59.66 229.48,59.82 UZ29.19
  IN4 w0.062: v2(229.52,58.96) 229.3,58.73 229.3,58.15 228.57,57.42 228.27,57.42 226.83,55.98 226.83,54.99 222.12,50.28 218.41,50.28 217.9,49.77 214.8,49.77 211.76,46.73 209.75,46.73 208.66,45.63 191.69,45.63 189.81,47.51 188.83,47.51 188.76,47.44 188.76,47.18 v2(188.99,46.95) ; v2(153,77) 153.06,76.94 153.82,76.94 153.93,76.82 157.05,76.82 157.95,75.92 157.95,74.59 158.4,74.14 159.59,74.14 159.82,73.92 160.76,73.92 161.59,73.08 162.76,73.08 165.89,69.95 168.38,69.95 172.17,66.16 172.17,64.48 173.64,63.01 173.64,62.33 174.26,61.71 174.26,56.57 176.82,54.02 176.82,49.9 180.52,46.19 182.69,46.19 182.97,45.92 182.97,45.59 v2(183.18,45.37)
  BOTTOM w0.076: UC1.H6 152.66,76.65 v2(153,77)
USB3_PRX_DTX_P3: length 202.2
  IN1 w0.062: v2(23.64,27.42) 23.79,27.56 23.79,28.28 24.87,29.36 24.87,29.91 30.5,35.55 30.5,40.57 32.55,42.62 33.46,42.62 35.63,44.8 35.63,48.09 37.25,49.71 37.25,51.05 37.69,51.49 37.69,70.43 37.51,70.6 37.51,76.6 39.32,78.4 39.32,79.01 41.29,80.98 42.66,80.98 45.54,83.87 46.95,83.87 50.6,87.53 55.81,87.53 56.69,88.4 62.45,88.4 63.61,89.56 80.47,89.56 80.99,90.08 86.99,90.08 88.19,88.87 92.24,88.87 93.56,90.19 111.74,90.19 112.71,89.22 123.37,89.22 124.64,87.95 130.21,87.95 131.56,86.6 140.94,86.6 144.03,83.51 144.03,79.17 143.47,78.61 143.47,77.52 143.4,77.45 143.4,76.84 143.94,76.3 149.48,76.3 149.86,76.68 149.99,76.68 150.02,76.68 150.23,76.89 v2(150.26,76.89)
  BOTTOM w0.076: v2(150.26,76.89) 150.32,76.91 UC1.H10
  BOTTOM w0.088: JUSB2.6 12.45,21.78 12.56,21.67 13.74,21.67 14.6,22.53 14.97,22.53 15.14,22.7 DI1.2 DI1.8 16.6,22.7 16.76,22.54 16.76,22.49 16.85,22.4 v7(17.57,22.4) 18.54,22.4 19.02,22.88 20.02,22.88 23.97,26.83 23.97,27.15 23.71,27.42 v2(23.64,27.42)
USB3_PRX_DTX_P4: length 194.9
  GND1 w0.088: v4(274.61,58.61) 274.41,58.41 274.23,58.41 274.15,58.49 v3(274.15,58.79)
  IN1 w0.062: v2(150.27,78.2) 150.27,78.43 150.21,78.49 149.98,78.49 149.88,78.39 149.88,78.01 150.17,77.73 150.55,77.73 150.79,77.48 150.79,75.96 151.15,75.6 154.12,75.6 154.48,75.25 155.9,75.25 156.14,75.49 160.49,75.49 161.16,74.82 161.16,73.88 161.91,73.13 162.42,73.13 163.12,72.43 163.12,72.25 166.08,69.3 166.08,68.7 169.36,65.42 169.36,61.5 171.19,59.68 171.19,53.64 174.25,50.58 174.25,49.71 180.14,43.81 183.88,43.81 186.91,40.78 212.16,40.78 212.55,40.39 216.72,40.39 219.5,43.16 219.5,43.62 219.85,43.97 222.93,43.97 223.25,44.29 223.25,44.55 223.19,44.61 222.75,44.61 222.66,44.71 222.66,44.83 v4(222.9,45.07)
  IN4 w0.062: v4(222.9,45.07) 223.01,45.18 223.01,46.21 223.31,46.51 223.86,46.51 227.57,50.22 227.57,51.16 228.84,52.43 230.87,52.43 232.28,53.84 232.28,55.26 232.58,55.56 232.58,57.24 233.91,58.57 233.91,60.27 235.71,62.07 235.71,63.24 237.33,64.86 242,64.86 244.63,67.49 244.63,72.3 245.22,72.88 245.22,75.74 246.33,76.84 247.9,76.84 249.13,78.08 255.37,78.08 255.89,77.55 256.84,77.55 257.19,77.91 267.63,77.91 268.16,77.39 268.16,76.75 269.68,75.23 269.68,74.49 272.04,72.13 272.04,67.92 272.78,67.18 273.59,67.18 275.19,65.58 275.19,60.55 274.21,59.56 274.21,58.51 274.27,58.45 274.45,58.45 v4(274.61,58.61)
  BOTTOM w0.076: UC1.F10 v2(150.27,78.2)
USB3_PTX_C_DRX_N1: length 14.5
  TOP w0.088: CI13.1 277.26,68.72 277.53,68.72 277.86,69.05 280.49,69.05 280.65,69.22 DI4.4 DI4.7 282.33,69.22 282.49,69.05 282.98,69.05 v2(283.25,69.32)
  IN1 w0.062: v2(283.25,69.32) 283.54,69.03 284.67,69.03 287.61,66.1 288.46,66.1 288.55,66.19 JUSB1.8
USB3_PTX_C_DRX_N2: length 2.2
  TOP w0.088: CZ151.2 228.36,58.67 228.36,59.05 228.13,59.28 228.13,59.58 227.98,59.73 UZ29.16
USB3_PTX_C_DRX_N3: length 9.3
  BOTTOM w0.088: JUSB2.8 12.45,27.42 12.55,27.52 13.01,27.52 13.64,26.89 13.64,24.47 13.69,24.42 13.69,24.37 14.11,23.96 14.16,23.96 14.26,23.85 14.82,23.85 14.98,23.7 DI1.4 DI1.7 16.62,23.7 16.78,23.86 16.95,23.86 17.1,23.71 17.24,23.71 CI5.1
USB3_PTX_C_DRX_N4: length 3.8
  TOP w0.088: UR1.3 276.74,58.19 276.62,58.3 276.33,58.3 276.08,58.55 276.08,59.76 275.7,60.14 275.38,60.14 CR32.2
USB3_PTX_C_DRX_P1: length 14.5
  TOP w0.088: v2(283.25,68.61) 282.98,68.88 282.49,68.88 282.33,68.72 DI4.6 DI4.5 280.69,68.72 280.52,68.88 277.93,68.88 277.6,68.55 277.26,68.55 CI16.1
  IN1 w0.062: JUSB1.9 288.55,65.78 288.38,65.95 287.55,65.95 284.61,68.89 283.54,68.89 283.26,68.61 v2(283.25,68.61)
USB3_PTX_C_DRX_P2: length 2.2
  TOP w0.088: UZ29.17 228.48,59.76 228.3,59.59 228.3,59.35 228.54,59.12 228.54,58.71 CZ150.2
USB3_PTX_C_DRX_P3: length 9.3
  BOTTOM w0.088: CI4.1 17.28,23.88 17.17,23.88 17.02,24.03 16.81,24.03 16.65,24.2 DI1.6 DI1.5 14.99,24.2 14.82,24.03 14.34,24.03 v7(14.05,24.31) 13.81,24.56 13.81,26.96 13.08,27.69 12.53,27.69 12.45,27.77 JUSB2.9
USB3_PTX_C_DRX_P4: length 3.8
  TOP w0.088: UR1.2 276.71,58.59 276.59,58.47 276.4,58.47 276.26,58.62 276.26,59.83 275.77,60.31 275.43,60.31 CR31.2
USB3_PTX_DRX_N1: length 189
  TOP w0.088: v2(273.1,69.02) 273.38,68.74 275.52,68.74 CI13.2
  IN1 w0.062: v4(151.86,85.59) 151.62,85.35 151.62,85 151.88,84.74 155.36,84.74 156.38,83.72 159.09,83.72 172.61,70.2 172.87,70.2 174.62,68.45 174.62,63.2 178.13,59.68 178.13,54.72 187.56,45.3 191.38,45.3 191.92,44.76 197.97,44.76 198.57,44.15 211.88,44.15 213.97,46.25 214.4,46.25 214.48,46.33 214.48,46.52 214.54,46.59 v4(214.82,46.59)
  IN4 w0.062: v2(273.1,69.02) 272.81,68.72 272.72,68.72 272.64,68.8 272.64,69.78 274.25,71.39 274.25,72.46 273,73.72 272.69,73.72 270.98,75.43 270.98,76.47 267.97,79.48 264.69,79.48 264.32,79.85 247.42,79.85 242.84,75.26 242.84,67.29 242.1,66.55 238.04,66.55 237.36,65.88 236.9,65.88 236.65,65.63 235.87,65.63 235.05,64.81 235.05,64.46 232.31,61.72 232.31,59.33 231.37,58.39 231.37,55.95 230.58,55.16 229.75,55.16 228.41,53.82 227.75,53.82 219.65,45.73 215.84,45.73 215.21,46.36 215.05,46.36 v4(214.82,46.59)
  GND5 w0.081: v4(151.86,85.59) 151.65,85.38 151.65,85.22 v5(151.76,85.12)
  BOTTOM w0.076: v5(151.76,85.12) 151.69,85.05 arc(151.66,85) 151.65,84.94 arc(151.63,84.85) 151.58,84.77 149.78,82.98 arc(149.56,82.71) 149.39,82.4 149.39,82.39 149.31,82.2 149.25,82.06 arc(149.23,82.01) 149.2,81.96 arc(149.09,81.8) 148.95,81.67 148.85,81.6 arc(148.73,81.44) 148.73,81.25 arc(148.76,81.05) 148.75,80.84 arc(148.74,80.68) 148.76,80.53 arc(148.78,80.35) 148.75,80.18 arc(148.71,80.04) 148.7,79.9 arc(148.73,79.81) 148.8,79.76 148.87,79.73 arc(149.06,79.79) 149.04,79.99 UC1.C13
USB3_PTX_DRX_N2: length 119.6
  GND1 w0.088: v4(228.18,56.43) 228.38,56.64 228.38,57.3 228.3,57.38 v3(227.99,57.38)
  IN4 w0.062: v4(228.18,56.43) 228.18,56.17 228.25,56.1 228.38,56.1 228.43,56.06 228.43,55.75 227.87,55.2 227.62,55.2 222.29,49.87 218.58,49.87 218.07,49.35 214.94,49.35 210.83,45.24 188.47,45.24 187.06,46.65 187.06,49.11 182.06,54.11 182.06,57.44 180.74,58.76 180.74,59.9 179.37,61.27 179.37,63.05 178.42,64 178.42,64.84 176.84,66.41 176.84,71.95 172.78,76.01 172.78,79.1 172.12,79.76 172.12,81.78 169.96,83.95 165.92,83.95 164.16,85.7 152.52,85.7 152.44,85.78 152.44,86.01 152.5,86.07 152.83,86.07 152.88,86.12 v4(152.88,86.45)
  GND5 w0.081: v5(152.78,85.99) 152.68,86.09 152.68,86.25 v4(152.88,86.45)
  BOTTOM w0.076: UC1.B13 arc(149.09,80.81) 149.24,80.89 arc(149.29,80.91) 149.34,80.94 arc(149.64,81.25) 149.79,81.65 arc(150.02,82.4) 150.47,83.03 152.51,85.06 152.57,85.13 arc(152.68,85.28) 152.71,85.47 152.71,85.84 arc(152.73,85.93) v5(152.78,85.99)
USB3_PTX_DRX_N3: length 205.9
  IN2 w0.083: v2(22.39,27.39) 22.39,27.69 22.31,27.78 22.12,27.78 22.05,27.85 22.05,30.22 21.34,30.93 21.34,35.86 20.19,37.01 20.19,39.59 19.37,40.41 19.37,41.08 18.66,41.79 18.66,49.78 18.34,50.1 18.34,54.4 18.41,54.47 18.41,57.13 19.12,57.84 19.12,69.58 21.48,71.94 21.48,74.02 22.78,75.32 22.78,76.23 23.34,76.79 25.12,76.79 27.37,79.04 31.08,79.04 35.59,83.55 39.52,83.55 39.86,83.89 46.98,83.89 49.09,86 56.7,86 57.35,86.64 57.35,87.1 58.67,88.42 61.89,88.42 63.67,90.2 85.61,90.2 87.68,88.13 92.59,88.13 96.96,92.49 113.77,92.49 114.76,91.51 123.52,91.51 126.53,88.5 142.34,88.5 143.4,89.56 145.58,89.56 145.73,89.42 145.73,89.23 145.66,89.16 145.36,89.16 145.27,89.07 145.27,88.77 v4(145.31,88.73)
  GND5 w0.088: v5(145.43,88.02) 145.53,88.12 145.53,88.5 v4(145.31,88.73)
  BOTTOM w0.076: 149.18,84.68 149.18,84.66 149.19,84.66 149.19,84.58 arc(149.1,84.14) 148.86,83.78 147.71,82.63 arc(147.54,82.38) 147.48,82.07 147.48,81.69 arc(147.48,81.69) 147.48,81.69 147.41,81.44 arc(147.4,81.37) 147.39,81.3 147.39,81.3 arc(147.4,81.23) 147.42,81.17 147.65,80.68 UC1.B15
  BOTTOM w0.088: 149.18,84.68 149.18,86.45 148.51,87.12 145.81,87.12 145.57,87.36 145.57,87.89 v5(145.43,88.02) ; 19.68,23.55 v7(19.68,23.54) ; 19.68,23.55 19.42,23.55 19.41,23.55 19.03,23.55 19.02,23.55 18.76,23.55 CI5.2 ; 19.68,23.55 19.9,23.55 19.92,23.57 20.06,23.57 20.86,24.37 20.93,24.37 21.35,24.79 21.35,24.86 22.17,25.67 22.17,27.16 v2(22.39,27.39)
USB3_PTX_DRX_N4: length 201.9
  TOP w0.088: v2(275.99,65.03) 276.2,64.82 276.2,64.67 273.48,61.95 273.48,60.26 273.67,60.07 273.81,60.07 CR32.1
  IN1 w0.062: v4(218.94,48.55) 218.92,48.53 218.92,47.91 218.8,47.79 216.99,47.79 216.11,46.91 216.11,44.77 214.84,43.49 198.3,43.49 198.29,43.51 198.23,43.51 197.65,44.09 191.66,44.09 191.13,44.62 186.88,44.62 177.44,54.06 177.44,59.4 173.96,62.88 173.96,68.17 172.62,69.51 172.33,69.51 158.78,83.06 156.1,83.06 155.08,84.08 151.48,84.08 150.44,85.12 150.44,86.52 v4(150.29,86.67)
  IN4 w0.062: v2(275.99,65.03) 275.99,65.3 276.05,65.36 276.39,65.36 276.45,65.42 276.45,65.69 275.79,66.35 275.79,67.24 274.74,68.28 274.74,73.59 271.49,76.84 271.16,76.84 268.12,79.89 264.82,79.89 264.05,80.66 249.05,80.66 248.61,80.22 247.23,80.22 242.47,75.46 242.47,68.39 241,66.92 237.88,66.92 237.21,66.25 236.75,66.25 236.5,66 235.37,66 231.94,62.57 231.94,59.64 229.68,57.39 229.68,55.8 228.18,54.29 227.65,54.29 222.57,49.21 218.89,49.21 218.66,48.98 218.66,48.83 v4(218.94,48.55)
  GND5 w0.081: v5(150.41,85.86) 150.51,85.96 150.51,86.45 v4(150.29,86.67)
  BOTTOM w0.076: UC1.C15 147.61,80 arc(147.55,79.9) 147.58,79.78 147.58,79.78 arc(147.61,79.75) 147.66,79.74 147.73,79.74 arc(147.77,79.75) 147.81,79.77 arc(147.83,79.79) 147.86,79.8 arc(147.94,79.9) 147.95,80.02 147.91,80.15 arc(147.88,80.35) 147.91,80.55 arc(147.92,80.67) 147.91,80.79 arc(147.88,81) 147.91,81.21 arc(147.93,81.27) 147.93,81.33 147.93,82.11 arc(147.96,82.25) 148.04,82.38 149.61,83.95 149.71,84.05 149.71,84.06 149.73,84.07
  BOTTOM w0.088: 149.73,84.07 150.03,84.37 arc(150.39,84.92) 150.52,85.56 150.52,85.61 arc(150.49,85.74) v5(150.41,85.86)
