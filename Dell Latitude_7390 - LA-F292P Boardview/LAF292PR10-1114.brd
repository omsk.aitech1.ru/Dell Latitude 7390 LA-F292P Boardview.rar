# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WLAN_WIGIG60GHZ_DIS#_R: length 4.7
  TOP w0.086: JNGFF1.56 242.12,42.4 241.37,43.15 v1(240.89,43.15) 240.29,43.15 240.01,42.87 239.11,42.87 DZ1.2
WRST#: length 5.3
  TOP w0.086: CE500.1 RE504.2 v1(253.29,80.43) 253.87,81 255.54,81 255.87,80.67 UE2.4
WWAN_ANTCTL0: length 1.9
  TOP w0.086: RZ327.1 229.15,74.43 v2(229.07,74.35)
  BOTTOM w0.086: v2(229.07,74.35) 229.07,74.38 229.3,74.15 JNGFF2.59
WWAN_ANTCTL0_R: length 459.5
  TOP w0.086: v2(31.69,82.94) v1(31.69,83.73) ; RZ327.2 227.08,74.99 CZ303.1
  GND1 w0.086: v3(227.05,74.98) 227.06,74.98 227.06,74.97 227.41,75.32 v4(227.47,75.32)
  IN2 w0.061: v4(227.47,75.32) 227.47,75.98 228.26,76.77 228.57,76.77 229.44,77.64 229.44,90.18 231.46,92.2 236.88,92.2 237.92,91.16 240.66,91.16 242.92,88.9 258.25,88.9 260.02,87.14 266.41,87.14 269.21,84.33 269.21,73.44 270.1,72.55 273.37,72.55 273.98,71.94 273.98,70.84 278.13,66.7 278.13,60.74 277.07,59.67 277.07,55.65 277.66,55.05 277.66,52.03 276.34,50.71 275,50.71 268.75,44.46 267.28,44.46 267.08,44.25 267.08,42.35 266.18,41.45 263.89,41.45 262.37,39.93 261.5,39.93 260.96,39.39 260.96,38.9 261.22,38.64 261.22,37.03 260.54,36.35 260.54,28.64 257.62,25.72 251.99,25.72 250.85,26.86 242.92,26.86 241.78,25.72 231.42,25.72 230.84,26.3 228.3,26.3 227.52,25.52 200.28,25.52 198.81,26.99 191.46,26.99 190.98,26.51 177.56,26.51 177.18,26.89 174.56,26.89 173.48,25.81 160.15,25.81 155.94,30.01 141.59,30.01 141.11,29.53 126.71,29.53 125.63,28.45 106.75,28.45 105.13,30.07 49.23,30.07 47.83,31.47 36.09,31.47 34.73,30.12 28.63,30.12 25.9,27.39 25.9,27.11 24.93,26.14 20.94,26.14 20.11,26.98 20.11,30.59 19.77,30.92 19.77,35.58 19.01,36.34 19.01,39.13 17.43,40.71 17.43,46.13 16.18,47.39 16.18,49.61 16.88,50.31 16.88,54.99 17.29,55.41 17.29,57.62 17.66,57.99 17.66,64.22 17.29,64.6 17.29,69.42 20.36,72.49 20.36,74.48 20.36,74.49 20.36,76.45 21.19,77.28 21.83,77.28 21.98,77.28 26.68,81.97 30.62,81.97 31.59,82.94 v2(31.69,82.94)
  BOTTOM w0.086: CZ182.1 31.89,83.45 31.89,83.14 v2(31.69,82.94) 31.59,82.94 30.43,81.78 27.86,81.78 27.7,81.93 JTUN1.3
WWAN_ANTCTL1: length 1.9
  TOP w0.086: RZ328.1 228.68,73.75 v2(229.02,73.75)
  BOTTOM w0.086: JNGFF2.61 229.12,73.65 v2(229.02,73.75)
WWAN_ANTCTL1_R: length 462.4
  TOP w0.086: v3(226.82,73.59) 226.82,73.61 CZ302.1 227.44,74.06 RZ328.2 ; v1(32.67,82.64) 32.12,82.64 31.84,82.36 v2(31.67,82.36)
  GND1 w0.086: v4(227.42,73.5) 226.9,73.5 v3(226.82,73.59)
  IN2 w0.061: v4(227.42,73.5) 227.68,73.25 228.31,73.25 228.59,73.53 228.59,75.12 229.66,76.19 229.66,90.09 231.55,91.98 236.79,91.98 237.79,90.97 240.58,90.97 242.87,88.68 258.21,88.68 259.94,86.95 266.28,86.95 269.02,84.21 269.02,77.96 268.39,77.34 268.39,76.56 268.93,76.03 268.93,73.44 270.43,71.94 271.15,71.94 272.23,70.86 273.65,70.86 277.91,66.6 277.91,60.83 276.59,59.51 276.59,55.81 277.43,54.96 277.43,52.13 276.21,50.9 274.92,50.9 268.67,44.64 267.21,44.64 266.86,44.29 266.86,42.44 266.05,41.64 263.81,41.64 262.29,40.12 261.42,40.12 260.77,39.47 260.77,38.82 261.03,38.56 261.03,37.11 260.35,36.43 260.35,28.72 257.54,25.91 252.07,25.91 250.93,27.05 242.84,27.05 241.7,25.91 231.5,25.91 230.92,26.49 228.22,26.49 227.44,25.71 200.36,25.71 198.89,27.18 191.38,27.18 190.9,26.7 177.64,26.7 177.26,27.07 174.48,27.07 173.4,25.99 160.23,25.99 156.02,30.2 141.52,30.2 141.03,29.72 126.63,29.72 125.55,28.64 106.83,28.64 105.09,30.38 80.28,30.38 79.82,30.84 70.23,30.84 69.94,31.12 67.91,31.12 67.66,30.87 58.89,30.87 58.41,30.4 49.22,30.4 47.93,31.7 35.99,31.7 34.64,30.34 28.59,30.34 25.71,27.47 25.71,27.19 24.95,26.43 20.98,26.43 20.29,27.11 20.29,30.66 19.96,31 19.96,35.66 19.2,36.42 19.2,39.21 17.62,40.78 17.62,46.21 16.37,47.47 16.37,49.53 17.06,50.23 17.06,54.92 17.47,55.33 17.47,57.54 17.85,57.91 17.85,64.3 17.47,64.67 17.47,69.34 20.54,72.41 20.54,74.41 20.55,74.41 20.55,76.37 21.27,77.09 21.75,77.09 22.06,77.09 26.69,81.72 31.03,81.72 v2(31.67,82.36)
  BOTTOM w0.086: JTUN1.4 26.9,81.68 27.02,81.56 30.87,81.56 v2(31.67,82.36) 31.77,82.36 32.35,82.94 CZ183.1
WWAN_ANTCTL2: length 1.8
  TOP w0.086: RZ329.1 228.98,73.08 v2(229.05,73.15)
  BOTTOM w0.086: JNGFF2.63 v2(229.05,73.15)
WWAN_ANTCTL2_R: length 462
  TOP w0.086: v2(31.69,81.77) 31.74,81.77 32.05,81.47 32.63,81.47 v1(32.75,81.35) ; CZ301.1 227.44,73.11 RZ329.2
  GND1 w0.086: v3(227.48,73.02) 227.47,73.02 227.47,73.05 v4(227.93,72.59)
  IN2 w0.061: v4(227.93,72.59) 228.17,72.35 229.39,72.35 229.89,72.85 229.89,90 231.58,91.69 236.76,91.69 237.67,90.78 240.5,90.78 242.83,88.45 258.17,88.45 259.86,86.76 266.15,86.76 268.83,84.08 268.83,79.97 266.56,77.71 266.56,73.79 269.45,70.91 271.86,70.91 272.14,70.64 273.56,70.64 277.68,66.51 277.68,60.93 276.36,59.61 276.36,52.14 275.31,51.09 274.84,51.09 270.51,46.75 268.11,46.75 267.13,45.77 267.13,44.83 264.9,42.6 264.51,42.6 262.21,40.31 261.34,40.31 260.16,39.12 260.16,28.79 257.5,26.14 252.11,26.14 251.01,27.24 242.77,27.24 241.66,26.14 231.54,26.14 231,26.68 228.15,26.68 227.36,25.9 200.44,25.9 198.97,27.37 191.3,27.37 190.82,26.88 177.71,26.88 177.34,27.26 174.4,27.26 173.32,26.18 160.3,26.18 156.1,30.39 141.44,30.39 140.96,29.9 126.55,29.9 125.47,28.83 106.91,28.83 105.16,30.57 80.36,30.57 79.9,31.03 70.31,31.03 70.02,31.31 67.83,31.31 67.58,31.06 58.76,31.06 58.32,30.62 49.32,30.62 48.04,31.9 35.88,31.9 34.51,30.53 28.51,30.53 25.51,27.53 25.51,27.25 24.88,26.62 21.06,26.62 20.48,27.19 20.48,30.74 20.14,31.08 20.14,35.74 19.39,36.5 19.39,39.28 17.81,40.86 17.81,46.29 16.55,47.55 16.55,49.45 17.25,50.15 17.25,54.84 17.66,55.25 17.66,57.46 18.03,57.83 18.03,64.38 17.66,64.75 17.66,69.27 20.73,72.33 20.73,74.33 20.73,74.33 20.73,76.3 21.34,76.9 21.67,76.9 22.14,76.9 26.69,81.46 31.38,81.46 v2(31.69,81.77)
  BOTTOM w0.086: CZ184.1 32.05,82.13 v2(31.69,81.77) 31.27,81.35 26.36,81.35 26.1,81.61 JTUN1.5
WWAN_ANTCTL3: length 5.9
  TOP w0.086: v2(227.39,70.74) 227.46,70.74 228.39,71.66 RZ330.1
  BOTTOM w0.086: JNGFF2.65 229.43,72.65 228.77,71.99 227.78,71.99 227.39,71.6 v2(227.39,70.74)
WWAN_ANTCTL3_R: length 460.7
  TOP w0.086: v3(227.1,71.61) 227.47,71.98 RZ330.2 227.45,72.11 CZ300.1 226.17,71.65 226.05,71.65 226.04,71.64 225.82,71.64 v1(225.26,71.08)
  GND1 w0.086: v4(227.69,71.51) 227.59,71.61 v3(227.1,71.61)
  IN2 w0.061: v2(31.69,81.19) 26.69,81.19 22.22,76.72 21.59,76.72 21.42,76.72 20.92,76.22 20.92,74.25 20.92,74.25 20.92,72.26 18.56,69.9 18.56,58.07 17.85,57.36 17.85,55.17 17.44,54.76 17.44,50.07 16.74,49.37 16.74,47.62 18,46.37 18,40.94 19.58,39.36 19.58,36.57 20.33,35.82 20.33,31.16 20.67,30.82 20.67,27.27 21.14,26.8 24.8,26.8 25.32,27.33 25.32,27.61 28.43,30.72 34.23,30.72 35.6,32.08 48.17,32.08 49.41,30.84 58.23,30.84 59.51,32.12 67.21,32.12 67.83,31.5 70.1,31.5 70.38,31.22 79.98,31.22 80.43,30.76 105.24,30.76 106.17,29.83 126.21,29.83 126.47,30.09 140.88,30.09 141.36,30.58 156.18,30.58 160.38,26.37 173.24,26.37 174.35,27.47 175.22,27.47 176.34,28.59 186.76,28.59 187.8,27.55 199.05,27.55 200.52,26.08 227.29,26.08 228.07,26.87 231.07,26.87 231.59,26.35 241.61,26.35 242.69,27.43 251.09,27.43 252.17,26.35 253.58,26.35 255.54,28.3 256.65,28.3 259.97,31.63 259.97,35.9 259.97,35.91 259.97,39.19 261.27,40.49 262.13,40.49 264.47,42.83 264.86,42.83 266.92,44.89 266.92,45.83 268.03,46.94 269.17,46.94 270.82,48.59 272.08,48.59 274.77,51.27 275.17,51.27 276.09,52.19 276.09,59.65 277.46,61.02 277.46,66.42 273.46,70.42 272.04,70.42 271.77,70.69 269.35,70.69 266.59,73.45 266.59,73.5 266.38,73.72 266.38,77.78 268.64,80.05 268.64,83.95 266.02,86.57 259.78,86.57 258.12,88.23 242.79,88.23 240.42,90.6 237.54,90.6 236.67,91.47 231.67,91.47 230.11,89.9 230.11,72.76 228.86,71.51 v4(227.69,71.51)
  BOTTOM w0.086: JTUN1.6 25.3,82.02 26.33,80.98 31.49,80.98 v2(31.69,81.19) 32.3,81.19 CZ185.1
WWAN_COEX1: length 8.7
  TOP w0.086: RZ130.1 228.14,65.98 228.14,66.67 v2(228.31,66.85)
  IN4 w0.051: v2(228.31,66.85) 228.86,67.39 228.86,68.12 230.63,69.89 230.63,71.6 JNGFF2.64
WWAN_COEX2: length 10.4
  TOP w0.086: RZ129.1 227.44,66.02 227.89,66.48 227.89,67.03 228.33,67.46 v2(228.35,67.46)
  IN4 w0.051: JNGFF2.62 231.6,73.4 230.47,72.27 230.47,69.95 228.35,67.83 v2(228.35,67.46)
WWAN_COEX3: length 10.2
  TOP w0.086: v2(227.47,66.81) 226.86,66.2 RZ128.1
  IN4 w0.051: v2(227.47,66.81) 227.96,67.3 227.96,67.65 230.32,70.01 230.32,72.38 231.85,73.9 JNGFF2.60
WWAN_PWR_EN: length 14.5
  TOP w0.086: v2(230.93,89.75) 230.83,89.85 230.83,91.07 230.09,91.8 228.82,91.8 227.88,90.86 227.65,90.86 226.36,89.57 RZ43.1 CZ198.1 224.73,88.76 v1(224.73,87.11)
  IN4 w0.051: v2(230.93,89.75) 230.93,87.97 231.5,87.4 JNGFF2.6
WWAN_RADIO_DIS#: length 82.2
  TOP w0.086: v2(227.58,83.12) 227.58,85.02 228.03,85.48 DZ5.1 ; v2(271.24,69.4) v1(271.24,68.45) RE10.1 269.54,66.89 v2(268.98,66.33) ; v2(268.57,60.98) 268.62,60.98 268.62,60.99 268.55,60.99 268.19,60.64 UE1.F12
  IN3 w0.061: v2(271.24,69.4) 270.49,69.4 267.21,72.68 267.21,74 265.14,76.08 253.05,76.08 251.47,74.5 248.57,74.5 247.72,73.64 245.84,73.64 242.32,70.12 242.32,69.26 239.99,66.93 235.99,66.93 235.36,66.3 233.14,66.3 232.78,66.66 230.55,66.66 229.56,67.65 229.56,80.58 228.52,81.62 228.52,82.76 228.16,83.12 v2(227.58,83.12)
  BOTTOM w0.086: v2(268.98,66.33) 268.98,66.15 269.69,65.44 269.69,64.69 269,64 269,61.41 v2(268.57,60.98)
WWAN_RADIO_DIS#_R: length 2.6
  TOP w0.086: JNGFF2.8 231.93,86.11 v1(231.41,85.6) 231.3,85.48 DZ5.2
WWAN_WAKE#: length 91.6
  TOP w0.086: RE38.1 270.53,54.57 v2(269.87,55.23) 269.57,55.23 UE1.M13
  IN3 w0.061: v2(229.02,83.32) 229.46,83.32 230.22,82.56 230.22,80.48 229.84,80.1 229.84,67.63 230.62,66.85 232.86,66.85 233.22,66.49 235.29,66.49 235.91,67.11 239.91,67.11 242.14,69.34 242.14,70.2 243.4,71.46 243.4,78.25 v2(244.51,79.36)
  BOTTOM w0.086: v2(229.02,83.32) 229.19,83.15 JNGFF2.23 ; v2(244.51,79.36) 246.07,79.36 247.36,78.06 249.29,78.06 249.55,78.32 249.55,78.7 249.8,78.95 250.87,78.95 254.45,75.37 260.17,75.37 262.67,72.86 262.67,71.61 263.08,71.2 263.08,70.53 263.66,69.95 267.37,69.95 271.31,66 271.31,61.66 269.71,60.06 269.71,55.39 v2(269.87,55.23)
XCLK_BIASREF: length 18.8
  TOP w0.086: RC52.1 v2(142.77,73.2) 142.78,73.18 RC324.1
  IN2 w0.061: v2(142.77,73.2) 142.71,73.25 142.71,75.2 140.76,77.15 140.05,77.15 139.81,77.39 139.81,79.3 139.07,80.04 136.27,80.04 135.92,79.69 133.33,79.69 133.08,79.94 132.55,79.94 131.99,79.39 v2(131.99,78.83)
  BOTTOM w0.117: v2(131.99,78.83) 132.02,78.83 132.24,78.6 UC1.E42
XDP_DBRESET#: length 141.1
  TOP w0.086: v3(62.68,90.23) 62.6,90.15 62.6,89.09 62.37,88.85 JXDP1.48 62.37,87.96 62.12,87.72 62.12,86.69 RC137.1 CC32.1
  GND1 w0.086: v4(62.98,90.64) 62.98,90.43 62.78,90.23 v3(62.68,90.23)
  IN3 w0.061: v4(62.98,90.64) 65.1,90.64 66.29,91.82 72.69,91.82 73.15,91.36 76.21,91.36 77.13,90.44 82.17,90.44 82.95,89.65 82.95,89.33 83.18,89.11 87.17,89.11 87.71,88.57 102.8,88.57 104.55,90.32 105.72,90.32 106.91,91.51 108.08,91.51 108.68,90.9 115.53,90.9 115.84,91.21 122.58,91.21 124.93,93.56 129.12,93.56 129.34,93.56 129.93,92.97 129.93,92.27 133.06,89.14 136.47,89.14 137.91,90.58 137.91,93.2 138.6,93.89 143.66,93.89 148.19,89.37 156.44,89.37 156.52,89.45 162.98,89.45 163.9,88.53 172.34,88.53 174.92,85.94 174.92,85.93 176.13,84.73 176.13,80.08 v2(176.87,79.33)
  BOTTOM w0.086: UC12.1 176.25,78.25 176.53,78.53 RC290.1 176.53,78.99 v2(176.87,79.33)
XDP_JTAGX: length 9.8
  BOTTOM w0.076: UC1.A59 122.56,81.64 122.56,82.51 122.52,82.55 122.52,83.63 122.43,83.72
  BOTTOM w0.086: CC305.1 RC87.1 119.17,87.38 RC328.1 119.22,86.78 119.68,86.32 119.68,85.43 120.25,84.86 v1(120.86,84.86) 121.52,84.86 122.43,83.95 122.43,83.72
XDP_OBS0: length 2.2
  TOP w0.086: JXDP1.21 70.47,92.17 69.82,92.82 v2(69.82,92.85)
  BOTTOM w0.086: RC239.2 69.82,92.44 69.82,92.44 v2(69.82,92.85)
XDP_OBS0_R: length 72
  IN4 w0.051: v4(69.23,92.85) 71.2,94.82 76.66,94.82 77.47,94.01 85.78,94.01 89.42,90.36 91.7,90.36 95.27,93.94 113.23,93.94 115.18,91.98 118.81,91.98 121.71,89.08 121.71,86.39 v2(124.22,83.88)
  GND5 w0.086: v4(69.23,92.85) 69.64,93.25 69.99,93.25 v5(70.3,92.95)
  BOTTOM w0.076: UC1.C55 124.68,80.46 124.68,83.42 v2(124.22,83.88)
  BOTTOM w0.086: v5(70.3,92.95) 70.32,92.92 70.32,91.67 RC239.1
XDP_OBS1: length 2.9
  TOP w0.086: JXDP1.23 69.87,92.11 69.44,92.54 68.88,92.54 68.62,92.8 v2(68.62,92.85)
  BOTTOM w0.086: RC240.2 68.93,92.49 68.62,92.8 v2(68.62,92.85)
XDP_OBS1_R: length 74.4
  IN4 w0.051: v4(124.96,83.35) 124.63,83.68 124.63,84.16 122.03,86.76 122.03,89.22 118.96,92.29 115.31,92.29 113.33,94.27 95.07,94.27 91.54,90.74 89.48,90.74 85.84,94.38 77.63,94.38 76.82,95.19 69.75,95.19 67.56,93 v4(67.56,92.87)
  GND5 w0.086: v5(68.06,92.87) v4(67.56,92.87)
  GND5 w0.127: v5(124.98,82.33) 124.98,83.33 v4(124.96,83.35)
  BOTTOM w0.076: UC1.D55 125.11,80.25 125.11,80.48 124.88,80.72 124.88,82.23 v5(124.98,82.33)
  BOTTOM w0.086: RC240.1 68.45,91.65 68.45,92.39 68.06,92.77 v5(68.06,92.87)
XDP_OBS2_R: length 2.9
  BOTTOM w0.076: T10.1 125.44,82.61 125.64,82.41 125.64,81.16 125.35,80.87 UC1.B54
XDP_OBS3_R: length 3.6
  BOTTOM w0.076: T11.1 124.5,83.07 124.5,80.47 124.23,80.2 UC1.C56
XDP_PRSNT_PIN1: length 8.6
  TOP w0.086: JXDP1.1 76.47,93.08 75.63,93.91 72.76,93.91 71.7,92.85 v2(71.65,92.85)
  BOTTOM w0.086: v2(71.65,92.85) 71.65,92.8 71.72,92.72 RC121.1 RC122.1
XDP_TMS: length 28.3
  TOP w0.086: JXDP1.58 59.37,88.97 59.94,89.54 61.61,89.54 62.1,90.03 v3(62.1,90.26) ; v2(81.48,89.44) 81.33,89.59 RC228.1 81.37,88.72 UC8.9
  GND1 w0.086: v3(62.1,90.26) 62.25,90.26 62.4,90.41 v4(62.4,90.64)
  IN4 w0.051: v2(81.48,89.44) 80.76,90.16 69.76,90.16 68.67,91.25 65.89,91.25 65.28,90.64 63.94,90.64 63.44,91.14 62.78,91.14 62.4,90.77 v4(62.4,90.64)
XTAL24_IN_U22: length 5.3
  BOTTOM w0.086: YC1.3 126.87,90.16 127.69,90.98 129.33,90.98 129.81,90.51 CC21.1 RC46.2 RC419.2
XTAL24_IN_U22_CPU: length 14.3
  BOTTOM w0.086: RC419.1 131.61,89.11 131.89,88.83 133.98,88.83 135.86,86.95 v6(135.86,84.07) 135.86,82.46 135.57,82.18 135.57,79.12 135.19,78.73 UC1.E37
XTAL24_IN_U42: length 3.4
  BOTTOM w0.086: RC417.2 RC415.2 143.45,91.83 CC338.1 141.9,91.83 YC3.3
XTAL24_IN_U42_CPU: length 20.2
  BOTTOM w0.086: UC1.E3 154.68,79.21 154.68,79.36 154.83,79.51 154.83,79.76 154.68,79.91 154.68,80.12 154.83,80.28 154.83,80.4 154.55,80.68 154.55,80.88 154.86,81.19 154.86,81.62 155.03,81.8 155.28,81.8 155.36,81.88 155.36,82.61 155.87,83.12 155.87,85.3 153.97,87.59 153.2,87.97 151.59,88.24 v6(148.47,89.38) 144.91,90.69 RC417.1
XTAL24_OUT_U22: length 5.8
  BOTTOM w0.086: YC1.1 128.57,92.17 129.34,91.4 CC22.1 131.08,91.4 131.46,91.02 131.46,90.66 RC46.1 132,90.51 132.45,90.05 RC420.2
XTAL24_OUT_U22_CPU: length 13
  BOTTOM w0.086: UC1.E35 136.31,78.82 136.31,81.65 136.38,81.71 136.6,81.71 136.69,81.8 136.69,82.13 136.6,82.22 136.38,82.22 136.29,82.3 v6(136.29,85.87) 136.29,87.08 134.08,89.29 RC420.1
XTAL24_OUT_U42: length 5.4
  BOTTOM w0.086: YC3.1 140.76,91.02 142.61,91.02 CC339.1 142.94,90.69 RC415.1 143.68,89.8 RC418.2
XTAL24_OUT_U42_CPU: length 19.2
  BOTTOM w0.086: RC418.1 145.55,89.75 v6(150.68,88.04) 151.19,87.87 151.34,87.83 152.87,87.56 153.71,87.18 155.62,84.92 155.62,83.19 155.01,82.58 155.01,82.28 154.22,81.49 154.22,80.6 153.97,80.35 153.71,80.35 153.39,80.02 UC1.C7
XTAL_25_IN: length 5.3
  BOTTOM w0.086: RT394.1 26,52.43 26.84,51.6 v1(26.88,51.6) 27.3,51.6 28.9,53.2 29,53.2 29.13,53.32 29.13,53.74 29.35,53.96 UT1.D22
XTAL_25_IN_R: length 2.5
  BOTTOM w0.086: RT394.2 CT21.1 24.05,51.52 YT1.1
XTAL_25_OUT: length 4.2
  BOTTOM w0.086: RT40.1 27.13,51.18 27.36,51.18 v1(28.16,51.98) 29.35,53.16 UT1.D23
XTAL_25_OUT_R: length 4.6
  BOTTOM w0.086: RT40.2 CT20.1 24.53,50.91 22.45,50.91 21.61,50.08 YT1.3
N04748: length 2.9
  TOP w0.203: PC939.1 PR929.1 56.14,40.54 PU901.3
N46735: length 2.5
  TOP w0.086: RA17.2 260.34,34.93 CA33.1 259.81,33.97 v1(259.82,33.96)
N16399089: length 6.6
  TOP w0.508: PR916.2 63.82,30.1 v1(64.76,30.1) 64.99,30.1 PD903.1 65.65,31.55 PD904.1 66.62,34.3 PD901.1
N16400770: length 34.2
  TOP w0.254: PR910.1 49.92,34.77 v2(50.46,34.77)
  IN3 w0.254: v2(58.69,58.48) 58.58,58.59 55.92,58.59 51.54,54.22 51.54,51.77 48.26,48.49 48.26,45.96 49.98,44.24 49.98,41.58 49.12,40.72 49.12,38.86 49.68,38.3 49.68,35.52 50.42,34.77 v2(50.46,34.77)
  BOTTOM w0.254: v2(58.69,58.48) 58.79,58.58 59.83,58.58 60.01,58.4 PR901.3
N16404606: length 2.5
  TOP w0.086: v1(69.73,38.45) PD905.3 67.93,39.14 PR939.2
N16404610: length 2.3
  TOP w0.086: v1(69.72,37.15) PD905.2 68.61,36.66 68.83,36.44 PR941.2
N16404614: length 4
  TOP w0.086: v1(65.61,41.19) 65.61,39.46 65.46,39.3 PR942.2 64.71,38.88 PU903.2
N16775301: length 4.9
  BOTTOM w0.086: PR206.1 v1(79.61,43.01)
  BOTTOM w0.254: PU200.16 81.72,43.57 PR204.2 ; PR204.2 81.12,43.62 81.12,43.52 PR206.1 ; PR204.2 81.4,44.74 PC208.2
N16775385: length 3.3
  BOTTOM w0.117: PC218.1 88.55,44.74 v1(88.75,44.54)
  BOTTOM w0.254: PC218.1 87.04,44.74 86.32,44.02 PU200.3
N16775433: length 1.7
  TOP w0.117: v1(84.63,34.88) 85.32,35.58 PC204.1
N16775513: length 2.5
  TOP w0.086: PC205.1 v1(80.5,34.76)
  TOP w0.508: PC205.1 PR203.2
N16775517:
  vias: v1(81.96,38.67) v2(81.72,39.85) v2(81.69,39.24)
N16776853: length 1.7
  BOTTOM w0.254: PU200.14 82.14,42.67 81.59,42.12 PC207.1
N16777273: length 6.2
  TOP w0.254: v2(86.78,45.3) 87.04,45.3 87.93,44.41 PC222.1 87.98,44.15 88.49,43.65 PR210.2 PR212.1
  BOTTOM w0.254: PU200.2 86.2,44.47 86.78,45.06 v2(86.78,45.3)
N16783014: length 1.7
  BOTTOM w0.086: PR105.1 79.41,41.31 79.74,40.98 79.74,40.57 v1(80.19,40.12)
N16783095: length 2.2
  BOTTOM w0.086: v1(79.38,44.66) 78.95,44.23 PC113.2
  BOTTOM w0.254: PC113.2 78.38,43.29 PR108.1
N16783134: length 2.4
  BOTTOM w0.086: PR117.1 56.86,70.82 57.33,70.35 v1(57.74,70.35)
  BOTTOM w0.254: PC127.2 PR117.1
N16783222:
  vias: v2(54.14,68.55)
N16784595: length 1.3
  TOP w0.508: PR100.2 PC102.1
N16784799: length 2.7
  TOP w0.086: v1(51.41,68.83) 50.91,68.32 PC114.1
  TOP w0.508: PC114.1 50.78,67.4 PR111.2
N17113942: length 4.9
  TOP w0.102: v1(82.02,51.14) 82.51,50.65 82.51,50.41 82.13,50.03 PC515.2
  TOP w0.117: PU503.3 79.95,50.31 80.21,50.06 PR516.1 81.18,50.06 PR515.2 82.08,50.04 PC515.2
N17275961: length 2.9
  TOP w0.203: PR614.2 68.1,78.75 PR612.2 68.54,78.29 v2(68.98,78.29)
  BOTTOM w0.203: PU602.39 69.39,77.93 69.03,78.29 v2(68.98,78.29)
N17275988: length 3
  TOP w0.203: PR616.2 68.95,79.64 68.95,79 v2(69.08,78.88)
  BOTTOM w0.203: PU602.40 69.56,78.33 69.08,78.81 v2(69.08,78.88)
N17419094: length 11.4
  TOP w0.254: v2(56.64,80.95) 56.53,81.06 PQ1200.4
  BOTTOM w0.254: PR1211.2 51.63,87.38 52.17,87.92 52.95,87.92 53.48,87.38 PR1206.2 53.48,86.45 PC1204.1 53.51,84.14 v1(54.07,83.58) 56.58,81.07 56.58,81.01 v2(56.64,80.95)
N17419103: length 2.1
  BOTTOM w0.102: PR1211.1 v1(49.81,86.7)
  BOTTOM w0.254: PQ1201.6 50.72,87.66 PR1211.1
N17419127: length 11.8
  TOP w0.254: v3(41.22,46.31) 41.14,46.39 PR1236.2 PC1216.1 40.1,46.39 39.34,45.63 PQ1210.4
  GND1 w0.254: v3(49.14,46.95) 48.84,46.64 v4(48.84,46.11) ; v3(41.22,46.31) 42.38,46.13 42.47,46.04 v4(42.54,46.04)
  IN4 w0.254: v4(48.84,46.11) 48.15,45.42 42.82,45.42 42.54,45.7 v4(42.54,46.04)
N17419137: length 1.1
  TOP w0.254: PR1242.1 48.18,46.9 PQ1217.6
N17420744: length 7
  TOP w0.086: PR1247.1 PR1258.2 v1(39.04,32.04) 37.51,32.04 36.17,30.7 PQ1218.1
N17421409: length 1.8
  BOTTOM w0.086: PQ1220.3 PQ1220.2 67.7,86.86 67.15,87.41 PR1271.1
N17423076: length 1.9
  BOTTOM w0.086: PQ1223.3 PQ1223.2 74.48,87.19 74.13,87.54 PR1272.1
N17423090: length 21.6
  IN3 w0.061: v4(72.14,83.62) 71.6,84.16 69.24,84.16 66.5,81.43 64.79,81.43 64.13,82.09 63.64,82.09 63.39,82.34 v4(63.39,82.58)
  GND5 w0.086: v4(63.39,82.58) 63.54,82.58 v5(63.82,82.86)
  GND5 w0.254: v5(73.04,84.36) 72.87,84.36 72.13,83.63 72.13,83.62 v4(72.14,83.62)
  BOTTOM w0.086: 73.83,84.49 PQ1223.6 ; PQ1221.1 63.15,86.63 v1(63.02,86.51) 62.59,86.07 62.59,84.27 62.91,83.96 63.27,83.96 63.81,83.43 63.81,82.88 v5(63.82,82.86)
  BOTTOM w0.203: PR1290.2 PR1268.1 73.83,84.49
  BOTTOM w0.254: v5(73.04,84.36) 73.32,84.36 73.58,84.62 PQ1223.6
N17446677: length 14
  TOP w0.086: PR1222.1 64.12,82.69 63.8,83.02 62.11,83.02 61.69,82.6 v3(61.69,82.58)
  GND1 w0.086: v4(62.17,82.58) v3(61.69,82.58)
  GND5 w0.086: v5(62.02,81.97) 62.02,82.43 v4(62.17,82.58)
  BOTTOM w0.086: PQ1209.1 57.46,86.97 56.13,85.63 PR1228.2 v1(58.53,85.18) 61.37,82.33 61.76,82.33 62.02,82.08 v5(62.02,81.97)
N18490882: length 3.1
  TOP w0.086: v1(270.69,78.02) 270.46,77.8 RI14.2 269.47,76.03 UI3.16
N19725601: length 27
  TOP w0.254: PR1212.2 61.1,84.46 58.5,84.46 57.88,83.83 57.88,79.82 v6(57.43,79.36) 55.64,77.58 51.76,77.58 50.94,76.77 48.63,76.77 PR1204.2 PC1206.2 47.35,76.75 PQ1203.4 46.09,77.06 45.68,77.47 41.06,77.47 40.81,77.21 PQ1204.1
N20151644: length 35.7
  TOP w0.254: v2(50.45,34.03) 50.14,33.72 PR909.1
  IN3 w0.254: v2(50.45,34.03) 49.29,35.19 49.29,38.14 48.73,38.7 48.73,40.88 49.6,41.74 49.6,44.08 47.88,45.8 47.88,48.65 51.16,51.93 51.16,54.38 55.76,58.97 58.55,58.97 v2(58.69,59.11)
  BOTTOM w0.254: v2(58.69,59.11) 58.84,58.96 59.76,58.96 60.01,59.22 PR901.2
N22211458: length 2.3
  TOP w0.086: PR1212.1 v1(62.06,83.53)
  TOP w0.254: PQ1207.3 60.06,83.49 60.32,83.23 60.82,83.23 PR1212.1
N22242716: length 11.9
  TOP w0.254: PQ1211.4 43.42,43.87 42.96,43.42 PR1237.2 41.14,43.42 40.81,43.09 40.63,43.09 PC1217.2 40.75,42.57 42.27,42.57 42.8,42.04 PQ1227.1 42.8,40.64 v1(42,39.85) 41.6,39.44 41.6,38.29 41.86,38.02 PR1244.2
N22400408: length 18.6
  TOP w0.254: PR1209.2 57.37,84.6 v1(57.37,83.1) v2(57.37,80.96)
  GND1 w0.254: v2(53.47,80.96) 53.47,80.67 52.85,80.04 v3(51.5,80.04)
  GND5 w0.203: v5(52.14,82.33) 52.24,82.33 v5(52.9,81.67)
  BOTTOM w0.254: v2(57.37,80.96) 57.37,80.78 57.06,80.47 53.96,80.47 v2(53.47,80.96) 52.9,81.53 v5(52.9,81.67) ; PC1205.2 51.17,84.59 51.66,84.11 PR1203.2 50.48,83.65 PQ1225.1 50.28,82.54 51.93,82.54 v5(52.14,82.33)
N22401321: length 1.8
  TOP w0.086: PQ1207.5 59.41,86.33 PR1224.2 59.28,86.46 PR1221.1
N22406932: length 25.1
  TOP w0.102: v2(46.8,37.49) 47.39,37.49 v1(47.69,37.19)
  TOP w0.254: PR1238.2 v3(48.18,50.15) 47.57,50.15 47.39,50.32 PQ1212.4 46.69,50.45 45.97,51.17 44.09,51.17 43.46,51.79 PQ1213.1 ; v2(46.8,37.49) 46.79,37.48 PR1246.2
  GND1 w0.508: v3(48.18,50.15) v4(48.18,50.63)
  IN1 w0.254: v4(48.18,50.63) 47.99,50.44 47.99,46.1 49.7,44.38 49.7,43.32 47.85,41.46 47.85,41.18 47.46,40.8 47.46,38.15 v2(46.8,37.49)
N22440950: length 2.7
  TOP w0.086: v1(42.4,35.77) 42.4,37.09 PR1244.1
  TOP w0.254: PQ1216.6 43.08,37.78 PR1244.1
N22511366: length 4.4
  TOP w0.086: PQ1207.2 59.41,82.75 PC1208.1 59.51,81.78 PR1220.2 59.58,81.67 PR1214.2 60.37,81.42 59.68,80.73 v1(59.3,80.73)
N23260134: length 7.9
  TOP w0.086: PU1202.4 66.98,82.95 66.58,82.54 65.11,82.54 64.77,82.2 63.82,82.2 63.54,82.48 v1(63.21,82.48) 62.53,82.48 62.25,82.2 61.23,82.2 60.85,82.58 PR1214.1
N23412536: length 1
  BOTTOM w0.508: CD40.2 RD41.1
N23413182: length 7.1
  BOTTOM w0.086: UD1.B4 107.69,37.85 108.37,37.85 109.07,37.15 109.07,36.2 v1(110.32,34.96) 110.71,34.57 RD29.1
N23413199: length 5
  BOTTOM w0.086: UD1.B3 107.78,36.28 108.08,36.28 108.45,35.91 108.45,34.81 v1(109.46,33.81) 109.76,33.5 RD28.1
N23415795: length 2.2
  BOTTOM w0.127: CD39.2 90.58,45.39 89.73,45.39 v1(89.51,45.6)
  BOTTOM w0.508: CD39.2 RD40.1
N23511003: length 5.2
  BOTTOM w0.086: v1(127.63,37.72) 126.17,37.72 RD32.1 125.34,37.83 123.23,37.83 UD2.B4
N23511005: length 6.9
  BOTTOM w0.086: UD2.B3 123.35,36.29 124.81,36.29 RD31.1 126.15,36.71 128.47,36.71 v1(128.88,37.13)
N23718631: length 2.7
  BOTTOM w0.508: CD67.2 112.99,53.07 112.48,53.58 v1(112.16,53.58) 111.83,53.58 111.55,53.3 RD78.1
N23733501: length 5.2
  BOTTOM w0.086: UD3.B4 141.31,37.18 141.31,36.58 141.5,36.4 141.6,36.4 142,35.99 142,32.91 RD71.1
N23733503: length 4.1
  BOTTOM w0.086: RD70.1 141.19,34.41 141.31,34.53 141.31,36.06 141.11,36.25 141.11,36.58 UD3.B3
N23741962: length 2
  TOP w0.086: PR1255.1 44,38.88 PR1257.2 44.17,38.71 PQ1216.5
N23746943: length 2.9
  BOTTOM w0.086: UD4.B3 156.86,36.35 158.35,36.35 158.58,36.58 RD72.1
N23746945: length 2.9
  BOTTOM w0.086: RD73.1 158.48,37.51 158.15,37.84 156.82,37.84 UD4.B4
N27076067: length 3
  TOP w0.508: PC944.1 61.96,37.42 61.73,37.19 60.46,37.19 v1(60.37,37.28) 60.23,37.42 59.36,37.42 PR934.2
N27076242: length 1.2
  TOP w0.508: PC930.1 PR914.2
N27077001: length 23.4
  TOP w0.254: PR937.2 57.54,44.95 55.1,47.39 v1(55.1,49.31) 55.1,49.78 55.91,50.59 55.91,55.25 56.13,55.47 56.13,58.26 57.84,59.98 59.27,59.98 60.11,59.14 60.11,56.88 60.37,56.63 PR917.2
N28424999: length 7.3
  BOTTOM w0.076: 113.26,56.11 114.38,57.23 114.38,60.12 114.7,60.44 115.13,60.44 115.15,60.46 UC1.AW71
  BOTTOM w0.086: 113.26,56.11 112.55,55.39 T113.1
N28425002: length 7.7
  BOTTOM w0.076: T114.1 113.12,56.28 114.14,57.3 114.14,60.11 114.63,60.61 115.06,60.61 115.19,60.74 115.62,60.74 116.13,60.22 UC1.AW70
N28489601: length 7.8
  BOTTOM w0.086: SW1.1 211.63,33.35 211.38,33.11 207.69,33.11 v1(206.45,34.34) 205.78,35.01 RC222.1
N28769860: length 4.8
  TOP w0.086: 181.12,31.44 181.13,31.45 181.13,32.18 v1(181.25,32.29)
  TOP w0.117: 181.12,31.44 PR421.2
  TOP w0.254: PU401.5 178.06,30.27 178.45,30.67 179.42,30.67 180.21,31.45 PR422.1 180.99,31.45 PR421.2
N28771761: length 13.4
  TOP w0.086: v2(175.02,26.04) 174.31,25.33 v1(170.71,25.33) 168.6,25.33 168.39,25.54 168.39,26.33 169.22,27.16 PR425.2 PR404.2
  GND1 w0.086: v4(176.93,26.33) 176.93,26.84 v3(177.06,26.97)
  IN2 w0.061: v2(175.02,26.04) 175.2,25.87 176.48,25.87 176.93,26.31 v4(176.93,26.33)
N28771835: length 5.7
  TOP w0.086: v2(169.41,33.33) 169.64,33.56 PR426.2 169.64,34.26 170.3,34.92 v1(170.57,34.92)
  BOTTOM w0.086: PU402.14 167.48,32.9 PR410.2 168.24,33.05 169.13,33.05 v2(169.41,33.33)
N28811129: length 2.4
  TOP w0.086: UZ3.10 19.96,31.85 19.73,32.09 CZ114.1 v1(19.35,31.07)
N28856399: length 7
  BOTTOM w0.076: UC1.BA70 115.86,59.6 115.86,59.87 115.55,60.18 115.39,60.18 115.29,60.28 114.77,60.28 114.55,60.05 114.55,56.63 T16.1
N28856402: length 4.7
  BOTTOM w0.076: UC1.BA68 116.78,58.94 116.91,58.82 116.91,58.57 116.74,58.4 116.69,58.4 115.15,56.87 115.15,55.68 T17.1
N28857231: length 5.4
  BOTTOM w0.076: UC1.BB68 116.81,58.24 116.76,58.24 115.48,56.96 115.48,55.79
  BOTTOM w0.086: T12.1 115.48,54.31 115.48,55.79
N28857234: length 5.5
  BOTTOM w0.076: UC1.BB69 116.62,58.68 114.83,56.9 114.83,56.54 114.49,56.2
  BOTTOM w0.086: 114.49,56.2 114.29,56 114.29,55.58 113.82,55.11 T13.1
N28857237: length 1.5
  TOP w0.086: T14.1 149.31,66.72 v2(149.31,66.46)
  BOTTOM w0.086: UC1.AK13 v2(149.31,66.46)
N28857240: length 1.4
  TOP w0.086: T15.1 149.9,65.99 v2(149.9,66.46)
  BOTTOM w0.086: v2(149.9,66.46) 149.9,66.4 UC1.AK12
N28861827: length 13.7
  BOTTOM w0.076: 118.53,83.1 118.53,83.09 118.83,82.8 118.84,82.8 119.72,81.92 119.72,80.47 UC1.C64
  BOTTOM w0.086: 118.53,83.1 118.53,83.27 117.5,84.31 115.19,84.31 v2(114.99,84.1) 113.97,83.09 112.26,83.09 111.4,83.96 RC120.1
N29708559: length 6.2
  BOTTOM w0.076: 156.36,58.79 156.05,58.79 155.82,59.02 154.7,59.02 154.53,59.18 154.53,59.53 UC1.AY4
  BOTTOM w0.086: 156.36,58.79 158.98,58.79 T126.1
N29708561: length 5.5
  BOTTOM w0.076: UC1.BB3 155.22,58.7 155.54,58.38 156.05,58.38 156.33,58.1
  BOTTOM w0.086: T127.1 160.11,58.1 156.33,58.1
N29708599: length 3.5
  TOP w0.086: v3(154.4,61.81) 155.47,61.81 156.06,62.41 156.14,62.41 T128.1
  GND1 w0.086: v3(154.4,61.81) 154.09,62.11 v4(154.02,62.11)
  GND5 w0.086: v4(154.02,62.11) 153.77,62.11 v5(153.47,61.81)
N29708601: length 1.2
  GND1 w0.086: v4(154.01,62.72) 153.88,62.85 v3(153.51,62.85)
  GND5 w0.086: v5(153.47,62.46) 153.75,62.46 v4(154.01,62.72)
N29708639: length 6.3
  BOTTOM w0.076: UC1.BB5 153.72,58.7 154.22,58.2 154.45,58.2
  BOTTOM w0.086: 154.45,58.2 155.49,57.16 159.11,57.16 T130.1
N30404696: length 3.6
  TOP w0.086: UZ5.12 256.83,33.86 CZ126.1 256.93,33.9 257.41,33.42 v1(258.65,33.42)
N30404698: length 1.6
  TOP w0.086: CZ127.1 255.98,32.95 255.87,33.06 UZ5.10
N32590572: length 1.8
  TOP w0.117: CZ117.1 203.08,41.97 UZ4.12
N32592963: length 1.7
  TOP w0.117: UZ4.10 203.88,42.12 CZ118.1
N32594166: length 1.7
  TOP w0.086: CZ109.1 233.83,37.59 UZ2.12
N32819772: length 2.7
  TOP w0.086: UZ8.6 224.96,42.73 CZ121.1 225.93,42.68 v1(225.98,42.63)
N34978918: length 2.9
  TOP w0.086: PU1203.1 44.04,31.79 44.21,31.96 44.21,32.24 43.81,32.65 PR1245.2 44.65,32.95 PR1283.2
N34978921: length 2.5
  TOP w0.086: PU1203.2 43.38,31.12 PR1247.2
  TOP w0.102: v1(41.9,29.99) 41.9,30.93 PR1247.2
N34978957: length 8.9
  TOP w0.086: PR1248.1 45.27,34.2 46.86,34.2 47.06,33.99 47.06,32.27 47.87,31.45 47.87,30.69 47.27,30.1 v1(46.39,30.1) 46.25,30.1 45.85,30.49 PU1203.4
N35025004: length 4.1
  TOP w0.086: PU1202.1 64.71,84.25 PR1219.2 64.67,84.71 64.97,84.71 65.37,85.11 PR1284.2 65.37,86.05 v1(65.77,86.45)
N35025007: length 2.5
  TOP w0.086: v1(63.37,83.82) 63.58,83.61 PR1222.2 64.48,83.61 64.49,83.6 65.79,83.6 PU1202.2
N35025022: length 2.8
  TOP w0.086: PR1250.2 45.04,34.88 PR1248.2 ; PR1250.2 44.17,34.92 PQ1216.2 ; PR1250.2 PC1220.1
N35029381: length 9.6
  GND1 w0.086: v4(47.41,90.81) 47.87,91.27 v3(47.87,91.65)
  GND5 w0.086: v4(47.41,90.81) 47.45,90.78 47.5,90.78 47.67,90.61 v5(47.67,90.38)
  BOTTOM w0.086: v5(47.67,90.38) 47.67,88.07 48.35,87.38 49.14,87.38 50.22,88.47 PQ1201.5 51.11,88.47 51.22,88.35 PC1212.1 v1(52.56,88.35)
N35029400: length 7.8
  BOTTOM w0.086: PQ1201.2 48.31,88.47 48.18,88.6 48.18,88.99 48.31,89.12 PQ1201.3 49.29,89.12 49.5,89.33 49.5,90.19 ; 49.5,90.19 49.04,89.73 48.19,89.73 48.05,89.87 48.05,91.11 PR1295.1 47.62,91.05 47.62,90.86 v1(47.1,90.34) ; 49.5,90.19 PR1213.1
N35029414: length 11.3
  TOP w0.086: v2(46.23,90.08) 46.43,89.87 PC1211.1 PR1217.2 PR1223.1 46.96,92.91 v1(46.87,93)
  BOTTOM w0.086: PR1218.2 47.03,88.16 PD1201.2 46.99,88.72 46.23,89.48 v2(46.23,90.08) 46.53,90.38 46.53,90.77 46.26,91.04 45.81,91.04 45.66,90.89 PU1201.1
N35029420: length 16.5
  TOP w0.254: PR1215.2 44.42,87.08 PR1225.1 PC1209.1 43.88,88.86 v2(43.48,89.26) v1(42.8,88.59) PQ1208.1
  BOTTOM w0.254: PR1287.2 50.5,85.54 PR1218.1 47.96,86.32 PD1201.1 46.27,87.08 46.27,88.95 45.63,89.59 PU1201.3 43.8,89.59 v2(43.48,89.26)
N35029430: length 5.3
  TOP w0.086: PC1210.1 46.07,90.64 v2(46.07,90.64) ; PC1210.1 PR1216.2 ; PC1210.1 PR1227.1
  TOP w0.102: PR1227.1 v1(45.33,92.93)
  BOTTOM w0.086: PU1201.2 45.66,90.24 v2(46.07,90.64)
N35029470: length 3.5
  TOP w0.086: PR1230.1 39.15,87.36 PQ1208.2 39.56,86.44 PR1232.1 40.4,85.55 PR1231.1
N35030736: length 28.9
  TOP w0.086: v3(48.07,37.8) 48.71,38.44 v1(48.71,38.92) 48.71,39.96 47.62,41.05 47.62,42.63 46.76,43.49 46.76,44.1 47.88,45.22 48.52,45.22 48.83,45.54 PQ1217.5 ; v2(33.55,36.66) 34.05,36.15 PC1224.1 34.18,36.16 PR1259.2
  GND1 w0.086: v4(48.1,37.25) 48.1,37.78 v3(48.07,37.8)
  IN4 w0.051: v4(48.1,37.25) 47.8,36.94 46.38,36.94 45.24,38.08 42.32,38.08 41.83,38.58 38.97,38.58 38.52,38.13 34.93,38.13 33.55,36.75 v2(33.55,36.66)
N35030744: length 2.8
  TOP w0.508: PQ1217.2 PQ1217.3 49.7,43.76 PR1249.1 49.7,42.58 PR1296.1
N35030767: length 71.2
  TOP w0.086: PR1254.2 35.67,38.71 35.38,39.01 PR1256.2 35.04,38.03 PC1223.1 35.04,38 v3(35.04,37.07) ; v3(35.04,37.07) 34.59,37.52 33.32,37.52 32.79,37 PD1206.2 ; v3(35.04,37.07) v1(36.13,37.07)
  GND1 w0.086: v3(35.04,37.07) 35.04,37.11 v4(35.4,37.47)
  IN3 w0.061: v4(35.4,37.47) 36.52,38.59 37.3,38.59 38.94,40.23 38.94,46.57 40.13,47.77 40.13,50.58 38.61,52.11 38.61,54.5 38.76,54.65 38.76,59.86 38.09,60.53 38.09,64.26 37.82,64.53 37.82,66.16 38.95,67.3 39.51,67.3 40.63,68.43 40.63,71.84 41.75,72.95 v4(41.75,76.55)
  GND5 w0.086: v5(42.06,76.92) 42.06,76.85 41.76,76.55 v4(41.75,76.55)
  BOTTOM w0.086: PU1201.7 38.81,90.24 38.09,89.52 38.09,88.45 38.69,87.85 38.69,86.79 40.61,84.87 40.61,84.33 41.61,83.33 41.99,83.33 43.08,82.25 43.08,78.4 42.06,77.38 v5(42.06,76.92)
N35030773: length 78.8
  TOP w0.254: PC1221.1 34.24,35.17 PR1261.1 34.06,35 PR1252.2 v1(32.05,35) 31.82,35.23 31.82,37.32 32.79,38.29 PD1206.1 33.11,39.01 PR1256.1 34.14,39.01 34.71,39.58 35.41,39.58 35.72,39.28 v3(36.68,39.28)
  GND1 w0.086: v4(37.22,39.28) v3(36.68,39.28)
  IN3 w0.061: v4(41.06,76.06) 41.52,75.6 41.52,72.99 40.44,71.92 40.44,68.5 39.43,67.49 38.88,67.49 37.63,66.24 37.63,64.46 37.9,64.18 37.9,60.45 38.57,59.78 38.57,54.73 38.42,54.58 38.42,52.03 39.95,50.5 39.95,47.85 38.75,46.65 38.75,40.31 37.72,39.28 v4(37.22,39.28)
  GND5 w0.086: v4(37.22,39.28) 37.44,39.49 v5(37.65,39.49) ; v4(41.06,76.06) v5(41.54,76.06)
  BOTTOM w0.254: v5(37.65,39.49) 41.38,39.49 PR1288.2 43.35,37.52 PQ1219.1 ; v5(41.54,76.06) 42.17,76.06 43.59,77.48 43.59,82.46 42.21,83.84 41.83,83.84 41.14,84.53 41.14,85.3 39.41,87.03 39.41,88.36 39.99,88.94 PU1201.5
N35030783: length 70.7
  TOP w0.381: v2(36.87,36.95) v6(37.81,36.01) PC1222.1 ; PC1222.1 37.81,33.82 38.45,33.18 PR1253.2 ; PC1222.1 PR1262.1
  IN3 w0.061: v2(36.87,36.95) 36.87,37.9 39.12,40.15 39.12,46.5 40.32,47.69 40.32,50.66 38.79,52.19 38.79,54.42 38.94,54.57 38.94,59.94 38.28,60.6 38.28,64.33 38,64.61 38,66.09 39.03,67.12 39.59,67.12 40.82,68.35 40.82,71.76 42.25,73.19 42.25,76.67 41.99,76.93 41.06,76.93 v4(40.77,76.65)
  GND5 w0.086: v5(41.24,76.51) 40.91,76.51 v4(40.77,76.65)
  BOTTOM w0.086: v5(41.24,76.51) 42.14,76.51 43.29,77.66 43.29,82.34 42.08,83.54 41.7,83.54 40.83,84.42 40.83,84.96 38.91,86.88 38.91,87.94 38.31,88.54 38.31,89.08 38.82,89.59 PU1201.6
N35030823: length 4.1
  BOTTOM w0.086: PQ1219.2 43.48,34.24 PR1266.1 PR1269.1 42.97,32.6 PR1270.1
N35031412: length 3.1
  TOP w0.086: PQ1205.1 61.59,79.92 62.2,80.53 62.2,81.11 PR1205.1 63.5,81.5 PR1208.1
N35031421: length 4.5
  TOP w0.086: PQ1206.2 64.83,80.03 64.43,80.43 PR1208.2 64.83,81.48 65.21,81.85 66.3,81.85 v1(66.32,81.82)
N35031425: length 32.9
  TOP w0.086: v2(64.86,80.63) 65.32,81.08 PQ1206.1 ; PR1207.1 39.17,73.48 39.17,76.04 39.92,76.79 39.92,77.43 41.19,78.7 v1(42.4,78.7) v3(42.84,78.7)
  GND1 w0.086: v4(43.34,78.65) 43.29,78.7 v3(42.84,78.7)
  IN3 w0.061: v2(64.86,80.63) 64.2,81.29 61.26,81.29 59.88,79.91 50.33,79.91 50.02,80.21 44.91,80.21 v4(43.34,78.65)
N35031429: length 4
  TOP w0.086: PQ1204.2 40.58,74 PR1207.2 PR1202.1 v1(41.44,71.9)
N35032568: length 5.8
  TOP w0.086: v1(38.78,38.52) 38.46,38.52 37.76,39.21 37.76,39.98 38.24,40.45 PR1241.1 38.33,41.23 PR1239.1 37.15,41.28 36.55,41.89 PQ1214.1
N35032572: length 2.7
  TOP w0.086: PR1241.2 39.07,39.54 39.37,39.84 PQ1215.2 39.56,39.84 40.21,39.19 v1(40.21,38.73)
N35032578: length 21.1
  TOP w0.086: v3(40.72,41.95) 40.5,41.74 PQ1215.1 39.69,41.74 v1(39.21,42.22) ; PR1240.1 44.71,57.55 44.71,56.19 45.11,55.79 45.11,54.55 44.51,53.95 v3(43.98,53.95)
  GND1 w0.086: v4(43.54,53.55) 43.55,53.55 43.94,53.95 v3(43.98,53.95) ; v4(41.36,42.07) 40.84,42.07 v3(40.72,41.95)
  IN3 w0.061: v4(41.36,42.07) 44.07,44.78 44.07,48.36 43.96,48.47 43.96,52.12 43.54,52.54 v4(43.54,53.55)
N35032580: length 2.9
  TOP w0.086: PR1235.1 44.18,57.17 PR1240.2 44.26,56.12 44.43,55.95 PQ1213.2
N35034018: length 1.2
  TOP w0.086: PR1243.1 35.54,40.49 PQ1214.2
N35034674: length 3.8
  TOP w0.086: v1(61.22,76.83) PR1210.1 61.51,77.78 62.8,79.08 PQ1205.2
N36307052: length 8.9
  TOP w0.086: RT97.2 33.82,72.37 v3(33.82,73.24)
  GND1 w0.086: v4(33.24,73.92) 33.82,73.34 v3(33.82,73.24)
  IN3 w0.061: v4(31.09,77.15) 33.24,75 v4(33.24,73.92)
  GND5 w0.086: v5(31.09,77.7) v4(31.09,77.15)
  BOTTOM w0.076: 31.46,77.1 31.46,75.78 UT5.F10
  BOTTOM w0.086: v5(31.09,77.7) 31.46,77.33 31.46,77.1
N36307117: length 5.3
  TOP w0.086: RT85.1 28.81,70.03 v1(29.42,70.64) v2(30.79,72.01)
  BOTTOM w0.086: v2(30.79,72.01) 30.79,72.09 UT5.G4
N36307119: length 5.1
  TOP w0.086: v2(31.41,71.99) 31.39,71.97 31.39,71.76 29.83,70.21 v1(29.83,69.4) RT84.1
  BOTTOM w0.086: v2(31.41,71.99) 31.41,72.22 UT5.F4
N36307451: length 1.7
  BOTTOM w0.254: RT105.1 CT85.1 24.93,77.73 RT396.2
N36307473: length 7.4
  TOP w0.254: RT395.1 23.72,78.01 v2(24.17,77.56)
  BOTTOM w0.254: UT5.K9 UT5.L9 28.86,75.03 28.69,75.19 28.69,75.21 28.54,75.36 28.49,75.36 27.21,76.64 v1(26.37,76.64) 25.8,76.64 25.29,77.15 24.58,77.15 v2(24.17,77.56)
N36307634: length 4.8
  BOTTOM w0.254: RT396.1 25.9,77.48 26.3,77.08 27.38,77.08 v1(27.66,76.81) 28.94,75.53 UT5.L10 UT5.K10
N36307669: length 1.5
  BOTTOM w0.076: 31.92,70.24 31.92,70.83 UT5.F1
  BOTTOM w0.086: RT63.1 31.92,70.24
N36307926: length 6.8
  TOP w0.086: v1(25.39,79.03) 25.82,78.6 RT103.1 25.82,77.4 v3(25.98,77.25)
  GND1 w0.086: v3(25.98,77.25) 26.2,77.25 v4(26.42,77.03)
  IN3 w0.061: v4(29.38,75.49) 28.43,75.49 26.88,77.03 v4(26.42,77.03)
  GND5 w0.086: v5(29.22,76.03) 29.38,75.87 v4(29.38,75.49)
N36827741: length 7.9
  TOP w0.086: UZ34.4 91.75,42.3 91.6,42.45 v1(91.6,43.01) 91.31,43.3 91.31,46.14 91.08,46.37 91.08,47.02 90.82,47.28 90.74,47.28 RZ120.2 90.56,47.58 91.82,47.58 UZ26.4
N38312012: length 2.4
  TOP w0.086: CT87.1 30.48,73.7 v2(30.24,73.94) 29.35,73.94 v1(29.25,74.04)
  BOTTOM w0.086: v2(30.24,73.94) 30.64,73.94 UT5.H7
N38327809: length 4.2
  BOTTOM w0.076: 34.52,73.78 32.98,73.78 UT5.D6
  BOTTOM w0.086: 34.52,73.78 34.73,73.99 36,73.99 RT101.1
N39070459: length 7
  TOP w0.086: v1(252.71,48.75) 253.42,48.04 QE11.3 252.85,45.17 252.85,44.08 253.33,43.6 RE70.1 RE90.2
N39070470: length 5.2
  TOP w0.086: v1(254.17,48.54) 254.17,47.01 254.66,46.52 QE4.2 254.66,45.28 254.32,44.94 253.88,44.94 RE70.2
N39317125: length 8.7
  TOP w0.254: v2(162.48,31.71) 161.87,31.1 159.94,31.1 v6(158.7,29.86) 158.03,29.19 PR424.1 PR423.1
  BOTTOM w0.254: v2(162.48,31.71) 162.67,31.9 PU402.5
N39469818: length 1.9
  TOP w0.086: v1(73.27,69.67) 73.01,69.93 PC631.1
  TOP w0.203: PR630.2 73.01,71.42 PC631.1
N39469863: length 4.4
  BOTTOM w0.203: 69.68,72.93 70.73,72.93 71.29,73.49 PU602.28
  BOTTOM w0.254: PC632.1 67.98,72.36 PR636.1 68.85,72.5 69.28,72.93 69.68,72.93
N39469972: length 2.4
  GND1 w0.203: v4(68.8,77.38) 68.33,77.85 v3(68.1,77.85)
  GND5 w0.203: v4(68.8,77.38) 69.03,77.61 v5(69.03,77.81)
  BOTTOM w0.203: PU602.38 69.25,77.53 69.03,77.75 v5(69.03,77.81)
N39469996:
  vias: v1(88.83,51.67) v2(89.85,50.45)
N39469998: length 1.6
  TOP w0.086: v1(86.16,54.54) 86.57,54.54 PC611.1
N39470129: length 2.2
  BOTTOM w0.086: v1(74.25,69.15) 74.41,69.31 PC640.1
  BOTTOM w0.203: PR646.2 74.41,70.88 PC640.1
N39470145: length 2.2
  BOTTOM w0.086: v1(76.23,69.49) 76.11,69.49 75.28,70.33 PC601.1
  BOTTOM w0.203: PR652.2 75.02,70.57 PC601.1
N39470173: length 1.9
  BOTTOM w0.086: v1(67.78,69.71) 68.11,70.04 PR641.1
  BOTTOM w0.254: PC632.2 67.97,70.71 PR641.1
N39470189: length 0.9
  BOTTOM w0.254: PR642.2 99.17,54.02 PH604.1
N39470446: length 4.3
  TOP w0.086: v2(68.37,75.8) 68.81,76.25 v1(68.81,76.36)
  TOP w0.254: PR602.1 68.37,75.9 v2(68.37,75.8)
  BOTTOM w0.203: v2(68.37,75.8) 68.5,75.93 PU602.34
  BOTTOM w0.254: PC603.1 68,75.8 v2(68.37,75.8)
N39470448: length 6.3
  TOP w0.086: PR603.1 67.48,72.22 v1(67.65,72.06)
  TOP w0.203: v2(68.42,75.17) 67.91,74.66 67.91,73.54 PR603.1
  BOTTOM w0.203: PU602.33 69.14,75.53 68.88,75.27 68.52,75.27 v2(68.42,75.17)
  BOTTOM w0.254: v2(68.42,75.17) 68.42,75.09 67.67,74.34 PC604.1
N39470528: length 2.6
  TOP w0.203: v2(68.55,74.51) 68.75,74.71 68.75,74.81 PR608.1
  BOTTOM w0.203: PU602.32 69.3,75.13 68.67,74.51 v2(68.55,74.51)
N39470532: length 3
  TOP w0.086: v2(68.55,73.92) v1(68.55,73.36)
  TOP w0.203: v2(68.55,73.92) 68.72,73.92 69.2,74.39 PR611.1
  BOTTOM w0.203: PU602.31 69.53,74.73 68.72,73.92 v2(68.55,73.92)
N40166471: length 9.2
  TOP w0.086: 25.77,42.63 RT193.1 27.09,42.63 27.47,43.01 27.96,43.01 28.12,42.85 v1(28.12,42.1) 28.12,41.54 v3(28.48,41.19) ; 25.77,42.63 RT191.2 ; 25.77,42.63 RT192.1
  GND1 w0.086: v4(28.96,41.19) v3(28.48,41.19)
  IN4 w0.051: v4(30.73,43.61) 30.73,42.96 v4(28.96,41.19)
  GND5 w0.086: v5(30.73,44.12) 30.72,44.11 30.72,43.62 v4(30.73,43.61)
N40166479: length 10.7
  TOP w0.086: v1(22.04,40.64) 22.27,40.41 v3(22.27,40.17) 21.91,40.17 RT181.1
  GND1 w0.086: v3(22.27,40.17) 23.13,40.17 v4(23.16,40.19)
  IN3 w0.061: v4(23.16,40.19) 23.16,40.27 23.66,40.78 23.66,43.37 24.28,43.99 25.55,43.99 26.05,44.48 26.38,44.48 26.74,44.13 v4(27.22,44.13)
  GND5 w0.086: v4(27.22,44.13) 27.71,44.62 v5(27.73,44.62)
N40166480: length 7.5
  TOP w0.086: v2(24.71,41.92) v1(23.93,41.14) 23.41,40.62 23.26,40.62 22.39,39.76 RT180.1
  IN4 w0.051: v2(24.71,41.92) 25.01,42.22 25.29,42.22 25.72,42.66 25.72,42.93 25.9,43.11 26.74,43.11 27.17,43.54 v4(27.22,43.54)
  GND5 w0.086: v5(27.73,44.12) 27.73,44.08 27.22,43.57 v4(27.22,43.54)
N40166593: length 5.2
  BOTTOM w0.086: UT11.F1 24.57,44.12 v1(24,44.7) 23.56,45.13 22.69,45.13 RT159.2
N40166639: length 2.2
  BOTTOM w0.076: 30.98,46.85 30.98,46.36 30.74,46.13 UT11.K10
  BOTTOM w0.086: 30.98,46.85 31.13,47 31.13,48.01 RT198.1
N40166640: length 2.3
  BOTTOM w0.076: UT11.K9 30.47,46.37 30.47,46.69
  BOTTOM w0.086: RT197.1 30,47.72 30.47,47.25 30.47,46.69
N40166643: length 2.2
  BOTTOM w0.086: RT196.1 31.98,47.27 31.87,47.27 UT11.L11
N40166736: length 2.2
  GND1 w0.086: v3(30.14,45.42) 30.01,45.56 v4(29.5,45.56)
  GND5 w0.086: v4(29.5,45.56) 29.99,45.56 v5(30.01,45.58)
  BOTTOM w0.086: UT11.H7 29.68,45.58 v5(30.01,45.58)
N40166740: length 3.9
  TOP w0.086: RT195.1 29.05,39.57 29.05,41.72 28.62,42.16 28.62,42.67 v2(28.61,42.67)
  BOTTOM w0.086: UT11.D6 28.73,42.79 28.65,42.7 28.62,42.7 28.62,42.67 v2(28.61,42.67)
N40421452: length 1.2
  TOP w0.117: v2(126.49,62.71) 127.04,62.71 T261.1
  BOTTOM w0.086: UC1.AT52 126.74,62.46 v2(126.49,62.71)
N40421453: length 6.9
  TOP w0.117: v2(128.31,58.25) 127.72,57.67 T260.1
  BOTTOM w0.076: UC1.AW50 127.62,60.43 127.62,59.91 arc(127.66,59.81) 127.67,59.71 127.67,59.56 127.64,59.49 127.64,59.21 127.65,59.19 127.81,59.03 128.09,59.03 128.31,58.82 v2(128.31,58.25)
N40421564: length 1.4
  TOP w0.117: T258.1 131.34,63.11 v2(131.07,63.38)
  BOTTOM w0.086: v2(131.07,63.38) 131.15,63.45 UC1.AP43
N40421565: length 1.2
  TOP w0.117: v2(131.99,64.02) 131.76,64.02 T257.1
  BOTTOM w0.086: UC1.AN43 v2(131.99,64.02)
N40421566: length 1.4
  TOP w0.086: T259.1 148.44,62.68 v2(148.44,62.11)
  BOTTOM w0.086: v2(148.44,62.11) 148.79,62.46 UC1.AT13
N41174761: length 3
  BOTTOM w0.086: QZ1.2 230.44,35.13 230.6,34.97 CZ200.1 231.3,34.97 232.07,35.75 RZ380.2
N41174762: length 1.5
  BOTTOM w0.086: QV2.1 227.09,29.77 RV5.2
N41174857: length 2.4
  BOTTOM w0.086: LV1.1 221.33,37.33 220.75,37.91 JEDP1.16
N41193025: length 3.7
  TOP w0.086: RC29.2 177.8,61.44 177.95,61.28 177.95,60.34 v1(178.64,59.65) 178.64,58.81 CC8.1
N41193026: length 0.9
  BOTTOM w0.086: RC28.2 CC7.1
N41308011: length 2.1
  BOTTOM w0.086: v1(280.08,41.74) 279.93,41.89 RZ334.1 279.93,43.42 CZ38.2
N41877854: length 5.2
  TOP w0.203: UA1.47 265.37,38.34 265.02,38.69 264.71,38.69
  TOP w0.254: 264.71,38.69 264.46,38.69 v1(263.87,39.28) 263.43,39.72 RA55.1 RA54.1
N41882113: length 6.9
  TOP w0.117: v1(274.3,41.23) 273.62,40.56 CA35.1 272.66,39.89 272.13,39.89 270.89,38.65 269.33,38.65 268.97,38.3 UA1.38
N41884313: length 2.6
  TOP w0.203: CA25.1 272.11,35.2 270.74,35.2 270.66,35.12 UA1.31
N41884577: length 4.9
  TOP w0.086: CA49.1 271.36,29.86 272.54,28.69 v1(272.67,28.69)
  TOP w0.203: UA1.24 269.37,31.49 269.98,30.88 270.24,30.88 271.22,29.9 CA49.1
N41886761: length 5.3
  TOP w0.086: v1(270.16,27.26) 270.09,27.33 CA29.2
  TOP w0.203: UA1.22 268.57,31.25 269.41,30.41 269.41,29.19 CA29.2
N41886763: length 2.4
  TOP w0.203: CA29.1 270.09,30.26 268.97,31.38 UA1.23
N41887296: length 2.3
  TOP w0.203: CA52.1 267,30.32 267,30.66 266.57,31.09 UA1.17
N41887299: length 4.3
  TOP w0.203: UA1.13 264.97,31.31 264.15,30.49 v1(263.63,30.49) 262.49,30.49 CA53.1
N41887876: length 5.8
  TOP w0.117: UA1.39 268.57,38.28 269.19,38.9 270.5,38.9 v1(270.93,39.33) 272.08,40.47 RA44.1 272.15,41.22 CA51.1
N44315031: length 9.9
  TOP w0.203: v2(58.59,36.92) 58.41,36.74 PU901.29
  TOP w0.254: PR947.1 63.89,41.23 PR935.1 63.11,40.36 PC947.1 63.12,39.67 v2(62.78,39.33)
  BOTTOM w0.203: v2(58.59,36.92) 61.51,36.92 v1(62.43,37.84) 62.78,38.19 v2(62.78,39.33)
N44321922: length 7.9
  TOP w0.086: v1(67.02,39.85) 66.62,39.85 PR961.1 66.71,38.68 PD905.1 66.7,37.79 PU903.1 65.36,37.21 64.56,36.41 64.56,35.21 PR950.1
N44325464: length 6.4
  TOP w0.086: UE1.G2 259.72,59.34 257.05,59.34 256.93,59.46 254.81,59.46 RE318.1
N44325691: length 1.8
  TOP w0.086: RE350.2 CE57.1 v1(252.65,59.14)
N44519702: length 3.2
  TOP w0.203: PR948.1 PR936.1 58.89,37.93 58.1,37.14 PU901.30
N44583000: length 5.3
  BOTTOM w0.086: PQ1209.3 56.6,88.55 PR1226.2 56.6,88.91 56.9,89.21 58.36,89.21 PR1229.1 v1(58.84,89.75)
N44583529: length 4.1
  BOTTOM w0.086: v1(55.44,88.78) 54.96,88.3 54.96,87.02 54.82,86.88 PR1233.1 54.48,86.54 54.71,86.32 PQ1209.2
N44585173: length 1.3
  TOP w0.086: PR1265.1 34.84,31.4 PQ1218.2
N44585176: length 5.9
  TOP w0.086: PR1251.2 36.67,32.39 36.16,31.89 PR1260.1 35.73,30.99 PQ1218.3 34.27,28.6 v1(34.08,28.41)
N44590042: length 38.5
  TOP w0.086: RZ326.1 241.9,77.96 241.9,89.86 v1(241.8,89.96) 240.92,90.84 239.65,90.84 v2(238.83,91.66)
  IN1 w0.051: v2(229.02,82.74) 228.64,83.12 228.64,83.16 228.64,83.48 228.64,83.48 228.64,83.75 228.64,83.75 228.64,84.06 228.64,84.06 228.64,84.95 227.88,85.71 227.88,87.26 227.22,87.92 227.22,91.38 228.1,92.27 238.23,92.27 v2(238.83,91.66)
  BOTTOM w0.086: v2(229.02,82.74) 229.11,82.65 JNGFF2.25
N44616404: length 6.8
  BOTTOM w0.086: PR1293.2 68.46,83.92 PR1289.1 69.02,85.57 67.82,85.57 67.7,85.44 PQ1220.5 67.48,84.66 67.48,84.08 v1(67.07,83.67) 66.95,83.55 PR1273.2
N44616413: length 6.7
  BOTTOM w0.086: PQ1221.4 65.55,84.34 65.83,84.06 66.68,84.06 67.05,84.43 PQ1220.6 67.05,85.34 67.65,85.94 69.56,85.94 PR1267.1
N44617199: length 7.7
  BOTTOM w0.086: v1(78.4,84.97) PR1294.2 77.36,84.97 76.45,85.89 PR1274.2 75.94,85.89 75.23,85.18 74.69,85.18 74.48,84.96 PQ1223.5 74.48,84.36 74.72,84.12 75.98,84.12 PR1290.1
N44618351: length 2.4
  BOTTOM w0.086: PQ1221.5 64.9,84.21 65.19,83.92 PR1263.1 PR1276.2
N44618356: length 2.3
  BOTTOM w0.086: PQ1221.2 64.9,86.95 65.24,87.3 PR1264.1 64.25,87.72 PR1275.2
N44618521: length 1.8
  BOTTOM w0.086: PR1292.2 70.45,87.4 70.6,87.25 71.3,87.25 71.54,87 PQ1222.2
N44621211: length 87.1
  TOP w0.117: v3(58.91,34.56) 58.47,35 58.47,35.2 58.13,35.54 PU901.26
  GND1 w0.117: v4(59.29,35.25) 59.29,34.94 v3(58.91,34.56)
  IN3 w0.061: v4(70.18,83.59) 70.2,83.57 70.2,83.24 66.44,79.49 52.52,79.49 48.74,75.71 46.91,75.71 45.37,74.17 45.37,61.76 44.75,61.13 44.75,48.74 44.82,48.67 44.82,45.07 45.57,44.32 47.43,44.32 47.86,43.89 47.86,41.97 47.42,41.54 47.42,36.91 47.09,36.58 47.09,35.31 47.22,35.19 47.8,35.19 v4(48.48,35.86)
  IN4 w0.069: v4(59.29,35.25) 59.05,35.01 51.21,35.01 50.89,35.33 49.01,35.33 v4(48.48,35.86)
  GND5 w0.086: v4(70.18,83.59) 70.42,83.83 v5(70.79,83.83)
N44641625: length 13.5
  BOTTOM w0.086: JNGFF2.67 231,72.15 231.14,72.01 231.14,69.78 230.26,68.89 230.26,67.47 230.71,67.01 232.87,67.01 233.39,66.49 235.23,66.49 235.64,66.09 T225.1
N44686334: length 3.8
  BOTTOM w0.086: PR1279.1 46.36,82.03 PQ1225.2 ; PR1279.1 PR1277.2 ; PR1279.1 45.45,82.37 v1(45.06,82.76)
N44687883: length 5.4
  TOP w0.086: v1(47.78,39.9) 47.41,40.27 47.41,41.58 47.28,41.7 PR1280.2 PR1282.1 46.65,40.63 PQ1227.2
N44737537: length 1.7
  TOP w0.254: PR1246.1 45.17,36.69 44.82,36.34 PQ1216.3
N44759345: length 5.5
  TOP w0.086: v1(199.19,32.37) 198.21,33.35 RE560.1 197.98,33.12 196.71,33.12 RE375.1 195.98,32.4 JESPI.8
N45172969: length 2.2
  TOP w0.086: QZ3.1 251.39,88.3 RZ511.1 v1(250.49,89.33)
N45269992: length 5.1
  TOP w0.086: v1(237.44,30.66) 237.28,30.82 237.28,32.04 RZ65.2 RZ64.2 235.83,32.55 235.2,33.18 235.02,33.18 234.63,33.57 UZ2.5
N45270557: length 3.9
  TOP w0.086: v1(234.89,39.59) 235.12,39.37 235.12,38.11 234.71,37.7 CZ113.1 234.62,37.68 234.62,36.05 UZ2.10
N45874245: length 2.4
  TOP w0.117: RT390.1 RT389.2 35.75,26.28 UT7.3
N45874265: length 4.6
  TOP w0.086: CT90.1 32.96,29.92 RT111.2 31.45,29.64 v1(31.45,28.67) UT7.5
N45903768: length 11.8
  TOP w0.086: RZ132.2 226.1,66.04 v2(227.46,67.4)
  IN4 w0.051: v2(227.46,67.4) 230.15,70.09 230.15,72.89 231.67,74.4 JNGFF2.58
N46477010: length 2.5
  TOP w0.086: v1(185.95,35.81) 185.6,36.15 CZ306.1 184.83,36.35 UZ41.6
N46814682: length 23.8
  IN3 w0.203: v2(86.24,77.29) 86.34,77.39 86.34,79.33 85.27,80.4 78.57,80.4 76.66,78.49 75.19,78.49 74.77,78.91 71.84,78.91 70.53,80.22 70.53,81.08 v4(70.45,81.15)
  GND5 w0.203: v5(69.92,81.61) 70.38,81.15 v4(70.45,81.15)
  BOTTOM w0.203: v2(86.24,77.29) 85.9,76.95 PH601.2 ; PR610.1 69.48,82.05 v5(69.92,81.61)
  BOTTOM w0.254: PR631.2 69.48,82.89 PR610.1
N46814700: length 2.4
  TOP w0.086: PR632.2 v3(72.68,82.96)
  GND1 w0.086: v3(72.68,82.96) 72.79,83.07 v4(72.79,83.55)
  GND5 w0.086: v5(72.36,82.61) 72.36,83.09 72.79,83.52 v4(72.79,83.55)
  BOTTOM w0.086: PC627.1 72.1,82.36 v5(72.36,82.61)
N46814728: length 3.9
  TOP w0.254: PR628.2 99.22,76.59 98.21,75.59 v2(98.21,75.14)
  BOTTOM w0.203: v2(98.21,75.14) 98.21,73.6 PH602.1
N46814746: length 3.4
  BOTTOM w0.203: PC627.2 72.11,81.16 72.98,81.16 PR638.2 73.53,80.61 73.53,80.03 73.29,79.79 PU602.8
N46814769: length 0.9
  TOP w0.203: PR621.1 70.83,82.83 70.92,82.92 PC617.2
N46815156: length 3.2
  BOTTOM w0.203: PU602.1 70.06,79 v1(68.93,80.13) 68.61,80.45 PR620.2
N46815164: length 3.8
  TOP w0.086: v3(69.87,84.33) v1(69.87,85.29)
  TOP w0.254: PC621.2 v3(69.87,84.33)
  GND1 w0.254: v4(69.47,83.56) 69.87,83.96 v3(69.87,84.33)
  GND5 w0.254: v5(70.12,82.91) v4(69.47,83.56)
  BOTTOM w0.254: v5(70.12,82.91) 70.35,82.69 PR623.1
N46815166: length 4.9
  TOP w0.203: v2(71.91,80.2) 71.91,80.27 71.49,80.68 71.3,80.68 PR621.2
  BOTTOM w0.203: 71.88,80.2 72.09,79.99 PU602.5 ; 71.88,80.2 71.87,80.2 71.87,80.3 71.23,80.95 PR622.2 PR623.2 ; 71.88,80.2 v2(71.91,80.2)
N46815186: length 4.1
  TOP w0.203: PC616.2 71.32,79.47 v2(71.32,80.2) 70.89,80.2 PR617.2
  BOTTOM w0.203: PU602.4 71.69,79.66 71.32,80.02 v2(71.32,80.2)
N46815188: length 2
  TOP w0.086: PC614.2 69.06,81.12 v1(68.98,81.03)
  TOP w0.203: PC614.2 69.11,82.06 PR617.1
N46815204: length 3
  BOTTOM w0.203: PR610.2 69.98,80.65 70.22,80.65 71.29,79.59 PU602.3
N46815214: length 3.2
  TOP w0.203: PR613.2 69.89,79.66 70.5,79.66 ; v2(70.07,80.16) 70.15,80.08 70.15,80.02 70.5,79.66 ; 70.5,79.66 PC613.2
  BOTTOM w0.203: v2(70.07,80.16) 70.15,80.08 70.15,80.04 70.35,79.84 70.54,79.84 70.89,79.49 PU602.2
