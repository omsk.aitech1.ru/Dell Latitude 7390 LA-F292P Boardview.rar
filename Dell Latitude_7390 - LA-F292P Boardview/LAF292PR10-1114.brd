# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D45: length 25.9
  IN1 w0.08: v2(121.27,41.1) 120.87,40.77 120.76,40.73 120.59,40.7 118.76,40.7 118.61,40.72 118.5,40.76 118.33,40.85 116.74,42.45 116.69,42.58 116.69,43.52 116.71,43.75 116.74,43.86 117.01,44.64 117.06,44.97 117.06,46.52 117.12,46.7 117.23,46.97 117.34,47.13 121.44,51.23 121.44,52.97 121.52,53.13 121.61,53.22 121.68,53.43 121.68,55.91 121.71,56.18 121.74,56.28 121.84,56.45 v2(122.12,56.73)
  BOTTOM w0.076: UD2.D9 v2(121.27,41.1) ; UC1.AY61 121.82,59.9 121.82,59.63 121.87,59.48 121.87,59.21 121.86,59.18 121.86,58.86 121.87,58.83 121.87,58.41 121.63,58.17 121.63,57.3 122.12,56.81 v2(122.12,56.73)
DDR_A_D46: length 25.6
  IN1 w0.08: v2(123.57,55.56) 123.81,55.8 123.9,55.8 124.03,55.67 124.03,54.86 123.74,54.57 123.74,54.39 124.03,54.1 124.03,53.42 124.23,53.22 124.23,49.47 122.77,48.01 122.47,48.01 122.39,47.93 122.39,47.69 122.47,47.61 122.6,47.61 122.68,47.52 122.68,47.3 122.6,47.22 121.57,47.22 121.46,47.1 121.46,46.94 121.57,46.82 122.57,46.82 122.68,46.7 122.68,46.54 122.57,46.42 122,46.42 121.89,46.3 121.89,46.14 122,46.02 122.57,46.02 122.68,45.9 122.68,44.95 122.5,44.76 122.3,44.76 122.01,45.04 122.01,45.27 121.86,45.42 121.86,45.6 121.76,45.7 121.65,45.7 121.46,45.5 121.46,45.12 121.38,45.04 121,45.04 120.9,44.94 120.9,44.61 v2(121.11,44.4)
  BOTTOM w0.076: v2(121.11,44.4) 121.27,44.24 121.27,43.41 UD2.E11 ; UC1.BA59 123,59.23 123,59.04 123.2,58.85 123.2,58.55 123.05,58.4 123.05,56.37 123.21,56.2 123.21,55.91 v2(123.57,55.56)
DDR_A_D47: length 26.3
  IN1 w0.08: v2(120.65,42.75) 121,42.75 121.1,42.64 121.1,41.64 121.2,41.54 121.41,41.54 121.51,41.64 121.51,43.39 121.38,43.52 120.87,43.52 120.78,43.61 120.78,43.82 120.88,43.93 121.4,43.93 121.51,44.03 121.51,44.76 121.61,44.87 121.81,44.87 121.91,44.76 121.91,44.13 121.99,44.05 122.16,44.05 122.62,44.52 122.84,44.52 122.95,44.64 122.95,47.81 124.5,49.36 124.5,53.33 124.32,53.51 124.32,55.76 123.9,56.18 v2(123.57,56.18)
  BOTTOM w0.076: v2(123.57,56.18) 123.22,56.53 123.22,58.33 123.36,58.48 123.36,58.91 123.2,59.08 123.2,59.54 122.94,59.79 UC1.AY59 ; UD2.E10 v2(120.65,42.75)
DDR_A_D48: length 27.5
  IN1 w0.08: v2(113.48,41.11) 113.32,40.95 112.92,40.95 112.46,41.42 112.07,41.42 111.93,41.28 111.76,41.28 111.56,41.48 111.56,45.5 113.77,47.71 113.77,47.92 118.09,52.24 118.09,57.34 118.5,57.75 118.5,59.36 117.66,60.19 117.66,61.51 v2(118.27,62.11)
  BOTTOM w0.076: v2(113.48,41.11) 113.81,41.51 UD2.T9 ; v2(118.27,62.11) UC1.AT66
DDR_A_D49: length 26.9
  IN1 w0.08: v2(118.27,61.48) 117.9,61.11 117.9,60.38 118.79,59.49 118.79,57.63 118.36,57.2 118.36,52.13 114.04,47.81 114.04,47.6 111.83,45.39 111.83,42.5 112.07,42.26 112.44,42.26 113.06,41.64 114.22,41.64 114.33,41.52 114.33,41.33 v2(114.12,41.12)
  BOTTOM w0.076: UD2.R9 v2(114.12,41.12) ; UC1.AU66 v2(118.27,61.48)
DDR_A_D50: length 30
  IN1 w0.08: v2(119.18,64.02) 119.59,64.43 120.27,64.43 120.54,64.16 120.54,60.33 120.98,59.89 120.98,53.57 120.74,53.33 120.74,51.46 116.41,47.13 116.41,46.92 116.29,46.8 116.09,46.8 115.97,46.68 115.97,46.52 116.09,46.4 116.29,46.4 116.41,46.28 116.41,46.12 116.29,46 115.37,46 115.26,45.88 115.26,45.72 115.37,45.6 116.29,45.6 116.41,45.48 116.41,45.3 116.3,45.19 114.46,45.19 114.29,45.01 114.29,43.7 v2(114.12,43.53)
  BOTTOM w0.076: UC1.AP65 v2(119.18,64.02) ; UD2.R11 v2(114.12,43.53)
DDR_A_D51: length 30.7
  IN1 w0.08: v2(114.11,42.71) 114.56,43.15 114.56,43.42 114.66,43.53 114.95,43.53 115.05,43.63 115.05,43.83 114.95,43.93 114.66,43.93 114.56,44.03 114.56,44.6 114.88,44.92 116.58,44.92 116.68,45.01 116.68,47.02 121.01,51.35 121.01,53.19 121.27,53.45 121.27,57.38 121.43,57.54 121.43,64.94 121.25,65.11 119.3,65.11 119.18,65 v2(119.18,64.65)
  BOTTOM w0.076: UC1.AN65 v2(119.18,64.65) ; UD2.R10 v2(114.11,42.71)
DDR_A_D52: length 30.3
  IN1 w0.08: v2(118.27,64.02) 117.26,63.01 117.26,59.83 117.7,59.39 117.7,59.01 117.55,58.86 117.55,52.47 113.23,48.15 113.23,47.93 111.02,45.72 111.02,41.23 112.07,40.18 v2(113.55,40.18)
  BOTTOM w0.076: UD2.T8 113.81,40.7 v2(113.55,40.18) ; UC1.AN66 v2(118.27,64.02)
DDR_A_D53: length 29.8
  IN1 w0.08: v2(118.27,63.38) 117.49,62.61 117.49,59.98 117.97,59.51 117.97,57.63 117.82,57.48 117.82,52.35 113.5,48.04 113.5,47.82 111.29,45.61 111.29,41.37 112.07,40.59 113.85,40.59 v2(114.17,40.27)
  BOTTOM w0.076: UC1.AP66 v2(118.27,63.38) ; UD2.R8 v2(114.17,40.27)
DDR_A_D54: length 28.8
  IN1 w0.08: v2(119.18,62.11) 119.55,61.75 119.55,60.84 119.65,60.74 119.82,60.74 119.96,60.88 120.12,60.88 120.24,60.76 120.24,60.6 120.1,60.45 120.1,60.29 120.69,59.7 120.69,59.55 120.57,59.44 120.2,59.44 120.08,59.32 120.08,59.15 120.2,59.04 120.57,59.04 120.69,58.92 120.69,53.69 120.19,53.19 120.19,53.02 120.47,52.74 120.47,52.54 120.26,52.33 120.26,52.06 120.47,51.85 120.47,51.57 119.91,51.02 119.75,51.02 119.48,51.28 119.31,51.28 119.2,51.17 119.2,51 119.46,50.73 119.46,50.57 119.35,50.45 119.18,50.45 118.91,50.72 118.75,50.72 118.63,50.6 118.63,50.43 118.9,50.17 118.9,50 115.7,46.8 115.7,46.36 115.61,46.27 115.17,46.27 114.88,45.98 114.88,45.83 114.99,45.72 114.99,45.56 114.88,45.46 114.35,45.46 114.02,45.13 114.02,44.76 113.94,44.68 113.65,44.68 113.53,44.57 113.53,44.36 113.61,44.28 113.94,44.28 114.02,44.2 114.02,43.98 113.91,43.87 113.57,43.87 113.49,43.8 v2(113.49,43.5)
  BOTTOM w0.076: v2(119.18,62.11) UC1.AT65 ; UD2.T11 v2(113.49,43.5)
DDR_A_D55: length 28
  IN1 w0.08: v2(113.49,42.73) 113.49,42.93 113.07,43.35 113.07,43.84 113.24,44.02 113.24,44.73 113.58,45.06 113.58,45.23 113.41,45.39 113.41,45.56 113.53,45.68 113.7,45.68 113.86,45.51 114.03,45.51 114.57,46.06 114.57,46.23 114.41,46.39 114.41,46.56 114.53,46.67 114.69,46.67 114.86,46.51 115.02,46.51 115.66,47.15 115.66,47.31 115.52,47.45 115.52,47.62 115.64,47.73 115.8,47.73 115.94,47.6 116.11,47.6 116.23,47.71 116.23,47.88 115.97,48.13 115.97,48.3 116.09,48.41 116.25,48.41 116.51,48.16 116.67,48.16 116.79,48.28 116.79,48.44 116.7,48.53 116.7,48.7 116.82,48.82 116.99,48.82 117.07,48.73 117.24,48.73 117.36,48.84 117.36,49.01 117.27,49.1 117.27,49.26 117.39,49.38 117.55,49.38 117.64,49.29 117.81,49.29 117.92,49.41 117.92,49.58 117.83,49.66 117.83,49.83 117.95,49.95 118.12,49.95 118.21,49.86 118.37,49.86 118.53,50.02 118.53,50.15 118.36,50.32 118.36,50.71 119.37,51.72 119.37,53.11 119.71,53.46 120.04,53.46 120.4,53.82 120.4,58.27 119.8,58.86 119.8,59.98 119.18,60.59 v2(119.18,61.48)
  BOTTOM w0.076: UD2.T10 113.81,42.33 v2(113.49,42.73) ; v2(119.18,61.48) UC1.AU65
DDR_A_D56: length 30.2
  IN4 w0.08: v2(121.92,41.1) 121.52,40.7 119.84,40.7 119.58,40.96 119.58,41.21 118.79,42 118.79,42.22 118.87,42.3 119.5,42.3 119.75,42.54 119.75,43.74 119.44,44.05 118.76,44.05 118.37,44.44 118.37,45.24 118.56,45.42 118.81,45.42 118.94,45.55 118.94,47.1 122.9,51.06 122.9,53.07 122.87,53.1 122.87,58.18 121.24,59.81 121.09,59.81 120.64,60.25 120.64,60.89 120.65,60.91 120.65,61.63 121.01,61.98 v2(121.01,62.11)
  BOTTOM w0.076: UC1.AT61 v2(121.01,62.11) ; UD2.C9 v2(121.92,41.1)
DDR_A_D57: length 29.1
  IN4 w0.08: v2(123.23,41.09) 122.81,41.51 122.16,41.51 122.16,41.51 121.63,41.51 120.8,42.34 120.19,42.34 120.04,42.49 120.04,43.86 119.44,44.46 119.44,44.82 119.34,44.92 119.21,44.92 119.12,44.82 119.12,44.42 119.02,44.32 118.87,44.32 118.64,44.55 118.64,45.07 118.73,45.15 118.93,45.15 119.21,45.44 119.21,46.99 123.19,50.97 123.19,53.71 123.16,53.73 123.16,57.77 123.26,57.86 123.42,57.86 123.51,57.95 123.51,58.09 123.42,58.18 123.26,58.18 123.16,58.27 123.16,58.39 121.41,60.15 121.41,60.67 121.01,61.07 v2(121.01,61.46)
  BOTTOM w0.076: UC1.AU61 v2(121.01,61.46) ; UD2.B8 v2(123.23,41.09)
DDR_A_D58: length 32.4
  IN4 w0.08: v2(121.93,64.02) 122.39,63.56 122.39,61.99 123.06,61.33 123.06,60.49 123.48,60.06 124.39,60.06 126.19,58.26 126.19,57.18 126.29,57.08 126.38,57.08 126.49,56.97 126.49,56.21 126.5,56.19 126.5,51.61 126.32,51.43 126.19,51.43 125.95,51.67 125.82,51.67 125.72,51.57 125.72,51.44 125.96,51.2 125.96,51.07 125.87,50.98 125.73,50.98 125.52,51.19 125.39,51.19 125.3,51.09 125.3,50.96 125.51,50.75 125.51,50.62 125.41,50.52 125.28,50.52 125.07,50.74 124.94,50.74 124.84,50.64 124.84,50.51 125.06,50.3 125.06,50.16 124.96,50.07 124.83,50.07 124.73,50.17 124.6,50.17 124.51,50.07 124.51,49.94 124.6,49.84 124.6,49.71 124.51,49.62 124.38,49.62 124.28,49.72 124.15,49.72 124.05,49.62 124.05,49.49 124.15,49.39 124.15,49.26 124.06,49.17 123.92,49.17 123.83,49.26 123.69,49.26 123.6,49.17 123.6,49.04 123.7,48.94 123.7,48.81 123.6,48.71 123.47,48.71 123.37,48.81 123.24,48.81 123.15,48.72 123.15,48.45 123.23,48.37 123.44,48.37 123.52,48.29 123.52,48.15 123.44,48.07 123.13,48.07 123.04,47.98 123.04,44.72 122.73,44.41 122.73,43.87 122.83,43.77 123.46,43.77 123.56,43.67 123.56,43.46 123.46,43.36 122.99,43.36 122.89,43.26 122.89,43.1 v2(123.26,42.73)
  BOTTOM w0.076: UC1.AP60 v2(121.93,64.02) ; UD2.B11 v2(123.26,42.73)
DDR_A_D59: length 32.8
  IN4 w0.08: v2(121.93,64.67) 122.72,64.67 123.38,64.01 123.38,62.36 123.29,62.26 123.2,62.26 123.11,62.17 123.11,62.04 123.2,61.94 123.29,61.94 123.38,61.85 123.38,61.28 124.32,60.34 124.5,60.34 126.78,58.06 126.78,57.91 126.68,57.82 126.6,57.82 126.51,57.73 126.51,57.59 126.6,57.5 126.68,57.5 126.78,57.41 126.78,56.48 126.77,56.47 126.77,51.5 123.85,48.57 123.85,47.81 123.76,47.71 123.43,47.71 123.33,47.62 123.33,47.49 123.43,47.39 123.76,47.39 123.85,47.3 123.85,47.17 123.76,47.07 123.43,47.07 123.33,46.98 123.33,46.85 123.43,46.75 123.76,46.75 123.85,46.66 123.85,46.53 123.76,46.43 123.43,46.43 123.33,46.34 123.33,46.21 123.43,46.11 123.76,46.11 123.85,46.02 123.85,45.89 123.76,45.79 123.43,45.79 123.33,45.7 123.33,45.57 123.43,45.47 123.76,45.47 123.85,45.38 123.85,45.25 123.76,45.15 123.43,45.15 123.33,45.06 123.33,44.93 123.43,44.83 123.76,44.83 123.85,44.74 123.85,42.13 123.63,41.91 v2(123.25,41.91)
  BOTTOM w0.076: UC1.AN60 v2(121.93,64.67) ; UD2.B10 v2(123.25,41.91)
DDR_A_D60: length 32
  IN4 w0.08: v2(121.01,64.02) 120.47,63.47 120.47,62.01 120.32,61.86 120.32,61.3 120.05,61.03 120.05,59.84 121.69,58.2 121.69,50.61 117.83,46.76 117.83,43.92 117.9,43.85 117.9,41.34 118.54,40.7 118.67,40.7 119.8,39.57 121.73,39.57 v2(122.35,40.19)
  BOTTOM w0.076: UD2.C8 v2(122.35,40.19) ; v2(121.01,64.02) UC1.AN61
DDR_A_D61: length 31.2
  IN4 w0.08: v2(122.58,41.11) 122.12,40.54 121.5,39.92 121.3,39.86 120.11,39.86 119.94,39.89 119.87,39.93 119.62,40.18 119.21,41.09 118.97,41.44 118.53,41.87 118.35,42.42 118.2,43.47 118.2,43.96 118.1,44.33 118.1,46.55 118.21,46.75 121.92,50.47 122.36,51.09 122.57,51.57 122.61,51.8 122.61,52.95 122.58,52.98 122.58,57.82 122.54,58.04 122.43,58.21 122.14,58.5 121.43,59.05 120.41,60.07 120.32,60.44 120.32,60.99 120.49,61.16 120.49,61.75 120.64,61.91 120.64,62.48 v2(121.01,63.38)
  BOTTOM w0.076: v2(121.01,63.38) UC1.AP61 ; UD2.B9 v2(122.58,41.11)
DDR_A_D62: length 31.9
  IN4 w0.08: v2(121.93,62.11) 122.81,61.24 122.81,60.48 123.51,59.78 124.28,59.78 125.64,58.41 125.64,58.13 125.74,58.03 125.76,58.03 125.85,57.94 125.85,57.81 125.76,57.71 125.74,57.71 125.64,57.62 125.64,57.49 125.74,57.39 125.76,57.39 125.85,57.3 125.85,57.17 125.54,56.85 125.54,51.79 125.08,51.33 124.94,51.33 124.7,51.58 124.56,51.58 124.47,51.49 124.47,51.35 124.72,51.11 124.72,50.97 124.46,50.71 124.46,50.47 122.48,48.49 122.48,48.37 122.77,48.08 122.77,46.68 122.68,46.59 121.73,46.59 121.63,46.49 121.63,46.08 121.35,45.81 121.2,45.81 121.07,45.68 121.07,45.42 121.23,45.27 121.4,45.27 122.39,46.26 122.68,46.26 122.77,46.17 122.77,44.87 122.69,44.79 122.5,44.79 122.01,45.27 121.84,45.27 121.74,45.18 121.74,45.06 122.45,44.36 122.45,43.75 122.6,43.59 122.6,43.46 122.51,43.37 122.36,43.37 122.27,43.28 122.27,43.14 122.36,43.05 122.51,43.05 122.6,42.96 v2(122.6,42.73)
  BOTTOM w0.076: UD2.C10 v2(122.6,42.73) ; v2(121.93,62.11) UC1.AT60
DDR_A_D63: length 31
  IN4 w0.08: v2(121.92,43.51) 122.17,43.77 122.17,44.15 122.09,44.23 121.98,44.23 121.62,43.87 121.49,43.87 121.39,43.96 121.39,44.1 121.73,44.43 121.73,44.62 121.4,44.94 121.15,44.94 120.65,45.44 120.65,47.05 120.89,47.28 121,47.28 121.1,47.18 121.1,46.95 121.18,46.87 122.42,46.87 122.5,46.95 122.5,47.97 122.21,48.26 122.21,48.6 124.19,50.58 124.19,51.79 124.28,51.88 125.15,51.88 125.24,51.97 125.24,52.11 125.15,52.2 124.28,52.2 124.19,52.29 124.19,52.43 124.28,52.52 125.15,52.52 125.24,52.61 125.24,52.75 125.15,52.84 124.28,52.84 124.19,52.93 124.19,53.06 124.38,53.25 125.11,53.25 125.21,53.35 125.21,57.06 125.37,57.21 125.37,58.32 124.17,59.52 123.43,59.52 122.5,60.45 122.5,60.91 v2(121.93,61.48)
  BOTTOM w0.076: UD2.C11 v2(121.92,43.51) ; UC1.AU60 v2(121.93,61.48)
DDR_A_DQS0: length 34.8
  IN4 w0.094: v2(101.16,42.73) 101.4,42.97 101.4,43.55 102.16,44.32 102.16,46.47 102.57,46.87 105.21,46.87 106,47.66 106,49.59 112.23,55.82 112.23,58.9 112.32,58.99 112.32,60.38 112.26,60.45 112.26,63.06 112.04,63.28 v2(111.65,63.28)
  BOTTOM w0.076: UD1.L10 v2(101.16,42.73) ; UC1.AM69 117.08,64.95 116.96,65.07 116.94,65.13 116.84,65.18 116.56,65.31 116.37,65.31 116.25,65.25 116.03,65.25 115.92,65.3 115.75,65.3 115.61,65.24 115.35,65.24 115.33,65.26 113.13,65.26 112.28,64.41 112.01,64.41 111.61,64.01 111.61,63.72 111.75,63.58 111.75,63.37 v2(111.65,63.28)
DDR_A_DQS1: length 36
  IN1 w0.094: v2(99.19,41.91) 98.99,42.11 97.72,42.11 97.61,42.22 97.38,42.22 96.91,42.69 96.91,43.46 96.81,43.56 96.64,43.56 96.42,43.77 96.42,44.23 98.41,46.22 99,46.22 100.34,47.57 102.91,47.57 106.9,51.56 107.91,51.56 112.13,55.78 112.13,58.95 112.32,59.14 112.32,60.11 112.53,60.32 112.55,60.32 v2(112.92,60.69)
  BOTTOM w0.076: UC1.AT70 116.69,62.5 116.73,62.46 116.73,62.31 116.72,62.3 116.59,62.23 116.37,62.23 116.29,62.27 116.01,62.27 115.88,62.22 115.78,62.22 115.64,62.27 114.79,62.27 113.54,61.03 113.54,60.78 113.26,60.5 113.11,60.5 v2(112.92,60.69) ; UD1.P10 v2(99.19,41.91)
DDR_A_DQS2: length 33.6
  IN4 w0.076: 118.2,65.95 118.22,65.95 118.23,65.95 119.31,65.95 119.52,66.16 119.52,66.37 119.63,66.49 v2(119.72,66.49)
  IN4 w0.094: v2(106.39,41.91) 106.58,42.11 107.94,42.11 109.16,43.33 109.16,47.08 111.52,49.44 112.39,49.44 114.16,51.21 114.16,52.21 116.25,54.29 116.25,57.96 116.78,58.5 116.78,62.08 116.39,62.48 116.39,64.35 117.98,65.95 118.2,65.95
  BOTTOM w0.076: UD1.D10 v2(106.39,41.91) ; UC1.AH65 v2(119.72,66.49)
DDR_A_DQS3: length 42.5
  IN1 w0.094: v2(112.99,66.53) 113.19,66.73 113.19,66.97 113.46,67.24 115.07,67.24 115.6,66.71 115.6,54.18 115.16,53.74 115.16,53.57 115.6,53.12 115.6,52.79 115.23,52.42 114.89,52.42 114.48,52.83 114.23,52.83 114.05,52.65 114.05,52.4 114.43,52.03 114.43,51.62 114.14,51.33 113.74,51.33 113.37,51.7 113.12,51.7 112.95,51.52 112.95,51.27 113.31,50.91 113.31,50.5 113.02,50.21 112.37,50.21 112.19,50.03 112.19,49.38 111.97,49.16 111.63,49.16 111.35,49.44 111.13,49.44 111.01,49.31 111.01,48.87 110.46,48.32 110.02,48.32 108.63,46.93 108.63,46.49 108.4,46.26 107.96,46.26 107.3,45.6 106.9,45.6 106.62,45.88 106.39,45.88 105.82,45.31 105.82,44.19 105.15,43.53 105.15,43.37 104.83,43.05 104.72,43.05 v2(104.41,42.74)
  BOTTOM w0.076: v2(112.99,66.53) 113.18,66.72 113.18,66.89 113.56,67.27 115.63,67.27 115.74,67.22 115.91,67.22 116.04,67.28 116.27,67.28 116.48,67.49 UC1.AG70 ; UD1.G10 v2(104.41,42.74)
DDR_A_DQS4: length 29.2
  IN4 w0.094: v2(117.41,42.71) 117.41,42.72 117.41,42.92 117.3,43.03 116.97,43.03 116.82,42.87 116.82,42.55 116.31,42.05 113.31,42.05 112.89,42.47 112.89,45.86 114,46.97 115.42,46.97 117.12,48.68 117.12,50.87 119.74,53.49 120.08,53.49 120.4,53.82 120.4,55.27 120.31,55.37 120.18,55.37 v2(119.99,55.18)
  BOTTOM w0.076: v2(119.99,55.18) 119.81,55.36 119.66,55.36 119.38,55.64 119.38,58.39 119.52,58.53 119.52,58.86 119.49,58.91 119.49,59.16 119.53,59.24 119.53,59.42 119.46,59.57 119.46,59.78 119.57,60.02 119.62,60.12 UC1.AY64 ; UD2.L10 v2(117.41,42.71)
DDR_A_DQS5: length 23.8
  IN1 w0.094: v2(119.33,42.72) 119.56,42.95 119.7,42.95 120.1,43.35 120.1,44.08 119.84,44.34 118.96,44.34 118.86,44.43 118.86,44.79 119.24,45.16 119.44,45.16 120.36,46.08 120.36,46.67 120.08,46.95 119.89,46.95 119.72,47.13 119.72,47.38 119.89,47.56 120.08,47.56 120.36,47.84 120.36,48.18 123.28,51.1 123.28,52.79 122.73,53.35 122.73,55.09 122.46,55.36 122.3,55.36 v2(122.11,55.55)
  BOTTOM w0.076: UC1.BA60 122.2,59.75 122.2,59.89 122.29,59.99 122.4,59.99 122.49,59.91 122.55,59.78 122.55,59.56 122.51,59.48 122.51,59.21 122.53,59.15 122.56,59.07 122.56,58.95 122.52,58.87 122.51,58.84 122.51,58.42 122.55,58.38 122.55,55.44 122.46,55.35 122.19,55.35 122.11,55.43 v2(122.11,55.55) ; UD2.G10 v2(119.33,42.72)
DDR_A_DQS6: length 28.8
  IN1 w0.076: 118.64,60.79 118.64,60.81 118.64,60.82 118.64,63.03 118.8,63.19 118.98,63.19 v2(119.18,63.38)
  IN1 w0.094: v2(115.45,42.72) 115.25,42.52 115.25,42.26 115.03,42.03 113.33,42.03 112.8,42.55 112.8,42.74 112.47,43.08 112.47,44.15 112.65,44.33 112.65,45.66 114.43,47.43 114.43,47.65 118.75,51.97 118.75,53.35 119.36,53.96 119.36,57.4 119.22,57.54 119.22,59.73 118.64,60.32 118.64,60.79
  BOTTOM w0.076: UC1.AR65 v2(119.18,63.38) ; UD2.P10 v2(115.45,42.72)
DDR_A_DQS7: length 29
  IN4 w0.076: v2(121.93,63.38) 121.74,63.2 121.57,63.2 121.38,63 121.38,61.24 121.67,60.94 121.67,60.93 121.68,60.92
  IN4 w0.094: 121.68,60.92 121.83,60.77 121.83,60.3 123.36,58.77 123.79,58.77 124.02,58.54 124.02,53.76 123.6,53.34 123.6,50.82 121.37,48.59 121.37,48.27 121.9,47.74 121.9,47.59 121.79,47.47 121.63,47.47 121.1,48.01 120.79,48.01 120.07,47.29 120.07,45.43 119.87,45.22 119.87,44.67 120.45,44.09 120.45,43.59 120.69,43.35 121.17,43.35 121.26,43.26 121.26,42.47 121.6,42.13 121.78,42.13 121.98,41.92 v2(121.98,41.92)
  BOTTOM w0.076: UC1.AR60 v2(121.93,63.38) ; UD2.D10 v2(121.98,41.92)
DDR_A_DQS#0: length 34.8
  IN4 w0.094: v2(101.83,42.71) 101.59,42.96 101.59,43.48 102.35,44.24 102.35,46.39 102.65,46.68 105.29,46.68 106.19,47.58 106.19,49.51 112.42,55.74 112.42,58.82 112.52,58.91 112.52,60.46 112.45,60.53 112.45,63.14 112.16,63.43 v2(112.16,63.78)
  BOTTOM w0.076: v2(112.16,63.78) 112.02,63.64 111.91,63.64 111.76,63.79 111.76,63.94 112.08,64.25 112.35,64.25 113.2,65.11 115.26,65.11 115.28,65.09 115.64,65.09 115.78,65.14 115.88,65.14 116,65.09 116.28,65.09 116.41,65.15 116.53,65.15 116.81,65.02 116.85,64.91 116.8,64.81 116.68,64.77 116.57,64.77 UC1.AM70 ; UD1.L11 v2(101.83,42.71)
DDR_A_DQS#1: length 35.9
  IN1 w0.094: v2(99.22,42.71) 99.22,42.54 98.98,42.3 97.8,42.3 97.69,42.41 97.45,42.41 97.1,42.77 97.1,43.54 96.89,43.75 96.72,43.75 96.61,43.85 96.61,44.15 98.49,46.03 99.08,46.03 100.42,47.38 102.99,47.38 106.98,51.37 107.99,51.37 112.32,55.7 112.32,58.87 112.51,59.06 112.51,60.03 112.61,60.13 112.77,60.13 v2(112.92,59.97)
  BOTTOM w0.076: UC1.AT69 116.95,62.5 116.9,62.45 116.9,62.24 116.81,62.16 116.62,62.07 116.34,62.07 116.26,62.1 116.05,62.1 115.94,62.05 115.72,62.05 115.61,62.1 115.61,62.11 114.85,62.11 113.71,60.96 113.71,60.71 113.33,60.33 113.07,60.33 112.92,60.18 v2(112.92,59.97) ; UD1.P11 v2(99.22,42.71)
DDR_A_DQS#2: length 33.6
  IN4 w0.076: v2(119.09,66.49) 119.16,66.49 119.34,66.31 119.34,66.23 119.24,66.13 118.23,66.13 118.22,66.14 118.2,66.14
  IN4 w0.094: 118.2,66.14 117.9,66.14 116.2,64.43 116.2,62.4 116.59,62 116.59,58.58 116.05,58.04 116.05,54.37 113.97,52.29 113.97,51.29 112.31,49.63 111.44,49.63 108.97,47.15 108.97,43.41 107.86,42.3 106.52,42.3 106.38,42.44 v2(106.38,42.71)
  BOTTOM w0.076: UD1.D11 v2(106.38,42.71) ; UC1.AH66 v2(119.09,66.49)
DDR_A_DQS#3: length 42.5
  IN1 w0.094: v2(104.46,43.51) 104.46,43.34 104.56,43.24 104.75,43.24 104.96,43.45 104.96,43.6 105.63,44.27 105.63,45.39 106.31,46.07 106.7,46.07 106.98,45.79 107.22,45.79 107.88,46.45 108.32,46.45 108.44,46.57 108.44,47.01 109.94,48.51 110.38,48.51 110.82,48.95 110.82,49.39 111.06,49.63 111.42,49.63 111.7,49.35 111.89,49.35 112,49.46 112,50.11 112.29,50.4 112.94,50.4 113.12,50.58 113.12,50.83 112.76,51.19 112.76,51.6 113.04,51.89 113.45,51.89 113.82,51.52 114.07,51.52 114.24,51.7 114.24,51.95 113.86,52.33 113.86,52.73 114.15,53.02 114.56,53.02 114.97,52.61 115.16,52.61 115.41,52.87 115.41,53.05 114.97,53.49 114.97,53.82 115.41,54.26 115.41,66.63 115,67.05 113.54,67.05 113.38,66.89 113.38,66.67 113.52,66.53 v2(113.7,66.53)
  BOTTOM w0.076: UC1.AG69 116.97,67.57 116.86,67.57 116.78,67.49 116.78,67.39 116.63,67.24 116.47,67.24 116.34,67.11 116.07,67.11 115.94,67.06 115.71,67.06 115.59,67.1 113.62,67.1 113.34,66.82 113.34,66.61 113.42,66.53 v2(113.7,66.53) ; UD1.G11 v2(104.46,43.51)
DDR_A_DQS#4: length 29.1
  IN4 w0.094: v2(117.41,43.52) 117.41,43.52 117.11,43.22 116.9,43.22 116.63,42.95 116.63,42.63 116.23,42.24 113.39,42.24 113.08,42.55 113.08,45.78 114.08,46.78 115.5,46.78 117.31,48.6 117.31,50.79 119.82,53.3 120.15,53.3 120.59,53.74 120.59,55.35 120.39,55.56 120.22,55.56 v2(119.99,55.79)
  BOTTOM w0.076: UC1.BA64 120,59.75 120,59.92 119.92,60 119.81,60 119.7,59.9 119.63,59.74 119.63,59.6 119.69,59.46 119.69,59.21 119.66,59.12 119.66,58.94 119.68,58.9 119.68,58.46 119.55,58.32 119.55,55.71 119.73,55.53 119.91,55.53 119.99,55.61 v2(119.99,55.79) ; UD2.L11 v2(117.41,43.52)
DDR_A_DQS#5: length 23.8
  IN1 w0.094: v2(119.34,43.54) 119.34,43.27 119.47,43.14 119.62,43.14 119.91,43.43 119.91,44 119.76,44.15 118.88,44.15 118.67,44.35 118.67,44.87 119.16,45.35 119.36,45.35 120.17,46.16 120.17,46.59 120,46.76 119.81,46.76 119.52,47.05 119.52,47.46 119.81,47.75 120,47.75 120.17,47.92 120.17,48.26 123.09,51.18 123.09,52.71 122.53,53.27 122.53,55.01 122.38,55.16 122.26,55.16 122.11,55.01 v2(122.11,54.9)
  BOTTOM w0.076: v2(122.11,54.9) 122.11,55.11 122.18,55.18 122.53,55.18 122.72,55.37 122.72,58.45 122.68,58.49 122.68,58.81 122.72,58.92 122.72,59.02 122.72,59.09 122.72,59.12 122.69,59.2 122.68,59.24 122.68,59.45 122.71,59.53 122.71,59.82 122.62,60 122.49,60.13 122.38,60.25 UC1.AY60 ; UD2.G11 v2(119.34,43.54)
DDR_A_DQS#6: length 28.8
  IN1 w0.076: v2(119.18,62.75) 119.18,62.89 119.06,63.01 118.87,63.01 118.82,62.96 118.82,60.82 118.83,60.81 118.83,60.79
  IN1 w0.094: 118.83,60.79 118.83,60.4 119.41,59.81 119.41,57.62 119.55,57.48 119.55,53.88 118.94,53.27 118.94,51.89 114.62,47.57 114.62,47.35 112.84,45.58 112.84,44.26 112.66,44.07 112.66,43.16 112.99,42.82 112.99,42.63 113.41,42.22 114.95,42.22 115.06,42.34 115.06,42.61 114.97,42.71 v2(114.76,42.71)
  BOTTOM w0.076: v2(119.18,62.75) 118.65,62.75 118.57,62.83 118.57,62.96 UC1.AR66 ; UD2.P11 114.85,43.12 114.76,43.02 v2(114.76,42.71)
DDR_A_DQS#7: length 28.9
  IN4 w0.076: v2(121.93,62.75) 121.93,62.95 121.85,63.03 121.65,63.03 121.55,62.93 121.55,61.31 121.79,61.07 121.8,61.07 121.82,61.05
  IN4 w0.094: 121.82,61.05 122.02,60.85 122.02,60.38 123.44,58.96 123.87,58.96 124.21,58.62 124.21,53.68 123.79,53.26 123.79,50.74 121.56,48.51 121.56,48.35 122.09,47.82 122.09,47.51 121.87,47.28 121.55,47.28 121.02,47.82 120.87,47.82 120.26,47.21 120.26,45.35 120.06,45.14 120.06,44.75 120.64,44.17 120.64,43.67 120.77,43.54 121.25,43.54 121.45,43.34 121.45,42.54 121.68,42.32 121.84,42.32 121.95,42.43 v2(121.95,42.71)
  BOTTOM w0.076: v2(121.95,42.71) 121.94,42.71 121.78,42.71 121.62,42.88 UD2.D11 ; UC1.AR61 v2(121.93,62.75)
DDR_A_ODT0: length 62.8
  IN1 w0.08: v2(118.04,40.34) 116.89,39.19 115.84,39.19 115.58,39.44 115.58,39.87 115.48,39.97 115.28,39.97 115.17,39.87 115.17,39.51 115.07,39.4 113.39,39.4 113.21,39.22 113.21,38.37 113.07,38.24 112.39,38.24 112.28,38.13 112.28,37.9 112.18,37.8 111.98,37.8 111.88,37.9 111.88,38.45 v2(111.67,38.66) 107.32,38.66 106.81,39.17 104.51,39.17 103.46,40.22 v2(102.48,40.22)
  IN2 w0.089: v2(111.67,38.66) 111.85,38.66 113.05,39.86 113.05,41.29 113.32,41.57 116.26,41.57 116.62,41.94 117.7,41.94 117.85,42.09 117.85,43.83 118.98,44.95 119.36,44.95 121.05,46.64 122.18,46.64 127.51,51.97 127.51,54.29 128.86,55.64 128.86,57.16 128.76,57.26 128.76,59.33 130.57,61.14 130.57,61.75 v2(130.19,62.13)
  BOTTOM w0.076: UC1.AT45 v2(130.19,62.13) ; UD2.J8 118.37,40.67 v2(118.04,40.34) ; UD1.J8 102.48,40.4 v2(102.48,40.22)
  BOTTOM w0.127: v2(111.67,38.66) 112.18,38.15 112.18,34.38 113.57,32.99 RD23.1
DDR_B_CAA0: length 46.5
  IN4 w0.08: v2(128.43,55.82) 128.65,56.04 128.69,56.04 128.69,56.04 129.24,56.04 129.34,55.94 129.34,55.53 129.22,55.4 128.37,55.4 128.29,55.32 128.29,55.08 128.37,55 129.29,55 129.45,54.84 129.45,53.63 129.32,53.51 129.23,53.51 129.15,53.43 129.15,53.08 129.24,52.99 129.34,52.99 129.43,52.89 129.43,52.76 129.34,52.67 129.24,52.67 129.15,52.57 129.15,52.44 129.24,52.35 129.34,52.35 129.43,52.25 129.43,52.12 129.34,52.03 129.24,52.03 129.15,51.93 129.15,51.8 129.24,51.71 129.34,51.71 129.43,51.61 129.43,51.48 129.34,51.39 129.24,51.39 129.15,51.29 129.15,51.06 127.2,49.12 127.2,48.86 127.12,48.78 126.86,48.78 126.74,48.66 126.74,48.53 126.87,48.4 127.09,48.4 127.2,48.29 127.2,47.86 127.07,47.74 126.77,47.74 126.69,47.82 126.69,48.13 126.52,48.3 126.38,48.3 126.27,48.19 126.27,44.33 126.36,44.23 126.44,44.23 126.53,44.13 126.53,44.01 126.44,43.91 126.36,43.91 126.27,43.82 126.27,43.03 126.36,42.93 126.44,42.93 126.53,42.84 126.53,42.72 126.43,42.61 126.36,42.61 126.27,42.52 126.27,41.81 126.37,41.7 126.52,41.7 126.64,41.59 126.64,40.78 126.53,40.67 126.37,40.67 126.27,40.57 126.27,39.76 126.37,39.66 126.53,39.66 126.64,39.55 126.64,38.97 126.53,38.86 126.37,38.86 126.27,38.76 126.27,37.89 126.94,37.22 127.05,37.22 127.36,37.53 127.5,37.53 127.73,37.3 127.73,37.16 127.87,37.02 128.01,37.02 128.27,37.27 128.38,37.27 128.55,37.1 128.55,36.98 128.3,36.73 128.3,36.58 128.55,36.34 128.69,36.34 128.84,36.49 128.92,36.49 128.92,36.49 129.13,36.49 129.35,36.27 v2(130.13,36.27)
  BOTTOM w0.076: 130.99,36.39 131.1,36.27 132.17,36.27 UD3.R2 ; UC1.AY48 128.85,60 128.78,59.92 128.78,58.55 128.83,58.49 128.83,57.93 128.75,57.86 128.75,55.82 128.67,55.74 128.51,55.74 v2(128.43,55.82)
  BOTTOM w0.127: RD42.2 128.74,33.03 129.46,33.74 129.46,35.6 v2(130.13,36.27) 129.58,36.83 129.58,37.11 129.76,37.29 130.08,37.29 130.99,36.39
DDR_B_CAA1: length 45.8
  IN4 w0.08: v2(127.43,64.06) 127.14,64.06 127.06,63.98 127.06,63.09 127.19,62.96 127.54,62.96 127.62,62.88 127.62,62.64 127.54,62.56 127.2,62.56 127.04,62.4 127.04,61.35 128.44,59.95 129.21,59.95 130.53,58.63 130.53,57.87 131.69,56.72 131.69,51.37 128.87,48.55 128.87,39.2 130.09,37.97 131.21,37.97 131.36,38.12 131.55,38.12 131.64,38.03 131.64,37.8 131.74,37.7 131.87,37.7 131.96,37.8 131.96,38.03 132.06,38.12 132.42,38.12 132.72,37.82 132.72,37.56 132.62,37.46 132.11,37.46 131.94,37.28 131.94,36.99 132.07,36.86 132.75,36.86 132.86,36.96 v2(132.86,37.12)
  BOTTOM w0.076: v2(132.86,37.12) 132.86,36.54 133.18,36.22 UD3.P2 132.88,35.62 131.1,35.62 130.77,35.95 130.36,35.95 130.13,35.73 ; UC1.AP50 v2(127.43,64.06)
  BOTTOM w0.127: 130.13,35.73 129.96,35.56 129.96,33.49 129.63,33.15 RD43.2
DDR_B_CAA2: length 44.8
  IN4 w0.08: v2(128.41,52.11) 128.21,51.91 128.21,51.75 128.49,51.47 128.49,51.28 125.68,48.47 125.68,37.64 127.52,35.8 127.66,35.8 127.75,35.88 127.89,35.88 127.99,35.78 127.99,35.55 127.92,35.48 127.92,35.37 128.23,35.06 129.68,35.06 129.76,35.14 129.76,35.25 129.86,35.35 130.06,35.35 130.16,35.25 130.16,35.14 130.24,35.06 130.69,35.06 130.95,35.31 131.08,35.31 131.2,35.19 131.34,35.06 131.74,35.06 131.87,35.19 132.24,35.19 132.37,35.06 132.75,35.06 132.86,35.17 133.27,35.17 v2(133.29,35.15)
  BOTTOM w0.076: UC1.BA48 129.28,59.09 129.28,58.55 129.18,58.44 129.18,57.11
  BOTTOM w0.127: 129.18,57.11 129.18,57.03 129.24,56.96 129.24,52.6 129.64,52.21 131.06,52.21 131.84,51.42 131.84,50.94 131.04,50.13 130.38,50.13 v2(128.41,52.11) ; UD3.N2 133.83,35.83 133.29,35.29 v2(133.29,35.15) 133.26,35.15 131.41,33.3 RD44.2
DDR_B_CAA3: length 42.3
  IN4 w0.08: v2(130.55,35.49) 130.55,35.55 130.45,35.65 130.04,35.65 129.94,35.75 129.94,35.89 129.85,35.97 129.64,35.97 129.54,35.87 129.54,35.45 129.44,35.35 129.24,35.35 129.14,35.45 129.14,36.01 129.03,36.11 128.87,36.11 128.73,35.97 128.73,35.45 128.63,35.35 128.39,35.35 128.28,35.45 128.28,36.19 128.08,36.39 127.89,36.39 127.69,36.19 127.55,36.19 127.37,36.37 127.37,36.51 127.59,36.73 127.59,36.88 127.44,37.03 127.3,37.03 127.08,36.81 126.94,36.81 125.98,37.77 125.98,38.94 126.09,39.06 126.16,39.06 126.28,39.19 126.28,39.33 126.15,39.47 126.09,39.47 125.98,39.58 125.98,40.85 126.08,40.96 126.24,40.96 126.34,41.06 126.34,41.26 126.24,41.36 126.08,41.36 125.98,41.46 125.98,48.38 128.82,51.23 128.82,53.72 128.91,53.8 129.03,53.8 129.13,53.9 129.13,54.38 129.03,54.48 128.89,54.48 128.46,54.05 v2(128.46,54.01)
  BOTTOM w0.076: v2(130.55,35.49) 130.63,35.41 132.95,35.41 133.09,35.56 133.24,35.56 133.5,35.82 133.5,36.39 UD3.N3 ; UC1.BB48 129.01,58.68 129.01,57.88 128.92,57.79 128.92,55.51 128.82,55.41 128.41,55.41 128.34,55.33 128.34,55.05 128.41,54.97 128.82,54.97 128.92,54.87 128.92,53.83 128.81,53.72 128.54,53.72 128.46,53.79 v2(128.46,54.01)
  BOTTOM w0.127: RD45.2 130.52,35.47 v2(130.55,35.49)
DDR_B_CAA4: length 48.9
  IN4 w0.08: v2(133.53,37.92) 133.41,37.92 133.41,37.93 133.19,38.15 133.19,38.53 133.02,38.7 132.35,38.7 132.25,38.79 132.25,39.15 132.16,39.24 131.94,39.24 131.86,39.16 131.86,38.81 131.76,38.71 131.55,38.71 131.45,38.81 131.45,39.15 131.37,39.23 131.12,39.23 131.04,39.15 131.04,38.66 130.94,38.56 130.33,38.56 129.45,39.44 129.45,39.59 129.55,39.69 129.79,39.69 129.96,39.85 129.96,40.02 129.88,40.1 129.55,40.1 129.45,40.2 129.45,40.4 129.55,40.5 129.76,40.5 129.84,40.58 129.84,40.74 129.67,40.91 129.55,40.91 129.45,41.01 129.45,48.37 132.27,51.19 132.27,57.23 132.44,57.4 132.44,58.73 132.33,58.83 131.95,58.83 131.61,58.49 131.61,57.97 131.51,57.87 131.36,57.87 131.12,58.11 131.12,58.52 131.59,58.99 131.59,59.14 131.43,59.3 131.32,59.3 131.07,59.05 130.93,59.05 130.79,59.2 130.79,59.34 130.98,59.54 130.98,59.76 130.86,59.88 130.75,59.88 130.5,59.63 130.36,59.63 130.21,59.77 130.21,59.92 130.51,60.22 130.51,60.36 130.49,60.38 130.49,60.66 130.42,60.72 130.19,60.72 130.12,60.65 130.12,60.4 129.92,60.2 129.78,60.2 129.65,60.34 129.65,60.42 129.75,60.52 129.75,60.63 129.68,60.7 129.02,60.7 128.63,61.09 128.17,61.09 127.96,61.3 127.96,63.28 128.12,63.44 v2(128.32,63.44)
  BOTTOM w0.076: v2(133.53,37.92) 133.93,37.92 134.18,37.67 134.18,37.01 UD3.M3 134.18,36.41 134.18,35.81 133.84,35.47 ; v2(128.32,63.44) 128.72,63.72 UC1.AP48
  BOTTOM w0.127: RD46.2 132.3,33.33 133.84,34.86 133.84,35.47
DDR_B_CAA5: length 46.2
  IN4 w0.08: v2(126.51,64.06) 126.41,64.16 125.74,64.16 125.66,64.08 125.66,63.88 125.74,63.8 126.02,63.8 126.12,63.7 126.12,61.77 128.52,59.37 128.96,59.37 129.95,58.38 129.95,57.63 131.1,56.48 131.1,51.55 128.28,48.73 128.28,38.96 129.85,37.39 130.74,37.39 131.85,36.28 136.31,36.28 136.83,35.76 137.73,35.76 137.83,35.66 v2(137.83,35.37)
  BOTTOM w0.076: 138.04,35.58 138.04,36.38 UD3.F3 ; UC1.AP52 v2(126.51,64.06)
  BOTTOM w0.127: RD47.2 136.74,33.58 137.83,34.66 v2(137.83,35.37) 138.04,35.58
DDR_B_CAA6: length 48
  IN4 w0.08: v2(138.07,37.12) 138.1,37.16 138.1,37.96 138.21,38.06 138.53,38.06 138.63,37.96 138.63,36.83 138.44,36.64 137.19,36.64 136.64,37.19 135.81,37.19 135.19,37.81 134.29,37.81 133.11,38.99 132.8,38.99 132.27,39.52 130.74,39.52 130.33,39.93 130.33,40.69 129.74,41.28 129.74,48.28 132.56,51.1 132.56,54.5 132.69,54.62 132.69,54.94 132.56,55.06 132.56,55.38 132.69,55.51 132.69,55.79 132.56,55.92 132.56,56.28 132.7,56.42 132.7,56.69 132.56,56.82 132.56,57.11 132.73,57.27 132.73,58.9 132.5,59.13 131.98,59.13 131.25,59.86 131.25,60.68 131.04,60.89 129.07,60.89 128.69,61.27 128.69,63.97 128.61,64.05 v2(128.31,64.05)
  BOTTOM w0.076: 138.89,35.47 138.73,35.63 138.73,36.42 UD3.E3 138.62,37.12 v2(138.07,37.12) ; UC1.AN50 v2(128.31,64.05)
  BOTTOM w0.127: 138.89,35.47 138.89,34.77 137.63,33.51 RD48.2
DDR_B_CAA7: length 47.8
  IN4 w0.08: v2(139.38,37.12) 139.05,37.12 138.93,37.25 138.93,38.62 138.72,38.82 138.04,38.82 137.81,38.59 137.81,37.65 137.69,37.52 137.05,37.52 137.02,37.5 135.92,37.5 135.18,38.24 134.28,38.24 133.23,39.28 132.92,39.28 132.39,39.81 130.86,39.81 130.62,40.05 130.62,40.82 130.04,41.4 130.04,48.19 133.65,51.81 133.65,58.55 132.76,59.44 132.13,59.44 131.44,60.13 131.44,60.73 131.07,61.11 129.14,61.11 128.88,61.37 128.88,64.11 v2(128.31,64.67)
  BOTTOM w0.076: v2(128.31,64.67) 128.72,64.45 UC1.AN48 ; UD3.E2 139.38,36.27 139.38,36.84 139.38,36.84 v2(139.38,37.12)
  BOTTOM w0.127: UD3.E2 139.16,35.78 139.16,33.93 138.52,33.3 RD49.2
DDR_B_CAA8: length 45.4
  IN4 w0.08: v2(126.5,64.71) 126.89,64.32 126.89,63.31 126.87,63.28 126.87,61.27 128.48,59.66 129.08,59.66 130.24,58.5 130.24,57.75 131.39,56.6 131.39,51.46 128.58,48.64 128.58,39.08 129.97,37.68 130.86,37.68 131.97,36.57 136.43,36.57 136.95,36.05 137.86,36.05 138.68,35.73 v2(139.68,35.42)
  BOTTOM w0.076: UC1.AN53 v2(126.5,64.71)
  BOTTOM w0.127: UD3.D2 v2(139.68,35.42) 139.68,33.1 RD50.2
DDR_B_CAA9: length 45.9
  IN4 w0.08: v2(140.02,36.32) 139.45,36.32 139.43,36.34 137.07,36.34 136.52,36.9 135.6,36.9 134.98,37.52 133.36,37.52 133.13,37.74 133.13,37.82 132.54,38.42 131.21,38.42 131.06,38.27 130.21,38.27 129.16,39.32 129.16,48.46 131.98,51.28 131.98,56.84 130.83,57.99 130.83,58.75 129.45,60.12 128.98,60.12 128.87,60.23 128.87,60.57 128.57,60.87 128.01,60.87 127.94,60.8 127.83,60.8 127.64,60.99 127.64,61.1 127.79,61.25 127.79,64.59 127.71,64.67 v2(127.4,64.67)
  BOTTOM w0.076: UC1.AN52 v2(127.4,64.67)
  BOTTOM w0.127: v2(140.02,36.32) 140.02,36.22 UD3.C2 140.33,34.3 140.3,34.27 RD51.2
DDR_B_CAB0: length 52.3
  IN2 w0.089: v2(147.71,37.93) 147.71,38.27 147.86,38.42 149.62,38.42 149.78,38.58 149.78,39.64 149.62,39.8 146.81,39.8 146.55,40.05 146.55,40.87 144.88,42.54 144.88,46.01 141.07,49.82 137.3,49.82 137.2,49.92 137.2,50.12 137.3,50.22 137.73,50.22 137.84,50.32 137.84,50.47 137.73,50.58 137.3,50.58 137.2,50.68 137.2,51.09 137.1,51.19 136.95,51.19 136.84,51.09 136.84,50.84 136.74,50.73 136.55,50.73 136.44,50.63 136.44,50.48 136.55,50.38 136.74,50.38 136.84,50.27 136.84,49.92 136.74,49.82 136.47,49.82 134.93,51.36 134.93,51.5 135.24,51.81 135.24,51.96 135.14,52.06 134.99,52.06 134.68,51.75 134.53,51.75 134.25,52.04 134.25,54.24 134.15,54.34 134.15,56.68 134.04,56.78 133.78,56.78 133.67,56.89 133.67,57.03 133.78,57.14 134.04,57.14 134.15,57.24 134.15,57.39 134.04,57.49 133.78,57.49 133.67,57.6 133.67,57.74 133.78,57.85 134.04,57.85 134.15,57.95 134.15,58.6 133.83,58.93 132.73,58.93 132.49,58.69 132.49,58.01 132.03,57.55 v2(132.02,57.55)
  BOTTOM w0.076: v2(147.71,37.93) 147.71,37.13 147.75,37.1 147.75,36.29 148.05,35.99 UD4.R2 147.75,35.62 146.94,35.62 146.89,35.57 146.64,35.57 ; UC1.BA43 132.28,59.44 132.28,59.2 132.29,59.17 132.3,59.15 132.3,58.89 132.29,58.86 132.29,58.43 132.37,58.35 132.37,57.91 v2(132.02,57.55)
  BOTTOM w0.127: RD52.2 145.95,34.87 146.64,35.57
DDR_B_CAB1: length 56.5
  IN2 w0.089: v2(133.19,55.5) 133.47,55.77 133.68,55.77 133.79,55.67 133.79,54.21 133.91,54.1 133.91,51.89 136.27,49.54 137.1,49.54 137.2,49.43 137.2,48.65 137.31,48.55 137.46,48.55 137.56,48.65 137.56,49.43 137.66,49.54 137.81,49.54 137.92,49.43 137.92,48.65 138.02,48.55 138.17,48.55 138.27,48.65 138.27,49.43 138.38,49.54 138.52,49.54 138.63,49.43 138.63,48.65 138.73,48.55 138.88,48.55 138.98,48.65 138.98,49.43 139.09,49.54 139.23,49.54 139.34,49.43 139.34,48.65 139.44,48.55 139.59,48.55 139.69,48.65 139.69,49.43 139.8,49.54 139.95,49.54 140.05,49.43 140.05,48.65 140.15,48.55 140.3,48.55 140.4,48.65 140.4,49.43 140.51,49.54 140.96,49.54 144.53,45.96 144.53,42.4 145.01,41.93 145.01,41.71 144.68,41.39 144.68,41.17 144.89,40.95 145.11,40.95 145.26,41.1 145.54,41.1 145.69,40.96 145.69,40.21 146.06,39.83 146.06,38.82 146.21,38.67 146.52,38.67 146.67,38.82 146.67,39.29 146.83,39.45 149.21,39.45 149.37,39.3 149.37,38.92 149.21,38.77 147.53,38.77 147,38.23 147,37.65 147.15,37.5 148.23,37.5 148.38,37.65 v2(148.38,37.89)
  BOTTOM w0.076: 147.01,34.69 147.05,34.72 147.05,35.19 147.27,35.41 147.97,35.41 148.47,35.91 UD4.P2 148.7,35.96 148.39,36.27 148.39,37.88 v2(148.38,37.89) ; 131.78,56.91 131.66,57.03 131.66,58.33 131.8,58.48 131.8,58.87 131.79,58.89 131.79,59.15 131.8,59.18 131.8,59.55 131.79,59.58 131.79,59.97 UC1.AY43
  BOTTOM w0.127: 147.01,34.69 146.84,34.52 RD53.2 ; v2(133.19,55.5) 131.78,56.91
DDR_B_CAB2: length 55.1
  IN2 w0.089: v2(149.67,37.94) 149.67,37.88 148.95,37.16 146.41,37.16 146.29,37.28 146.29,37.49 146.63,37.83 146.63,38 146.37,38.26 146.19,38.26 145.85,37.92 145.64,37.92 144.44,39.12 144.44,39.43 144.53,39.52 145.25,39.52 145.36,39.62 145.36,39.77 145.25,39.87 144.3,39.87 144.19,39.98 144.19,40.12 144.3,40.23 145.25,40.23 145.36,40.33 145.36,40.48 145.25,40.58 144.3,40.58 144.19,40.69 144.19,45.91 143.87,46.23 143.72,46.23 143.12,45.63 142.97,45.63 142.86,45.73 142.86,45.88 143.47,46.48 143.47,46.63 143.36,46.73 143.22,46.73 142.61,46.13 142.47,46.13 142.36,46.23 142.36,46.38 142.97,46.99 142.97,47.13 142.86,47.24 142.71,47.24 142.11,46.63 141.96,46.63 141.86,46.74 141.86,46.88 142.46,47.49 142.46,47.64 142.36,47.74 142.21,47.74 141.61,47.14 141.46,47.14 141.36,47.24 141.36,47.39 141.96,47.99 141.96,48.14 141.83,48.27 141.19,48.27 141.09,48.37 141.09,48.93 140.98,49.03 140.83,49.03 140.73,48.93 140.73,48.37 140.63,48.27 137.05,48.27 133.57,51.75 133.57,53.95 v2(133.19,54.33)
  BOTTOM w0.076: UC1.AY44 131.48,59.67 131.64,59.51 131.64,59.22 131.63,59.18 131.63,58.86 131.63,58.85 131.64,58.84 131.64,58.55 131.5,58.4 131.5,55.95 v1(131.7,55.75) ; UD4.N2 149.35,36.23 149.69,36.58 149.69,37.91 v2(149.67,37.94)
  BOTTOM w0.127: UD4.N2 149.35,35.84 149.12,35.61 149.12,35.2 148.53,34.61 148.53,32.92 RD54.2 ; v2(133.19,54.33) 133.11,54.33 v1(131.7,55.75)
DDR_B_CAB3: length 53.7
  IN2 w0.089: v2(130.29,54.34) 130.29,54.34 130.72,53.91 130.72,49.76 128.55,47.59 128.55,41.59 128.92,41.23 128.92,41.01 128.77,40.87 128.77,40.65 128.98,40.44 129.2,40.44 129.35,40.58 129.56,40.58 130.7,39.44 130.88,39.44 131.18,39.14 131.18,38.92 130.95,38.69 130.95,38.47 131.16,38.26 131.38,38.26 131.61,38.49 131.62,38.49 132.17,38.49 132.33,38.34 132.33,38.12 131.94,37.73 131.94,37.52 132.09,37.37 132.49,37.37 132.71,37.58 132.85,37.58 133,37.74 133,38.34 133.15,38.49 133.62,38.49 134.01,38.1 134.01,37.55 134.16,37.39 134.38,37.39 134.79,37.8 135.18,37.8 135.33,37.65 135.33,37.02 135.48,36.87 136.78,36.87 137.08,36.56 139.15,36.56 140.45,35.26 140.98,35.26 141.41,35.69 141.78,35.69 142.23,35.24 143.65,35.24 144.06,35.65 146.41,35.65 146.74,35.33 147.38,35.33 147.7,35.65 148.32,35.65 v2(148.56,35.42)
  BOTTOM w0.076: UD4.N3 149,36.36 149,35.78 148.63,35.42 v2(148.56,35.42) ; v2(130.29,54.34) 130.95,55 130.95,59.34 131.19,59.57 131.19,60.04 131.21,60.11 131.32,60.32 131.48,60.49 UC1.AW44
  BOTTOM w0.127: v2(148.56,35.42) 147.73,34.59 RD55.2
DDR_B_CAB4: length 54.5
  IN2 w0.089: v2(133.13,53.74) 132.7,53.31 132.7,50.22 133.94,48.98 134.08,48.98 134.27,49.17 134.42,49.17 134.52,49.07 134.52,48.92 134.33,48.73 134.33,48.59 134.44,48.48 134.58,48.48 134.77,48.67 134.92,48.67 135.03,48.57 135.03,48.42 134.84,48.23 134.84,48.08 135.69,47.23 136.64,47.23 136.75,47.34 136.75,47.61 136.85,47.71 137,47.71 137.1,47.61 137.1,47.34 137.21,47.23 137.36,47.23 137.46,47.34 137.46,47.61 137.56,47.71 137.71,47.71 137.82,47.61 137.82,47.34 137.92,47.23 138.07,47.23 138.17,47.34 138.17,47.61 138.28,47.71 138.42,47.71 138.53,47.61 138.53,47.34 138.63,47.23 138.78,47.23 138.88,47.34 138.88,47.61 138.99,47.71 139.13,47.71 139.24,47.61 139.24,47.34 139.34,47.23 139.49,47.23 139.59,47.34 139.59,47.61 139.7,47.71 139.84,47.71 139.95,47.61 139.95,47.34 140.05,47.23 140.48,47.23 143.55,44.17 143.45,44.06 143.17,44.06 143.07,43.96 143.07,43.81 143.17,43.71 143.45,43.71 143.55,43.6 143.55,43.45 143.45,43.35 143.17,43.35 143.07,43.25 143.07,43.1 143.17,42.99 143.45,42.99 143.55,42.89 143.55,42.74 143.45,42.64 143.17,42.64 143.07,42.53 143.07,42.39 143.17,42.28 143.45,42.28 143.55,42.18 143.55,42.03 143.45,41.93 143.17,41.93 143.07,41.82 143.07,41.68 143.17,41.57 143.45,41.57 143.55,41.47 143.55,41.32 143.45,41.22 143.17,41.22 143.07,41.11 143.07,40.96 143.17,40.86 143.45,40.86 143.55,40.76 143.55,40.61 143.45,40.51 143.17,40.51 143.07,40.4 143.07,40.25 143.17,40.15 143.45,40.15 143.55,40.05 143.55,39.9 143.45,39.79 143.17,39.79 143.07,39.69 143.07,39.54 143.17,39.44 143.45,39.44 143.55,39.33 143.55,39.13 143.75,38.93 143.75,38.79 143.69,38.73 143.69,38.58 143.8,38.48 143.94,38.48 144,38.53 144.15,38.53 144.25,38.43 144.25,38.28 144.19,38.22 144.19,38.08 144.3,37.97 144.45,37.97 144.5,38.03 144.65,38.03 145.24,37.44 145.24,37.29 144.5,36.55 144.5,36.4 144.6,36.3 144.75,36.3 145.49,37.04 145.64,37.04 145.74,36.94 145.74,36.79 145.52,36.57 145.52,36.42 145.63,36.32 145.77,36.32 146,36.54 146.14,36.54 146.34,36.34 149.13,36.34 149.45,36.65 149.86,36.65 v2(150.3,37.1)
  BOTTOM w0.076: 131.55,55.32 131.28,55.59 131.28,58.59 UC1.BB44 ; v2(150.3,37.1) UD4.M3 150,36.52 149.65,36.17 149.65,35.79 149.38,35.53 149.38,35.04
  BOTTOM w0.127: v2(133.13,53.74) 131.55,55.32 ; RD56.2 149.51,34.91 149.38,35.04
DDR_B_CAB5: length 55.3
  IN2 w0.089: v2(129.54,57.62) 129.66,57.51 129.66,55.14 129.52,55 129.52,49.77 127.52,47.78 127.52,40.36 132.05,35.84 136.12,35.84 137.74,34.22 144.07,34.22 144.22,34.36 145.06,34.36 145.33,34.63 145.68,34.63 146.01,34.3 153.24,34.3 154.12,35.17 v2(154.12,35.19)
  BOTTOM w0.076: UC1.AY47 129.78,60.2 arc(129.9,60.01) 129.95,59.79 129.95,59.55 arc(129.95,59.54) 129.94,59.54 129.94,59.53 arc(129.94,59.52) 129.94,59.5 129.94,59.19 arc(129.94,59.18) 129.94,59.18 129.95,59.15 129.95,58.91 129.92,58.78 129.92,58 v2(129.54,57.62) ; v2(154.12,35.19) 154.12,35.28 154.21,35.37 154.21,36.41 UD4.F3
  BOTTOM w0.127: v2(154.12,35.19) 154.12,35.19 154.21,35.1 154.21,33.55 154.84,32.92 RD57.2
DDR_B_CAB6: length 55.8
  IN2 w0.089: v2(133.13,52.55) 133.13,51.63 133.41,51.35 133.41,51.2 132.99,50.78 132.99,50.63 133.09,50.53 133.24,50.53 133.66,50.95 133.81,50.95 133.91,50.85 133.91,50.7 133.49,50.28 133.49,50.13 133.59,50.03 133.74,50.03 134.16,50.45 134.31,50.45 134.41,50.35 134.41,50.2 133.99,49.77 133.99,49.63 134.09,49.52 134.24,49.52 134.67,49.95 134.81,49.95 135.79,48.97 135.79,48.83 135.3,48.34 135.3,48.19 135.4,48.09 135.55,48.09 136.04,48.57 136.19,48.57 136.29,48.47 136.29,48.32 135.8,47.84 135.8,47.69 135.91,47.58 136.05,47.58 136.46,47.99 140.12,47.99 140.43,47.69 140.57,47.69 140.88,48 141.03,48 141.14,47.89 141.14,47.74 140.83,47.43 140.83,47.29 143.06,45.05 143.21,45.05 143.62,45.46 143.77,45.46 143.87,45.36 143.87,45.21 143.46,44.8 143.46,44.65 143.83,44.28 143.83,39.25 146.27,36.81 149.12,36.81 149.31,37 149.58,37 149.73,37.15 149.73,37.34 149.94,37.55 150.69,37.55 150.84,37.4 150.84,36.85 151.04,36.66 154.73,36.66 154.88,36.81 v2(154.88,37.13)
  BOTTOM w0.076: 155.28,35.17 154.88,35.57 154.88,36.38 UD4.E3 v2(154.88,37.13) ; UC1.BA44 131.12,59.08 131.12,54.79
  BOTTOM w0.127: v2(133.13,52.55) 133.07,52.55 131.12,54.5 131.12,54.79 ; 155.28,35.17 155.36,35.08 155.36,34.38 156.62,33.12 RD58.2
DDR_B_CAB7: length 55.6
  IN2 w0.089: v2(154.71,35.23) 154.32,35.62 151.11,35.62 150.86,35.37 150.86,35.2 150.3,34.64 146.15,34.64 145.83,34.97 145.18,34.97 144.92,34.7 144.08,34.7 143.93,34.56 139.44,34.56 138.9,35.1 138.9,35.52 138.55,35.87 136.8,35.87 136.49,36.18 132.19,36.18 127.87,40.5 127.87,47.72 129.86,49.72 129.86,54.57 v2(130.24,54.95)
  BOTTOM w0.076: UC1.AW46 130.26,60.46 130.45,60.27 130.55,60.07 130.55,59.58 130.78,59.35 130.78,55.49 v2(130.24,54.95)
  BOTTOM w0.127: UD4.E2 154.55,35.39 v2(154.71,35.23) 154.71,34.17 155.73,33.14 RD59.2
DDR_B_CAB8: length 55.5
  IN2 w0.089: v2(155.52,35.54) 155.09,35.96 149.73,35.96 148.75,34.98 146.3,34.98 145.97,35.31 145.04,35.31 144.78,35.05 143.93,35.05 143.79,34.9 139.58,34.9 139.25,35.24 139.25,35.66 138.69,36.22 136.94,36.22 136.63,36.52 132.33,36.52 128.21,40.65 128.21,47.64 130.29,49.72 v2(130.29,53.07)
  BOTTOM w0.076: UC1.AY46 130.26,59.81 arc(130.24,59.75) 130.21,59.69 arc(130.16,59.63) 130.13,59.57 130.11,59.52 arc(130.11,59.49) 130.1,59.45 130.1,59.23 arc(130.1,59.22) 130.11,59.21 130.11,59.19 arc(130.12,59.12) 130.13,59.05 130.13,59.05 130.12,58.93 130.1,58.79 130.1,57.18
  BOTTOM w0.127: RD60.2 155.71,34.63 155.71,35.34 v2(155.52,35.54) 155.2,35.85 UD4.D2 ; 130.1,57.18 130.1,57.05 129.73,56.67 129.73,53.63 v2(130.29,53.07)
DDR_B_CAB9: length 55.2
  IN2 w0.089: v2(130.13,56.3) 130.14,56.3 131.06,55.37 131.06,49.7 128.9,47.53 128.9,41.74 130.85,39.79 131.02,39.79 131.97,38.83 133.76,38.83 134.44,38.15 135.64,38.15 135.92,38.43 140.31,38.43 140.55,38.19 140.55,37.03 141.55,36.03 141.92,36.03 142.2,35.75 142.53,35.75 142.64,35.86 142.64,36.23 142.8,36.38 143.1,36.38 143.25,36.23 143.25,35.85 143.41,35.7 143.62,35.7 143.92,36 149.28,36 149.59,36.31 v2(155.52,36.31)
  BOTTOM w0.076: v2(130.13,56.3) 130.61,56.78 130.61,58.92 130.36,59.17 UC1.BA46
  BOTTOM w0.127: v2(155.52,36.31) 155.52,36.24 UD4.C2 156.15,35.61 156.15,34.97 156.42,34.7 156.53,34.7 RD61.2
DDR_B_CKE0: length 61.5
  IN4 w0.08: v2(124.65,63.97) 125.21,63.41 125.21,61.92 126.9,60.24 126.9,60.07 127.1,59.87 127.27,59.87 127.47,59.66 127.47,59.5 127.68,59.29 127.84,59.29 128.05,59.09 128.05,58.92 128.25,58.72 128.42,58.72 128.78,58.36 128.78,56.5 128.85,56.43 129.22,56.43 129.32,56.53 129.32,56.74 129.42,56.84 129.61,56.84 129.73,56.72 129.73,55.21 129.83,55.1 129.83,51.21 127.59,48.96 127.59,47.43 127.49,47.34 126.99,47.34 126.89,47.24 126.89,47.11 126.99,47.02 127.49,47.02 127.59,46.92 127.59,46.79 127.49,46.7 126.76,46.7 126.66,46.6 126.66,46.47 126.76,46.38 127.49,46.38 127.59,46.28 127.59,46.15 127.49,46.06 126.76,46.06 126.66,45.96 126.66,45.83 126.76,45.74 127.49,45.74 127.59,45.64 127.59,45.51 127.49,45.42 126.76,45.42 126.66,45.32 126.66,45.19 126.76,45.1 127.49,45.1 127.59,45 127.59,44.87 127.49,44.78 126.76,44.78 126.66,44.68 126.66,44.55 126.76,44.46 127.49,44.46 127.59,44.36 127.59,43.74 127.48,43.64 126.78,43.64 126.68,43.53 126.68,43.33 126.78,43.23 127.48,43.23 127.59,43.13 127.59,42.52 127.48,42.42 126.78,42.42 126.68,42.32 126.68,42.11 126.91,41.88 127.15,41.88 127.27,42.01 127.47,42.01 127.59,41.89 127.59,41.49 127.44,41.35 127.44,41.07 127.59,40.92 127.59,40.57 127.39,40.37 126.78,40.37 126.68,40.27 126.68,40.08 126.78,39.98 127.38,39.98 127.48,39.88 127.48,38.83 127.19,38.54 126.78,38.54 126.68,38.44 126.68,38.09 126.93,37.83 127.08,37.83 127.6,38.35 127.85,38.35 127.93,38.27 127.93,38.14 127.75,37.96 127.75,37.83 127.85,37.74 127.98,37.74 128.15,37.91 128.28,37.91 128.94,37.26 128.94,37.02 129.08,36.88 129.32,36.88 129.52,36.68 130.46,36.68 130.66,36.49 130.66,36.34 130.57,36.25 130.57,36.11 130.71,35.97 130.86,35.97 130.94,36.05 131.09,36.05 131.22,35.92 131.22,35.72 131.36,35.58 133.54,35.58 133.7,35.42 133.95,35.42 134.1,35.58 135.75,35.58 v2(135.99,35.34)
  BOTTOM w0.076: v2(124.65,63.97) 124.65,63.97 UC1.AN56 ; UD3.K3 135.78,36.68 135.74,36.64 135.74,36.3 135.48,36.04 135.48,35.77 135.91,35.34 v2(135.99,35.34)
  BOTTOM w0.127: v2(135.99,35.34) 135.99,34.97 134.08,33.05 RD65.1
DDR_B_CKE1: length 61.4
  IN4 w0.08: v2(124.67,63.32) 124.96,63.32 125.04,63.24 125.04,60.94 125.99,59.99 126.39,59.99 127.9,58.48 127.9,54.13 127.82,54.05 127.82,53.75 127.98,53.59 127.98,53.34 127.82,53.19 127.82,52.93 127.98,52.78 127.98,52.53 127.82,52.37 127.82,51.16 125.27,48.6 125.27,48.16 125.17,48.07 125.09,48.07 125.01,47.99 125.01,47.83 125.09,47.75 125.22,47.75 125.3,47.67 125.3,47.5 125.22,47.43 124.95,47.43 124.86,47.33 124.86,47.2 124.95,47.11 125.24,47.11 125.3,47.05 125.3,46.85 125.24,46.79 124.95,46.79 124.86,46.69 124.86,46.56 124.95,46.47 125.25,46.47 125.3,46.41 125.3,46.2 125.25,46.15 124.95,46.15 124.86,46.05 124.86,45.92 124.95,45.83 125.22,45.83 125.3,45.75 125.3,45.58 125.22,45.51 124.95,45.51 124.86,45.41 124.86,45.28 124.95,45.19 125.21,45.19 125.29,45.11 125.29,44.95 125.21,44.87 124.95,44.87 124.86,44.77 124.86,44.64 124.95,44.55 125.22,44.55 125.3,44.47 125.3,44.3 125.22,44.23 124.95,44.23 124.86,44.13 124.86,44 124.95,43.91 125.22,43.91 125.3,43.83 125.3,43.66 125.22,43.59 124.95,43.59 124.86,43.49 124.86,43.36 124.95,43.27 125.22,43.27 125.3,43.19 125.3,43.02 125.22,42.95 124.95,42.95 124.86,42.85 124.86,42.72 124.95,42.63 125.22,42.63 125.3,42.55 125.3,42.38 125.22,42.31 124.95,42.31 124.86,42.21 124.86,42.08 124.95,41.99 125.2,41.99 125.29,41.89 125.29,41.76 125.2,41.67 124.95,41.67 124.86,41.57 124.86,41.44 124.95,41.35 125.22,41.35 125.3,41.27 125.3,41.1 125.22,41.03 124.93,41.03 124.86,40.96 124.86,40.78 124.93,40.71 125.24,40.71 125.29,40.65 125.29,40.44 125.24,40.39 124.93,40.39 124.86,40.32 124.86,40.14 124.93,40.07 125.25,40.07 125.3,40.01 125.3,39.8 125.25,39.75 124.95,39.75 124.86,39.65 124.86,39.52 124.95,39.43 125.22,39.43 125.3,39.35 125.3,39.18 125.22,39.11 124.93,39.11 124.86,39.04 124.86,38.86 124.93,38.79 125.22,38.79 125.3,38.71 125.3,38.54 125.22,38.47 124.95,38.47 124.86,38.37 124.86,38.24 124.95,38.15 125.17,38.15 125.27,38.05 125.27,37.51 125.8,36.98 125.8,36.86 125.66,36.72 125.66,36.61 125.77,36.5 125.89,36.5 126.02,36.63 126.15,36.63 126.28,36.5 126.28,36.29 125.91,35.92 125.91,35.81 126.09,35.64 126.2,35.64 126.62,36.05 126.72,36.05 126.91,35.87 126.91,35.77 126.45,35.31 126.45,35.17 126.6,35.03 126.74,35.03 127.18,35.47 127.31,35.47 127.36,35.42 127.37,35.42 127.47,35.32 127.47,35.18 127.19,34.9 127.19,34.79 127.32,34.66 127.53,34.66 127.73,34.87 127.88,34.87 128.09,34.65 134.85,34.65 134.95,34.75 134.95,35.05 v2(134.84,35.16)
  BOTTOM w0.076: v2(134.84,35.16) 134.84,35.78 134.83,35.79 134.83,36.04 135.08,36.29 135.13,36.29 135.47,36.63 135.47,37.2 UD3.K4 ; UC1.AP55 124.85,63.5 v2(124.67,63.32)
  BOTTOM w0.127: RD66.1 133.19,33.31 134.84,34.96 v2(134.84,35.16)
DDR_B_CKE2: length 65.3
  IN4 w0.08: v2(125.58,64.77) 125.13,64.48 124.7,64.44 124.57,64.4 124.26,64.09 124.26,61.29 125.68,59.87 127.42,58.55 127.61,58.36 127.61,54.25 127.53,54.17 127.53,51.25 124.59,48.3 124.59,36.6 126.82,34.36 145.1,34.36 145.34,34.6 151.29,34.6 v2(151.88,35.19)
  BOTTOM w0.076: UD4.K3 151.3,36.49 151.65,36.13 151.65,35.76 151.88,35.52 v2(151.88,35.19) ; UC1.AN55 v2(125.58,64.77)
  BOTTOM w0.127: RD81.1 152.16,33.77 151.81,34.12 151.81,35.11 v2(151.88,35.19)
DDR_B_CKE3: length 63.9
  IN4 w0.08: v2(125.58,63.38) 125.95,63.02 125.95,61.6 129.07,58.48 129.07,57.38 129.23,57.22 129.79,57.22 130.7,56.31 130.7,51.69 127.88,48.87 127.88,38.73 129.62,36.98 130.57,36.98 131.69,35.87 136.14,35.87 136.44,35.57 136.44,34.77 136.56,34.65 137.09,34.65 137.2,34.75 137.2,34.82 137.3,34.93 137.5,34.93 137.6,34.82 137.6,34.75 137.7,34.65 137.91,34.65 138.01,34.75 138.01,34.87 138.11,34.97 138.31,34.97 138.41,34.87 138.41,34.75 138.52,34.65 140.24,34.65 140.34,34.75 140.34,35.12 140.44,35.23 140.64,35.23 140.74,35.12 140.74,34.75 140.85,34.65 141.05,34.65 141.15,34.75 141.15,35.12 141.25,35.23 141.46,35.23 141.56,35.12 141.56,34.75 141.66,34.65 141.86,34.65 141.96,34.75 141.96,35.12 142.07,35.23 142.27,35.23 142.37,35.12 142.37,34.75 142.47,34.65 142.68,34.65 142.78,34.75 142.78,35.12 142.88,35.23 143.08,35.23 143.18,35.12 143.18,34.75 143.28,34.65 144.89,34.65 145.18,34.94 151.05,34.94 v2(151.29,35.19)
  BOTTOM w0.076: v2(151.29,35.19) 151.29,35.44 151,35.73 151,36.84 151.18,37.02 151.18,37.39 UD4.K4 ; UC1.AP53 v2(125.58,63.38)
  BOTTOM w0.127: v2(151.29,35.19) 151.29,32.84 RD82.1
