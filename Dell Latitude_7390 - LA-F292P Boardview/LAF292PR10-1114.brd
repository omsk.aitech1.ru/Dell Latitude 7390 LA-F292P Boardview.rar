# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_ROM_WP#: length 13.3
  IN4 w0.051: v4(35.86,63.69) 35.86,64.27 37,65.41 37,69.26 v4(36.61,69.66)
  GND5 w0.086: v5(35.86,64.17) v4(35.86,63.69) ; v4(36.61,69.66) 36.63,69.66 36.9,69.39 v5(37.19,69.39)
  BOTTOM w0.086: v5(37.19,69.39) 37.34,69.24 37.71,69.24 v1(39.04,70.56) 39.35,70.87 RT4.1 40.05,70.93 UT2.3 ; UT1.V1 35.79,64.1 v5(35.86,64.17)
TBT_RSENSE: length 1.2
  TOP w0.086: v2(32.04,61.52) 31.82,61.75 RT39.1
  BOTTOM w0.117: v2(32.04,61.52) 32.04,61.52 UT1.J6
TBT_SRC_CFG1: length 5.9
  BOTTOM w0.086: v1(41.83,65.1) 41.43,65.49 RT338.1 40.81,65.49 RT30.1 37.64,64.6 37.17,64.13 UT1.AA1
TBT_TMU_CLK_OUT: length 4.4
  BOTTOM w0.076: 36.15,64.26 36.15,64.08 36.01,63.93 36.01,63.43 UT1.V2
  BOTTOM w0.086: RT28.1 37.06,66.65 36.44,66.02 36.44,65.35 v1(36.38,65.29) 36.15,65.07 36.15,64.26
TBTA_AUXN: length 26.6
  IN4 w0.062: v4(25.39,70.97) 25.13,70.71 24.74,70.71 24.54,70.5 24.54,68.08 25.95,66.67 28.53,66.67 29.29,65.9 29.66,65.9 30.13,65.43 30.71,65.43 31.29,64.85 31.29,64.21 32.17,63.33 32.17,61.96 32.57,61.56 34.72,61.56 35.24,61.04 35.24,60.49 35.81,59.93 36.08,59.66 36.44,59.66 37.01,59.09 37.01,56.85 36.81,56.66 36.3,56.66 v2(35.96,56.32)
  GND5 w0.088: v4(25.39,70.97) 25.37,70.95 v5(23.92,70.95)
  BOTTOM w0.088: v2(35.96,56.32) 35.96,56.34 UT1.W16
TBTA_AUXN_C: length 7.8
  BOTTOM w0.076: 29.88,70.34 29.89,70.35 29.89,70.35 30.12,70.58 30.12,70.73 29.98,70.88 29.98,71.15 30.08,71.31 UT5.J2
  BOTTOM w0.088: CT81.2 24.73,70.72 25.05,70.72 RT95.1 25.4,70.81 25.5,70.72 26.89,70.72 v7(27.18,70.43) 27.64,69.96 29.5,69.96 29.88,70.34
TBTA_AUXP: length 26.7
  IN4 w0.062: v4(25.39,70.39) 25.21,70.56 24.8,70.56 24.68,70.44 24.68,68.14 26.01,66.81 28.59,66.81 29.35,66.05 29.72,66.05 30.19,65.58 30.77,65.58 31.44,64.91 31.44,64.27 32.32,63.39 32.32,62.02 32.63,61.71 34.78,61.71 35.39,61.1 35.39,60.55 35.95,59.99 36.14,59.8 36.5,59.8 37.15,59.15 37.15,56.79 36.92,56.57 36.92,56.47 37.1,56.3 37.1,56.14 36.98,56.02 36.89,56.02 v2(36.59,56.32)
  GND5 w0.088: v4(25.39,70.39) 25.21,70.39 25.14,70.32 v5(23.92,70.32)
  BOTTOM w0.088: v2(36.59,56.32) UT1.Y16
TBTA_AUXP_C: length 8.1
  BOTTOM w0.076: 30,70.22 30.01,70.23 30.01,70.24 30.29,70.51 30.29,70.69 30.48,70.88 30.48,71.15 30.41,71.22 30.3,71.22 30.22,71.15 UT5.J1
  BOTTOM w0.088: 30,70.22 29.57,69.79 27.57,69.79 27.29,70.06 27.24,70.06 26.83,70.47 26.83,70.5 26.78,70.54 25.49,70.54 25.4,70.46 RT96.1 25.05,70.55 24.73,70.55 CT80.2
TBTA_BOT_N: length 23.3
  IN3 w0.083: v2(20.26,83.54) 21.03,83.54 21.49,83.08 21.49,82.52 24.88,79.13 24.88,75.25 24.51,74.88 23.8,74.88 v2(23.69,74.77)
  BOTTOM w0.076: UT5.L7 29.31,74.03 29.39,73.95 29.39,73.83 29.33,73.77 29.1,73.77 28.84,74.03 28.32,74.03 28.31,74.02 28.29,74.02
  BOTTOM w0.088: RT122.2 16.34,83.17 16.61,83.17 16.86,83.42 18.99,83.42 19.1,83.32 20.04,83.32 v2(20.26,83.54) ; v2(23.69,74.77) 23.89,74.97 25.03,74.97 25.74,74.26 27.57,74.26 27.81,74.02 28.29,74.02
TBTA_BOT_N_R: length 9.6
  TOP w0.088: v2(6.71,83.01) 6.64,83.08 JUSBC1.B7
  BOTTOM w0.088: v2(6.71,83.01) 6.89,82.83 11.45,82.83 11.83,83.21 12.45,83.21 12.89,83.64 DT42.8 DT42.2 14.96,83.64 RT122.1
TBTA_BOT_P: length 23.3
  IN3 w0.083: v2(20.26,82.95) 20.55,82.95 20.64,83.03 20.64,83.27 20.71,83.35 20.95,83.35 21.3,83 21.3,82.44 24.7,79.05 24.7,75.33 24.44,75.07 24.14,75.07 24.09,75.12 24.09,75.36 23.98,75.47 23.8,75.47 v2(23.69,75.36)
  BOTTOM w0.076: UT5.K7 29.5,74.17 29.35,74.27 29.34,74.27 29.33,74.27 29.11,74.27 29.11,74.27 29.09,74.27 29.01,74.19 28.32,74.19 28.31,74.19 28.29,74.19
  BOTTOM w0.088: v2(23.69,75.36) 23.91,75.14 25.1,75.14 25.81,74.43 27.64,74.43 27.88,74.19 28.29,74.19 ; RT123.2 16.36,83 16.68,83 16.93,83.25 18.92,83.25 19.03,83.15 20.07,83.15 v2(20.26,82.95)
TBTA_BOT_P_R: length 9.6
  TOP w0.088: JUSBC1.B6 6.56,82.57 v2(6.7,82.43)
  BOTTOM w0.088: v2(6.7,82.43) 6.93,82.66 11.52,82.66 11.9,83.04 12.52,83.04 12.91,82.64 DT42.7 DT42.4 15.07,82.64 RT123.1
TBTA_CC1: length 19.8
  TOP w0.086: v1(14.33,84.64) 14.33,84.22 14.24,84.13 v3(14.24,84.08)
  TOP w0.203: v3(14.24,84.08) 14.22,84.11
  TOP w0.254: JUSBC1.A5 8.17,83.32
  TOP w0.305: 8.74,83.15 8.34,83.15 8.17,83.32
  TOP w0.381: RT104.2 21.76,78.27 v2(21.41,78.62) ; 8.74,83.15 10.84,83.15 11.71,84.02 DT41.6 DT41.5 13.65,84.11 14.22,84.11
  GND1 w0.381: v3(14.24,84.08) 14.24,84.21 v4(14.57,84.54)
  IN3 w0.381: v2(21.41,78.62) 18.47,78.62 16.4,80.68 16.4,82.61 15.27,83.74 14.93,83.74 14.57,84.1 v4(14.57,84.54)
TBTA_CC2: length 26.1
  TOP w0.305: v2(6.75,81.85) 6.56,81.85 6.34,82.08 JUSBC1.B5
  IN3 w0.381: v2(21.76,76.29) 19.09,76.29 15.7,79.68 15.7,82.37 15.23,82.84 14.04,82.84 13.53,82.33 13.53,81.37 v2(13.48,81.31)
  BOTTOM w0.381: v2(13.48,81.31) 14.07,81.9 DT42.5 DT42.6 12.34,82.14 12.25,82.23 7.87,82.23 7.49,81.85 v2(6.75,81.85) ; RT105.2 23.21,78.14 v1(22.72,77.65) 21.76,76.69 v2(21.76,76.29)
TBTA_DBG_CTL1: length 5.5
  BOTTOM w0.076: UT5.E4 32.76,72.53 33.5,71.78 34.43,71.78 34.64,71.58
  BOTTOM w0.086: RT106.1 36.49,69.99 36.06,70.42 36.06,70.7 v1(35.5,71.26) 34.96,71.26 34.64,71.58
TBTA_DBG_CTL2: length 4.9
  BOTTOM w0.076: 34.45,72.28 33.23,72.28 32.72,72.8 UT5.D5
  BOTTOM w0.086: 34.45,72.28 35.11,72.28 36.49,70.9 RT107.1
TBTA_DC_SS: length 74.1
  GND1 w0.508: v4(66.59,31.66) 66.84,31.66 67.35,31.15 v3(67.35,30.77)
  IN3 w0.508: v4(45.53,37.14) 45.29,37.14 44.91,37.52 42.91,37.52 40.75,39.69 40.75,42.32 43.65,45.23 43.65,48.19 43.54,48.3 43.54,51.95 42.67,52.82 42.67,60.44 44.33,62.1 44.33,76.76 45.66,78.09
  IN4 w0.508: v4(66.59,31.66) 66.31,31.94 59.1,31.94 58.79,31.63 54.18,31.63 53.08,32.74 52.56,32.74 v4(52.19,32.37)
  GND5 w0.508: v5(51.63,32.37) v4(52.19,32.37) ; v5(46.42,36.61) 46.07,36.61 v4(45.53,37.14)
  BOTTOM w0.508: v5(46.42,36.61) 48.58,36.61 49.12,36.08 49.12,33.08 49.83,32.37 v5(51.63,32.37)
  vias: v1(47.57,79.51) v2(46.68,78.84) v2(46.68,78.25) v2(46.8,77.68) v2(47.26,78.84) v2(47.26,78.25) v2(47.39,77.68) v2(47.87,78.84) v2(47.87,78.25)
TBTA_DEBUG1: length 3.4
  TOP w0.086: RT92.2 27.1,70.78 27.1,70.9 27.43,71.23 v2(27.43,71.23)
  BOTTOM w0.076: UT5.L2 28.49,71.53
  BOTTOM w0.086: 28.49,71.53 28.32,71.53 27.95,71.16 27.51,71.16 27.43,71.23 v2(27.43,71.23) 27.43,71.43 v1(27.14,71.71)
TBTA_DEBUG2: length 2.2
  TOP w0.086: RT93.2 28.06,70.65 v2(28.47,71.05)
  BOTTOM w0.076: UT5.K2 29.47,71.27 29.04,71.27 28.82,71.05 28.74,71.05
  BOTTOM w0.086: 28.74,71.05 v2(28.47,71.05)
TBTA_DEBUG3: length 3.5
  TOP w0.086: v1(27.11,71.69) 27.45,72.03 v2(27.45,72.15) 28.06,72.76 RT89.2
  BOTTOM w0.076: UT5.L3 29.19,72 28.82,72
  BOTTOM w0.086: v2(27.45,72.15) 28.09,72.15 28.25,72 28.82,72
TBTA_DEBUG4: length 7.9
  GND1 w0.086: v3(25.9,75.78) 26.35,75.78 26.38,75.75 v4(26.45,75.75)
  IN4 w0.051: v4(26.45,75.75) 26.03,75.32 26.03,74.66 26.94,73.75 26.94,72.09 27.34,71.68 v2(27.8,71.68)
  BOTTOM w0.076: UT5.K3 29.48,71.78 28.64,71.78
  BOTTOM w0.086: 28.64,71.78 27.9,71.78 v2(27.8,71.68)
TBTA_HPD: length 310.5
  TOP w0.086: v3(32.71,62.72) 33.06,63.08 RT23.1 ; DZ107.1 263.3,46.82 v2(263.15,46.98)
  GND1 w0.086: v4(31.72,62.02) 31.95,62.25 31.95,62.48 32.19,62.72 v3(32.71,62.72)
  IN1 w0.051: v2(36.67,77.91) 36.47,77.71 36.47,70.11 36.06,69.71 36.06,68.11 36.42,67.75 36.42,66 33.71,63.29 33.08,63.29 31.8,62.02 v4(31.72,62.02) ; v4(153.11,75.01) 153.82,75.01 154.56,74.27 158.73,74.27 159.29,74.82 160.41,74.82 160.62,74.61 160.62,73.64 161.51,72.75 161.51,71.59 162.65,70.44 162.65,69.45 165.8,66.3 167.3,66.3 167.84,65.76 167.84,63.74 168.85,62.72 168.85,61.2 170.68,59.37 170.68,52.49 171.7,51.47 171.7,51.09 172.94,49.84 173.4,49.84 179.44,43.8 179.44,42.91 180.1,42.25 182.03,42.25 182.28,42 184.97,42 186.7,40.27 211.95,40.27 212.36,39.86 217,39.86 220.01,42.86 221.45,42.86 221.99,43.39 226,43.39 226.81,42.58 229.46,42.58 232.23,39.8 v4(232.23,38.56)
  IN3 w0.061: v4(153.11,75.01) 153.41,75.31 153.41,78.99 153.19,79.21 153.03,79.21 151.79,80.45 151.03,80.45 148.59,82.9 139.35,82.9 138.87,83.38 132.7,83.38 132.07,82.75 132.05,82.75 132.05,82.75 130.57,82.75 129.22,81.4 127.79,81.4 124.06,85.14 115.19,85.14 112.9,82.84 112.3,82.84 110.68,84.46 105.45,84.46 104.23,83.23 78.56,83.23 76.72,85.08 69.09,85.08 67.16,83.15 64.94,83.15 64.65,83.44 61.89,83.44 58.92,80.47 50.56,80.47 50.17,80.87 44.43,80.87 42.18,78.62 42.18,78.29 v4(42.16,78.27)
  IN4 w0.051: v2(36.67,77.91) 36.67,77.22 37.61,76.29 38.68,76.29 39.47,77.08 41.12,77.08 41.24,76.97 42.45,76.97 42.66,77.19 42.66,77.77 v4(42.16,78.27)
  GND5 w0.086: v4(31.72,62.02) 31.41,62.33 31.41,62.84 v5(31.4,62.85) ; v4(232.23,38.56) 232.25,38.56 232.25,38.56 232.57,38.24 v5(232.57,38.2)
  BOTTOM w0.086: UT1.G2 31.08,62.85 v5(31.4,62.85) ; v5(232.57,38.2) 233.94,36.83 v1(233.94,35.92) 233.94,32.93 234.17,32.7 234.57,32.7 235.3,33.42 239.48,33.42 240.76,34.71 247.21,34.71 247.9,35.39 251.12,35.39 252.65,36.92 252.65,40.49 254.81,42.66 258.24,42.66 262.56,46.98 v2(263.15,46.98) ; RT73.2 37.41,77.17 v2(36.67,77.91)
TBTA_HPD_R: length 4.4
  BOTTOM w0.076: UT5.C10 33.46,75.28 34.4,75.28
  BOTTOM w0.086: 34.4,75.28 35.32,75.28 35.56,75.53 v1(35.56,76.12) RT73.1
TBTA_I2C_INT: length 6.9
  IN4 w0.051: v4(30.73,66.75) 30.9,66.93 30.9,67.95 33.22,70.27 33.22,70.5 v4(33.24,70.52)
  GND5 w0.086: v5(33.22,71.03) 33.22,70.54 v4(33.24,70.52) ; v5(30.31,67) 30.47,67 v4(30.73,66.75)
  BOTTOM w0.086: v5(30.31,67) 29.76,67.55 RT16.1
TBTA_I2C_INT_R: length 3
  BOTTOM w0.086: RT410.1 30.04,65.64 30.04,63.44 UT1.E2
TBTA_LSRX: length 23.5
  TOP w0.088: RT21.1 28.31,65.31 v3(28.31,63.92) ; v2(24.27,76.03) 24.3,76.06 24.3,76.41 24.55,76.67 RT88.1 RT90.1 24.99,74.95 v1(25.1,74.84)
  GND1 w0.088: v3(28.31,63.92) 28.67,63.56 29.02,63.56 29.02,63.57 v4(29.01,63.57)
  IN1 w0.062: v4(29.01,63.57) 28.62,63.97 28.62,68.16 27.64,69.14 27.64,70.72 28.05,71.14 28.05,71.38 28.68,72 28.68,72.69 27.29,74.08 26.23,74.08 v2(24.27,76.03)
  GND5 w0.088: v5(28.76,62.52) 29.01,62.77 v4(29.01,63.57)
  BOTTOM w0.088: v5(28.76,62.52) 28.76,62.13 28.45,61.82 UT1.B5
TBTA_LSRX_R: length 8.2
  GND1 w0.088: v3(25.9,76.67) 26.15,76.67 v4(26.37,76.44)
  IN4 w0.062: v4(29.16,72.11) 27.99,73.29 27.99,75.47 27.01,76.44 v4(26.37,76.44)
  GND5 w0.088: v4(29.16,72.11) 28.81,72.11 v5(28.69,72.24)
  BOTTOM w0.076: v5(28.69,72.24) 28.71,72.27 29.12,72.27 29.33,72.27 29.33,72.27 29.58,72.27 29.72,72.41 UT5.K4
TBTA_LSTX: length 15.4
  TOP w0.088: RT87.1 RT89.1 27.14,72.53 v2(26.54,71.92) 26.08,71.46 RT22.1 25.37,71.24 v1(25.25,71.13)
  IN3 w0.083: v2(26.54,71.92) 26.26,71.64 26.26,71.08 26.61,70.72 27.25,70.72 27.45,70.52 27.45,66.99 27.12,66.66 27.12,64.58 v4(28.57,63.13)
  GND5 w0.088: v4(28.57,63.13) 28.43,62.99 v5(28.43,62.28)
TBTA_LSTX_R: length 7.5
  TOP w0.088: RT87.2 28.06,73.92 27.47,74.51 v3(26.84,74.51) 26.48,74.51 v1(26.26,74.28)
  GND1 w0.088: v4(26.45,74.89) 26.83,74.51 v3(26.84,74.51)
  IN4 w0.062: v4(26.45,74.89) 27.53,73.81 27.53,72.92 28.16,72.29 v4(28.16,72.18)
  GND5 w0.088: v5(28.43,72.58) 28.43,72.45 v4(28.16,72.18)
  BOTTOM w0.088: v5(28.43,72.58) 28.48,72.53 UT5.L4
TBTA_MRESET: length 3.6
  BOTTOM w0.086: RT86.1 34.64,77.73 34.21,77.3 33.62,77.3 33.37,77.05 32.61,77.05 32.22,76.67 UT5.E11
TBTA_RESET_N_EC_R: length 1.8
  BOTTOM w0.086: RT110.1 31.72,77.41 UT5.F11
TBTA_ROM_CLK_PD: length 2
  GND1 w0.086: v3(35.92,72.64) 35.59,72.31 v4(35.42,72.31)
  GND5 w0.086: v4(35.42,72.31) 34.9,72.31 v5(34.59,71.99)
  BOTTOM w0.086: v5(34.59,71.99) 34.56,72.02 UT5.A3
TBTA_ROM_CS#_PD: length 4.5
  GND1 w0.086: v4(35.39,74.74) 35.71,74.42 v3(35.92,74.42)
  IN1 w0.051: v4(35.39,74.74) 34.99,74.74 34.23,73.99 34.23,72.49 v4(34.32,72.4)
  GND5 w0.086: v4(34.32,72.4) 34.1,72.4 v5(33.72,72.03)
TBTA_ROM_DI_PD: length 5.9
  GND1 w0.086: v4(35.42,75.61) 35.62,75.61 v3(35.92,75.31)
  IN1 w0.051: v4(35.42,75.61) 35.12,75.31 34.6,75.31 34.36,75.55 33.94,75.55 33.75,75.36 33.75,73.58 v2(33.19,73.02)
  BOTTOM w0.086: UT5.B4 33.68,72.53 v2(33.19,73.02)
TBTA_ROM_DO_PD: length 2.2
  GND1 w0.086: v4(35.43,72.89) 35.92,73.39 v3(35.92,73.53)
  GND5 w0.086: v5(34.92,72.77) 35.31,72.77 v4(35.43,72.89)
  BOTTOM w0.086: UT5.A4 34.48,72.78 34.9,72.78 v5(34.92,72.77)
TBTA_ROSC: length 2.3
  BOTTOM w0.076: 31.48,70.72 31.48,70.92 31.48,70.92 31.48,71.13 31.48,71.13 31.48,71.27 UT5.G2
  BOTTOM w0.086: RT100.1 31.03,69.68 31.48,70.13 31.48,70.72
TBTA_RX1N: length 45.6
  TOP w0.156: v2(6.7,84.58) 6.69,84.57 JUSBC1.B10 ; v2(26.71,58.4) 26.74,58.4 26.94,58.21 arc(27.05,58.13) 27.19,58.1 27.26,58.1 arc(27.37,58.14) 27.41,58.26 27.41,63.21 arc(27.41,63.25) 27.41,63.3 27.22,64.37 arc(27.2,64.46) 27.16,64.55 21.7,74.01 arc(21.69,74.03) 21.68,74.05 21.4,74.45 arc(21.38,74.48) 21.36,74.52 21.26,74.69 20.56,76.09 arc(20.54,76.13) 20.53,76.17 19.35,80.56 19.32,80.64 arc(19.27,80.83) 19.23,81.02 arc(19.23,81.04) 19.22,81.06 arc(19.15,81.5) 19.11,81.95 arc(19.1,82.14) 19.1,82.32 19.1,84.53 arc(19.02,84.72) 18.83,84.8 18.71,84.8 arc(18.57,84.78) v2(18.45,84.7)
  BOTTOM w0.076: UT1.B13 28.31,58.27 arc(28.18,58.35) 28.04,58.38 27.9,58.38 arc(27.78,58.35) 27.67,58.28 27.65,58.26 arc(27.64,58.25) 27.63,58.25 arc(27.63,58.24) 27.62,58.24 arc(27.58,58.22) 27.54,58.22 27.54,58.22 arc(27.54,58.22) 27.54,58.22 27.27,58.22 27.23,58.26
  BOTTOM w0.156: v2(6.7,84.58) 6.95,84.83 arc(7,84.86) 7.06,84.88 7.42,84.88 arc(8,84.99) 8.49,85.32 9.01,85.84 arc(9.37,86.08) 9.79,86.17 12.54,86.17 arc(12.6,86.15) 12.65,86.12 DT14.1 13.36,86.14 arc(13.41,86.17) 13.47,86.18 13.97,86.18 arc(14.01,86.18) 14.04,86.18 arc(14.24,86.15) 14.42,86.08 arc(14.59,85.99) 14.74,85.86 arc(15.84,85.13) 17.13,84.87 18.03,84.87 arc(18.26,84.83) v2(18.45,84.7) ; 27.23,58.26 27.07,58.26 arc(26.88,58.29) v2(26.71,58.4)
TBTA_RX1P: length 45.6
  TOP w0.156: JUSBC1.B11 6.49,85.08 arc(6.61,85.1) v2(6.7,85.16) ; v2(18.45,85.28) 18.61,85.12 arc(18.7,85.06) 18.81,85.04 18.83,85.04 arc(19.19,84.89) 19.34,84.53 19.34,82.32 arc(19.34,82.15) 19.35,81.97 19.35,81.97 arc(19.39,81.53) 19.46,81.1 arc(19.46,81.08) 19.46,81.07 arc(19.5,80.88) 19.55,80.7 19.58,80.62 20.76,76.23 arc(20.76,76.21) 20.77,76.2 21.47,74.8 21.56,74.64 arc(21.58,74.61) 21.59,74.59 21.59,74.59 21.87,74.19 arc(21.89,74.16) 21.91,74.13 27.37,64.67 arc(27.42,64.54) 27.46,64.41 27.64,63.34 arc(27.65,63.27) 27.65,63.21 27.65,58.26 arc(27.54,57.98) 27.26,57.86 27.19,57.86 27.09,57.85 arc(26.9,57.84) v2(26.71,57.82)
  BOTTOM w0.076: 27.24,58.02 27.28,58.06 27.54,58.06 arc(27.63,58.04) 27.71,57.99 arc(27.75,57.96) 27.8,57.93 arc(27.87,57.93) 27.93,57.96 27.97,58.01 arc(27.99,58.05) 27.99,58.08 UT1.A13
  BOTTOM w0.156: v2(26.71,57.82) 26.77,57.87 arc(26.93,57.98) 27.12,58.02 27.24,58.02 ; v2(6.7,85.16) arc(6.75,85.13) 6.81,85.11 7.42,85.11 arc(7.91,85.21) 8.32,85.49 8.85,86.01 arc(9.28,86.3) 9.79,86.4 12.8,86.4 arc(12.91,86.42) DT13.1 arc(13.07,86.44) 13.15,86.42 13.97,86.42 arc(14.01,86.42) 14.06,86.42 arc(14.52,86.3) 14.91,86.03 arc(15.93,85.35) 17.13,85.11 18.03,85.11 arc(18.26,85.15) v2(18.45,85.28)
TBTA_RX2N: length 32.8
  TOP w0.156: JUSBC1.A10 8.6,80.82 arc(9.01,80.74) 9.35,80.52 10.47,79.39 arc(10.66,79.27) 10.87,79.23 12.6,79.23 arc(12.62,79.23) 12.64,79.23 arc(12.64,79.23) 12.64,79.23 12.65,79.23 arc(12.69,79.23) 12.72,79.24 DT9.1 arc(13.09,79.31) 13.2,79.29 13.56,79.29 arc(13.96,79.21) 14.29,78.99 14.33,78.94 arc(14.62,78.51) 14.72,78 14.72,76.79 arc(14.87,76.04) 15.3,75.41 15.3,75.41 arc(15.37,75.34) 15.44,75.29 15.58,75.18 arc(15.6,75.18) 15.61,75.17 17.01,74.5 arc(17.05,74.49) 17.08,74.47 17.5,74.19 arc(17.64,74.08) 17.78,73.96 17.97,73.79 arc(18.08,73.68) 18.18,73.56 18.23,73.5 18.46,73.23 19.77,71.43 21.09,69.42 23.9,64.38 arc(23.98,64.19) 24,64 24,62.86 arc(24.05,62.73) 24.18,62.68 24.18,62.68 arc(24.28,62.68) 24.38,62.71 24.39,62.72 arc(24.44,62.75) 24.48,62.79 v2(24.56,62.83)
  BOTTOM w0.076: UT1.A7 28.09,60.9 arc(28.16,60.93) 28.19,61 28.19,61.06 arc(28.16,61.12) 28.1,61.15 27.87,61.15 arc(27.82,61.14) 27.79,61.12 27.6,60.93 arc(27.59,60.92) 27.58,60.91 arc(27.57,60.91) 27.56,60.91 arc(27.55,60.9) 27.53,60.89 arc(27.5,60.89) 27.48,60.89 arc(27.42,60.9) 27.36,60.93 27.24,61.05 27.24,61.07 arc(27.23,61.11) 27.21,61.14
  BOTTOM w0.156: v2(24.56,62.83) 24.54,62.85 arc(24.74,62.65) 25,62.54 25.05,62.53 arc(25.54,62.46) 26,62.27 26.19,62.18 arc(26.51,61.94) 26.76,61.61 26.79,61.57 27.21,61.14
TBTA_RX2P: length 32.7
  TOP w0.156: JUSBC1.A11 7.67,80.32 arc(7.89,80.37) 8.09,80.5 arc(8.19,80.56) 8.3,80.59 8.6,80.59 arc(8.92,80.52) 9.18,80.35 10.3,79.23 arc(10.57,79.05) 10.87,78.99 12.6,78.99 arc(12.83,78.92) 12.97,78.73 DT10.1 13.32,78.98 arc(13.4,79.03) 13.49,79.05 13.56,79.05 arc(13.86,78.99) 14.12,78.82 14.16,78.78 arc(14.4,78.42) 14.49,78 14.49,76.79 arc(14.65,75.95) 15.13,75.24 arc(15.21,75.16) 15.3,75.09 15.45,74.99 arc(15.48,74.97) 15.5,74.96 15.51,74.95 16.91,74.29 arc(16.93,74.28) 16.95,74.27 17.36,73.99 arc(17.5,73.9) 17.62,73.79 17.81,73.62 arc(17.91,73.52) 18,73.41 18.05,73.35 18.27,73.08 19.57,71.29 20.89,69.3 23.69,64.26 arc(23.75,64.13) 23.76,64 23.76,62.86 arc(23.89,62.56) 24.18,62.44 arc(24.4,62.39) v2(24.56,62.25)
  BOTTOM w0.076: UT1.B7 arc(28.26,60.74) 28.04,60.69 arc(27.96,60.68) 27.89,60.68 arc(27.83,60.68) 27.77,60.7 arc(27.67,60.73) 27.57,60.74 arc(27.53,60.73) 27.48,60.73 arc(27.36,60.75) 27.25,60.82 27.13,60.94 27.12,60.94 arc(27.08,60.95) 27.04,60.97
  BOTTOM w0.156: 27.04,60.97 26.59,61.42 26.55,61.5 26.55,61.5 arc(26.35,61.77) 26.07,61.97 25.89,62.06 arc(25.48,62.23) 25.04,62.3 25.02,62.3 arc(24.87,62.3) 24.71,62.28 v2(24.56,62.25)
TBTA_SBU1: length 22.5
  TOP w0.088: JUSBC1.A8 8,81.82 8.19,82.02 DT41.9 DT41.1 13.56,81.8 13.45,81.7 13.28,81.7 v2(12.9,81.31)
  IN3 w0.083: v2(12.9,81.31) 12.03,80.45 12.03,79.89 12.39,79.54 14.95,79.54 19.09,75.4 21.68,75.4 v2(21.99,75.7)
  BOTTOM w0.088: RT108.2 23.03,76.67 22.06,75.7 v2(21.99,75.7)
TBTA_SBU1_R: length 6.5
  BOTTOM w0.076: 28.44,75.1 28.78,74.77 29.48,74.77 UT5.K8
  BOTTOM w0.088: RT108.1 v1(25.06,76.67) 25.54,76.18 25.58,76.18 25.6,76.16 27.33,76.16 28.39,75.1 28.44,75.1
TBTA_SBU2: length 25.4
  TOP w0.088: JUSBC1.B8 6.67,83.57 v2(6.7,83.6)
  IN3 w0.083: v2(23.68,76.02) 23.68,78.81 21.25,81.24 20.11,81.24 18.23,83.12 16.83,83.12 15.66,84.29 v2(15.16,84.29)
  BOTTOM w0.088: v2(23.68,76.02) 24.07,75.62 RT109.2 ; v1(14.86,84.72) 15.16,84.43 v2(15.16,84.29) 15.01,84.14 DT42.1 DT42.9 11.94,84.14 11.09,83.3 7.41,83.3 7.1,83.6 v2(6.7,83.6)
TBTA_SBU2_R: length 4
  BOTTOM w0.076: UT5.L8 28.02,74.53 v1(27.72,74.83)
  BOTTOM w0.088: v1(27.72,74.83) 26.29,74.83 25.89,75.23 RT109.1
TBTA_TOP_N: length 24.3
  TOP w0.088: v2(16.95,82.08) 16.73,82.3 16.48,82.3 16.27,82.51 16.27,82.79 16.07,82.99 15.84,82.99 RT121.1
  IN3 w0.083: v2(16.95,82.08) 17.13,82.25 17.75,82.25 19.71,80.29 21.28,80.29 22.57,79.01 22.57,75.32 22.08,74.84 22.08,73.8 22.42,73.46 23.24,73.46 23.5,73.71 23.5,73.89 23.67,74.06 v2(23.67,74.07)
  BOTTOM w0.076: 28.22,73.53 28.24,73.53 28.24,73.52 28.64,73.52 28.71,73.6 28.71,73.68 28.79,73.76 28.89,73.76 28.97,73.68 28.97,73.56 29,73.53 UT5.L6
  BOTTOM w0.088: v2(23.67,74.07) 23.68,74.06 23.68,73.79 23.6,73.72 23.36,73.72 23.27,73.63 23.27,73.46 23.33,73.4 23.8,73.4 24.38,73.97 25.32,73.97 25.42,73.87 27.38,73.87 27.72,73.53 28.22,73.53
TBTA_TOP_N_R: length 7.5
  TOP w0.088: JUSBC1.A7 8.1,82.32 8.29,82.51 11.33,82.51 11.74,82.92 11.9,82.92 12.31,82.52 DT41.8 DT41.2 14.02,82.52 14.14,82.64 RT121.2
TBTA_TOP_P: length 24.4
  TOP w0.088: v2(16.95,82.66) 16.77,82.48 16.55,82.48 16.45,82.58 16.45,82.86 16.14,83.17 15.84,83.17 RT120.1
  IN3 w0.083: v2(23.09,74.07) 23.1,74.07 23.31,73.86 23.31,73.79 23.16,73.64 22.5,73.64 22.27,73.87 22.27,74.76 22.75,75.24 22.75,79.09 21.36,80.48 19.79,80.48 17.82,82.44 17.18,82.44 v2(16.95,82.66)
  BOTTOM w0.076: UT5.K6 29.32,73.27 29.08,73.27 28.99,73.36 28.24,73.36 28.24,73.36 28.22,73.36
  BOTTOM w0.088: v2(23.09,74.07) 23.1,74.07 23.23,73.93 23.23,73.84 23.1,73.7 23.1,73.39 23.26,73.23 23.88,73.23 24.45,73.8 25.24,73.8 25.35,73.69 27.31,73.69 27.65,73.36 28.22,73.36
TBTA_TOP_P_R: length 7.4
  TOP w0.088: JUSBC1.A6 8.1,82.82 8.24,82.69 11.26,82.69 11.67,83.1 11.86,83.1 12.28,83.52 DT41.7 DT41.4 14.56,83.52 RT120.2
TBTA_TX1N: length 2.9
  BOTTOM w0.076: 26.87,59.21 26.89,59.21 26.93,59.17 26.93,59.17 arc(27.08,59.16) 27.23,59.11 arc(27.26,59.1) 27.3,59.1 27.54,59.1 arc(27.55,59.1) 27.56,59.11 arc(27.56,59.11) 27.57,59.11 arc(27.58,59.12) 27.59,59.13 arc(27.59,59.13) 27.6,59.13 arc(27.6,59.13) 27.6,59.14 arc(27.61,59.14) 27.61,59.14 arc(27.61,59.14) 27.61,59.15 arc(27.62,59.15) 27.62,59.15 arc(27.62,59.15) 27.62,59.15 27.64,59.17 arc(27.76,59.25) 27.91,59.28 28.03,59.28 arc(28.2,59.25) 28.34,59.15 UT1.B11
  BOTTOM w0.156: 26.87,59.21 26.15,59.21 arc(26.04,59.22) 25.93,59.26 25.73,59.39 CT96.1
TBTA_TX1N_C: length 40.6
  TOP w0.156: JUSBC1.A3 7.74,84.32 arc(7.89,84.35) 8.02,84.44 8.12,84.54 arc(8.17,84.58) 8.23,84.59 8.74,84.59 arc(9.04,84.65) 9.29,84.82 10.23,85.75 arc(10.68,86.05) 11.21,86.16 12.55,86.16 arc(12.61,86.14) 12.66,86.11 DT6.1 13.22,85.99 arc(13.44,86.14) 13.69,86.19 13.95,86.19 arc(14.39,86.1) 14.77,85.85 16.5,84.11 arc(16.99,83.7) 17.52,83.34 arc(17.73,83.16) 17.85,82.9 arc(17.9,82.65) 17.92,82.39 arc(17.92,82.3) 17.94,82.21 19.17,76.95 19.17,76.94 19.2,76.85 arc(19.22,76.78) 19.24,76.71 20.1,74.72 20.84,73.26 26.22,64.22 arc(26.24,64.17) 26.26,64.12 26.31,63.99 arc(26.34,63.58) 26.36,63.17 26.36,61.44 arc(26.1,60.16) 25.38,59.07 arc(25.23,58.97) 25.05,58.94 24.92,58.94 arc(24.86,58.95) 24.81,58.98 24.58,59.21 24.58,59.22 24.54,59.27 v2(24.54,59.32)
  BOTTOM w0.156: CT96.2 25.14,59.3 arc(25.11,59.2) 25.03,59.15 24.8,59.11 24.72,59.11 arc(24.58,59.18) v2(24.54,59.32)
TBTA_TX1P: length 2.9
  BOTTOM w0.076: UT1.A11 28.04,59.06 arc(28.11,59.05) 28.16,59.01 arc(28.17,58.94) 28.14,58.87 arc(28.11,58.85) 28.08,58.84 27.88,58.84 arc(27.79,58.86) 27.71,58.92 27.7,58.92 arc(27.68,58.94) 27.65,58.94 27.3,58.94 arc(27.23,58.95) 27.17,58.97 arc(27.05,59) 26.93,59.02 26.93,59.02 26.89,58.98 26.87,58.98
  BOTTOM w0.156: 26.87,58.98 26.24,58.98 arc(25.96,58.92) CT95.1
TBTA_TX1P_C: length 40.7
  TOP w0.156: JUSBC1.A2 8.74,84.82 arc(8.95,84.87) 9.12,84.98 10.06,85.92 arc(10.59,86.27) 11.21,86.39 12.78,86.39 arc(12.9,86.42) DT5.1 13.01,86.47 arc(13.06,86.44) 13.12,86.43 13.95,86.43 arc(14.48,86.32) 14.93,86.02 16.67,84.28 arc(17.14,83.89) 17.65,83.55 arc(17.92,83.3) 18.08,82.96 arc(18.14,82.68) 18.15,82.39 arc(18.16,82.33) 18.17,82.27 19.43,76.91 arc(19.44,76.86) 19.46,76.81 20.31,74.82 21.05,73.38 26.42,64.34 arc(26.46,64.27) 26.49,64.19 26.54,64.04 arc(26.58,63.61) 26.6,63.17 26.6,61.44 arc(26.32,60.07) 25.54,58.9 arc(25.32,58.75) 25.05,58.7 24.76,58.7 arc(24.72,58.7) 24.68,58.69 24.62,58.67 v2(24.54,58.64)
  BOTTOM w0.156: CT95.2 25.12,58.78 arc(25.03,58.84) 24.92,58.86 24.86,58.86 arc(24.8,58.85) 24.75,58.82 v2(24.54,58.64)
TBTA_TX2N: length 3.2
  BOTTOM w0.076: UT1.B9 28.31,59.87 arc(28.22,59.8) 28.12,59.76 arc(27.94,59.75) 27.77,59.78 arc(27.61,59.8) 27.45,59.81 arc(27.4,59.81) 27.35,59.81 arc(27.31,59.81) 27.26,59.82 27.24,59.82 27.13,59.85 27.08,59.83 27.06,59.83
  BOTTOM w0.156: CT98.1 25.76,60.42 arc(25.86,60.5) 25.98,60.55 arc(25.99,60.56) 26,60.56 arc(26.02,60.56) 26.04,60.56 26.18,60.56 arc(26.25,60.55) 26.31,60.5 26.76,59.97 arc(26.9,59.87) 27.06,59.83
TBTA_TX2N_C: length 33.6
  TOP w0.156: JUSBC1.B3 6.28,81.08 arc(6.53,81.03) v2(6.74,80.89) ; v2(15.78,77.44) 15.87,77.38 arc(15.98,77.34) 16.1,77.32 16.17,77.32 arc(16.21,77.32) 16.24,77.32 arc(16.52,77.24) 16.76,77.08 16.96,76.88 arc(17,76.83) 17.03,76.79 20.47,72.13 21.97,69.94 25.52,63.82 arc(25.59,63.63) 25.62,63.43 25.62,61.27 arc(25.61,61.11) 25.56,60.95 25.56,60.94 25.52,60.83 arc(25.39,60.66) 25.18,60.58 arc(24.86,60.55) v2(24.54,60.5)
  BOTTOM w0.156: CT98.2 25.07,60.55 arc(25.01,60.61) 24.92,60.64 24.75,60.64 arc(24.69,60.63) 24.63,60.59 v2(24.54,60.5) ; v2(6.74,80.89) 6.74,80.82 6.78,80.77 arc(6.83,80.74) 6.89,80.73 7.46,80.73 arc(7.88,80.64) 8.24,80.4 8.95,79.7 arc(9.45,79.37) 10.03,79.25 12.7,79.25 arc(12.86,79.28) DT18.1 13.06,79.3 arc(13.12,79.27) 13.18,79.26 13.48,79.26 arc(13.79,79.2) 14.05,79.02 14.58,78.5 arc(14.75,78.24) 14.81,77.94 14.81,77.63 arc(14.89,77.43) 15.09,77.35 15.58,77.35 arc(15.69,77.37) v2(15.78,77.44)
TBTA_TX2P: length 3.2
  BOTTOM w0.076: UT1.A9 28.03,59.98 arc(28.1,60.01) 28.13,60.08 28.13,60.09 arc(28.09,60.17) 28.01,60.21 27.92,60.21 arc(27.8,60.18) 27.71,60.12 27.67,60.09 arc(27.67,60.08) 27.67,60.08 arc(27.67,60.08) 27.67,60.08 arc(27.64,60.06) 27.61,60.04 arc(27.52,59.99) 27.42,59.97 arc(27.39,59.96) 27.35,59.96 arc(27.33,59.97) 27.31,59.97 27.3,59.97 27.29,59.98 27.28,59.98 27.17,60.01 27.15,60.05 27.13,60.06
  BOTTOM w0.156: 27.13,60.06 27.12,60.07 27.06,60.07 arc(27,60.08) 26.95,60.12 26.52,60.62 26.49,60.66 arc(26.35,60.76) 26.18,60.8 arc(25.96,60.84) 25.78,60.97 CT97.1
TBTA_TX2P_C: length 33.6
  TOP w0.156: v2(24.54,61.08) 24.66,60.95 arc(24.8,60.85) 24.97,60.82 25.15,60.82 arc(25.24,60.84) 25.3,60.92 25.34,61.03 25.34,61.03 arc(25.37,61.15) 25.38,61.27 25.38,61.27 25.38,63.43 arc(25.36,63.57) 25.31,63.7 21.77,69.81 20.28,72 16.84,76.65 arc(16.82,76.68) 16.79,76.71 16.59,76.91 arc(16.42,77.03) 16.22,77.08 16.11,77.07 arc(16.03,77.06) 15.96,77.03 arc(15.82,76.88) v2(15.77,76.68) ; v2(6.72,80.27) 6.64,80.27 6.62,80.3 arc(6.31,80.5) JUSBC1.B2
  BOTTOM w0.156: v2(15.77,76.68) 15.77,76.76 15.77,76.76 15.77,76.87 15.63,77 arc(15.51,77.09) 15.37,77.11 15.09,77.11 arc(14.72,77.26) 14.57,77.63 14.57,77.94 arc(14.53,78.15) 14.41,78.33 13.88,78.86 arc(13.7,78.98) 13.48,79.02 13.34,79.02 arc(13.23,78.98) 13.18,78.86 13.18,78.84 arc(13.13,78.71) DT17.1 12.71,78.94 arc(12.64,78.99) 12.54,79.01 10.03,79.01 arc(9.35,79.15) 8.78,79.53 8.07,80.24 arc(7.79,80.42) 7.46,80.49 7.08,80.49 arc(7,80.47) 6.93,80.43 6.77,80.27 v2(6.72,80.27) ; v2(24.54,61.08) 24.66,60.96 arc(24.71,60.92) 24.77,60.91 24.96,60.91 arc(25.02,60.92) 25.07,60.96 CT97.2
TBTA_USB2_RBIAS: length 2.7
  TOP w0.086: RT42.1 30.59,54.72 v3(30.88,54.72)
  GND1 w0.086: v4(30.35,54.42) 30.4,54.42 30.7,54.72 v3(30.88,54.72)
  GND5 w0.086: v5(30.73,54.95) 30.35,54.57 v4(30.35,54.42)
  BOTTOM w0.086: v5(30.73,54.95) 30.73,55.06 UT1.F19
TBTA_USB20_N: length 54.7
  IN3 w0.083: v2(24.29,72.32) 24.29,72.37 24.47,72.56 24.55,72.56 24.7,72.42 24.7,72.15 24.35,71.8 24.35,71.29 24.27,71.21 20.56,71.21 20.37,71.02 20.37,70.44 20.56,70.25 23.44,70.25 23.53,70.17 23.53,69.74 23.44,69.66 20.53,69.66 20.34,69.47 20.34,68.89 20.53,68.7 23.49,68.7 23.58,68.62 23.58,68.19 23.49,68.11 20.74,68.11 20.55,67.92 20.55,67.34 20.74,67.15 23.43,67.15 23.51,67.06 23.51,66.64 23.43,66.56 22.38,66.56 22.18,66.36 22.18,65.79 22.38,65.6 23.22,65.6 24.05,64.77 26.32,64.77 26.42,64.66 26.42,64.21 26.34,64.13 25.34,64.13 25.15,63.94 25.15,63.36 25.34,63.17 26.71,63.17 26.79,63.08 26.79,62.66 26.71,62.58 25.34,62.58 25.15,62.39 25.15,61.81 25.34,61.62 27.4,61.62 27.49,61.53 27.49,61.11 27.4,61.03 25.34,61.03 25.15,60.83 25.15,60.26 25.34,60.06 28.16,60.06 28.5,59.73 28.5,56.94 29.07,56.37 29.42,56.37 29.69,56.1 29.69,55.91 29.47,55.69 v2(29.46,55.69)
  BOTTOM w0.088: UT1.D19 29.13,55.36 v2(29.46,55.69) ; RT404.2 24.99,72.44 24.9,72.53 24.5,72.53 v2(24.29,72.32)
TBTA_USB20_P: length 54.7
  IN3 w0.083: v2(30.09,55.69) 29.88,55.9 29.88,56.18 29.5,56.56 29.14,56.56 28.68,57.02 28.68,59.8 28.24,60.25 25.42,60.25 25.34,60.33 25.34,60.76 25.42,60.84 27.48,60.84 27.67,61.03 27.67,61.61 27.48,61.8 25.42,61.8 25.34,61.88 25.34,62.31 25.42,62.39 26.78,62.39 26.97,62.58 26.97,63.16 26.78,63.35 25.42,63.35 25.34,63.44 25.34,63.86 25.42,63.94 26.41,63.94 26.61,64.13 26.61,64.74 26.4,64.95 24.13,64.95 23.3,65.78 22.45,65.78 22.37,65.86 22.37,66.29 22.45,66.37 23.51,66.37 23.7,66.56 23.7,67.14 23.51,67.33 20.81,67.33 20.73,67.41 20.73,67.84 20.81,67.92 23.57,67.92 23.76,68.11 23.76,68.69 23.57,68.88 20.61,68.88 20.53,68.97 20.53,69.39 20.61,69.47 23.52,69.47 23.71,69.66 23.71,70.24 23.52,70.43 20.64,70.43 20.55,70.52 20.55,70.94 20.64,71.03 24.34,71.03 24.54,71.22 24.54,71.73 24.88,72.07 24.88,72.5 24.63,72.75 24.44,72.75 v2(24.27,72.91)
  BOTTOM w0.088: UT1.E19 29.78,55.37 v2(30.09,55.69) ; v2(24.27,72.91) 24.48,72.7 24.7,72.7 RT403.2
TBTB_AUXN: length 20.4
  IN4 w0.062: v4(23.54,48.09) 23.86,48.09 23.93,48.15 23.93,48.42 23.83,48.51 23.28,48.51 23.22,48.57 23.22,48.69 23.42,48.89 24.45,48.89 26.94,51.38 27.69,51.38 29.01,52.7 32.41,52.7 34.51,54.79 34.51,55.97 35.32,56.78 35.32,57.13 35.43,57.24 35.78,57.24 35.96,57.06 v2(35.96,57)
  GND5 w0.088: v5(23.54,48.57) 23.33,48.37 23.33,48.29 v4(23.54,48.09)
  BOTTOM w0.088: v5(23.54,48.57) CT157.1 ; v2(35.96,57) 35.97,57 UT1.W15
TBTB_AUXN_C: length 5.3
  BOTTOM w0.076: 25.96,45.89 25.98,45.89 25.98,45.88 26.36,45.88 26.61,45.63 UT11.J2
  BOTTOM w0.088: CT157.2 23.36,47.37 23.36,47.05 RT204.1 23.36,46.34 23.36,46.21 23.44,46.13 25.37,46.13 25.61,45.89 25.96,45.89
TBTB_AUXP: length 20.4
  IN4 w0.062: v2(36.61,57) 36.22,57.38 35.36,57.38 35.18,57.19 35.18,56.84 34.37,56.03 34.37,54.86 32.35,52.84 28.95,52.84 27.63,51.52 26.88,51.52 24.39,49.03 23.36,49.03 23.07,48.75 23.07,48.21 v4(22.95,48.09)
  GND5 w0.088: v4(22.95,48.09) 23.08,48.22 23.08,48.4 v5(22.9,48.57)
  BOTTOM w0.088: v2(36.61,57) 36.62,57 UT1.Y15 ; v5(22.9,48.57) CT156.1
TBTB_AUXP_C: length 5.1
  BOTTOM w0.076: 25.96,45.72 25.98,45.72 25.98,45.72 26.13,45.72 UT11.J1
  BOTTOM w0.088: 25.96,45.72 25.54,45.72 25.3,45.96 23.37,45.96 23.19,46.13 23.19,46.36 RT205.1 23.19,47.03 23.19,47.26 CT156.2
TBTB_BOT_N: length 32.6
  IN3 w0.083: v4(29.75,46.67) 29.54,46.46 29.42,46.46 29.19,46.69 26.37,46.69 26.05,47.01 26.05,47.73 26.32,48 26.32,48.86 26.13,49.05 26.13,51.12 23.95,53.3 22.65,53.3 22.14,53.81 22.14,54.82 19,57.96 19,65.32 18.8,65.52 18.26,65.52 v2(18.06,65.72)
  GND5 w0.088: v4(29.75,46.67) 29.55,46.47 29.38,46.47 v5(29.23,46.63)
  BOTTOM w0.088: v2(18.06,65.72) 17.87,65.53 17.11,65.53 16.78,65.86 16.78,67.97 16.6,68.16 16.38,68.16 RT216.2
TBTB_BOT_N_R: length 9.6
  TOP w0.088: JUSBC2.B7 6.64,68.57 v2(6.71,68.51)
  BOTTOM w0.088: RT216.1 14.96,68.66 DT44.2 DT44.8 12.81,68.66 12.44,68.28 12.11,68.28 11.99,68.41 7.51,68.41 7.38,68.28 6.94,68.28 v2(6.71,68.51)
TBTB_BOT_P: length 32.6
  IN3 w0.083: v2(18.06,65.14) 18.26,65.34 18.72,65.34 18.81,65.25 18.81,57.89 21.96,54.75 21.96,53.73 22.57,53.11 23.88,53.11 25.94,51.05 25.94,48.98 26.14,48.78 26.14,48.08 25.86,47.81 25.86,46.94 26.29,46.51 29.11,46.51 29.34,46.28 29.55,46.28 v4(29.75,46.08)
  GND5 w0.088: v4(29.75,46.08) 29.54,46.3 29.4,46.3 v5(29.23,46.13)
  BOTTOM w0.088: RT217.2 16.33,67.99 16.53,67.99 16.61,67.9 16.61,65.79 17.04,65.36 17.84,65.36 v2(18.06,65.14)
TBTB_BOT_P_R: length 9.6
  TOP w0.088: JUSBC2.B6 6.55,68.07 6.7,67.92 v2(6.7,67.93)
  BOTTOM w0.088: v2(6.7,67.93) 6.82,68.05 6.83,68.05 6.89,68.11 7.45,68.11 7.58,68.23 11.91,68.23 12.04,68.11 12.33,68.11 12.78,67.66 DT44.7 DT44.4 15.07,67.66 RT217.1
TBTB_CC1: length 57.1
  TOP w0.086: v3(30.57,45.88) 29.56,45.88 CT155.1
  TOP w0.102: v2(14.83,69.22) 14.83,69.38 14.28,69.92 v1(14.28,70.32)
  TOP w0.254: JUSBC2.A5 8.01,68.82
  TOP w0.305: 8.01,68.82 8.15,68.69 8.45,68.69
  TOP w0.381: v2(14.83,69.22) 13.99,69.22 13.79,69.03 DT43.5 DT43.6 11.45,69.03 11.11,68.69 8.45,68.69
  GND1 w0.086: v4(30.73,46.75) 30.73,46.04 v3(30.57,45.88)
  IN2 w0.381: v2(14.83,69.22) 13,67.4 13,66.54 11.87,65.41 11.87,62.96 14.11,60.71 14.11,60.08 v4(14.38,59.81)
  IN4 w0.381: v4(30.73,46.75) 30.82,46.66 30.82,46.1 29.31,44.59 29.31,44.56 29.28,44.53 29.28,44.41 28.96,44.09 28.36,44.09 26.6,45.84 24.11,45.84 23.57,45.3 21.32,45.3 20.74,45.88 20.74,46.57 19.96,47.35 19.66,47.35 19.03,47.98 19.03,49.81 19.75,50.54 19.75,53.53 14.22,59.06 14.22,59.65 v4(14.38,59.81)
  GND5 w0.254: v5(30.17,46.97) 30.5,46.97 v4(30.73,46.75)
  BOTTOM w0.086: v5(30.17,46.97) 30.17,47.23 29.53,47.86 29.53,48.78 29.78,49.03 RT197.2
  BOTTOM w0.203: UT11.L9 30.23,46.91 v5(30.17,46.97)
TBTB_CC2: length 50.4
  TOP w0.254: JUSBC2.B5 6.37,67.57
  TOP w0.305: v2(6.75,67.35) 6.73,67.37 6.57,67.37 6.37,67.57
  IN1 w0.381: v2(30.71,47.52) 30.47,47.76 26.24,47.76 26,47.52 24.79,47.52 24.26,47 23.01,47 22.81,47.2 21.66,47.2 21.1,47.76 21.1,48.57 20.47,49.2 20.47,56.31 19.3,57.49 15.27,57.49 14.79,57.97 v2(14.79,59.34)
  BOTTOM w0.203: UT11.L10 30.73,47.5 v2(30.71,47.52)
  BOTTOM w0.254: v2(30.71,47.52) 30.55,47.68 30.55,48.84 30.74,49.03 RT198.2
  BOTTOM w0.381: v2(14.79,59.34) 14.89,59.44 15.87,59.44 17.37,60.94 17.37,63.53 15.7,65.2 15.7,66.14 14.75,67.09 14.14,67.09 DT44.5 DT44.6 11.41,67.16 10.84,67.73 7.92,67.73 7.54,67.35 v2(6.75,67.35) ; CT154.1 31.03,49.03 RT198.2
TBTB_DBG_CTL1: length 7.3
  TOP w0.086: v1(25.04,40.5) 24.88,40.34 v2(24.12,40.34) 23.97,40.34 RT199.1
  IN4 w0.051: v2(24.12,40.34) 24.12,40.56 25.61,42.05 26.03,42.05 26.92,42.93 27.2,42.93 v4(27.2,42.94)
  GND5 w0.086: v5(27.73,43.62) 27.73,43.47 v4(27.2,42.94)
TBTB_DBG_CTL2: length 5.9
  TOP w0.086: v2(27.72,42.61) 27.61,42.61 26.81,41.8 26.81,41.78 26.74,41.72 v1(26.74,41.09) 26.43,40.79 26.38,40.79 25.25,39.66 RT200.1
  BOTTOM w0.086: v2(27.72,42.61) UT11.D5
TBTB_DC_SS: length 42.6
  TOP w0.508: PD904.2 68.52,32.72 v2(69.08,32.72)
  IN1 w0.508: v4(45.03,34.53) 45.03,36.66 44.52,37.17 44.52,40.09 45.03,40.6 46.4,40.6 47.24,41.44 47.24,42.16 48.31,43.22 48.31,44.48 46.58,46.21
  IN4 w0.508: v4(45.03,34.53) 45.03,34.04 48.11,30.96 58.98,30.96 59.35,31.33 65.27,31.33 65.57,31.02 67.38,31.02 v2(69.08,32.72)
  vias: v1(47.26,46.83) v2(45.94,47.56) v2(45.94,46.97) v2(46.53,47.56) v2(46.53,46.97)
TBTB_DEBUG1: length 2.9
  BOTTOM w0.086: RT188.2 24.63,47.56 25.19,47 26.43,47 26.73,46.7 UT11.L2
TBTB_DEBUG2: length 12.3
  TOP w0.086: RT189.2 24.86,36.2 23.98,37.08 v1(23.98,37.55) 23.98,37.77 v3(24.45,38.24)
  GND1 w0.086: v3(24.45,38.24) v4(24.45,38.82)
  IN4 w0.051: v4(26.71,42.15) 26.71,42.07 26.54,41.89 25.67,41.89 24.86,41.08 24.86,39.33 24.44,38.91 24.44,38.83 v4(24.45,38.82)
  GND5 w0.086: v4(26.71,42.15) 27.04,42.48 v5(27.07,42.48)
  BOTTOM w0.086: UT11.K2 27.07,45.79 v5(27.07,42.48)
TBTB_DEBUG3: length 1.2
  GND1 w0.086: v3(26.59,46.62) 26.64,46.62 27.09,47.08 v4(27.09,47.09)
  GND5 w0.086: v5(27.23,46.63) 27.23,46.93 27.09,47.07 v4(27.09,47.09)
TBTB_DEBUG4: length 3.3
  TOP w0.086: v3(26.24,44.6) 26.46,44.38 RT186.2
  GND1 w0.086: v4(26.88,44.63) 26.85,44.6 v3(26.24,44.6)
  GND5 w0.086: v4(26.88,44.63) 27.19,44.63 v5(27.4,44.84)
  BOTTOM w0.086: UT11.K3 27.23,46.02 27.4,45.86 v5(27.4,44.84)
TBTB_HPD: length 293
  TOP w0.086: v2(256.23,50.12) 255.38,50.12 DZ106.1
  IN1 w0.051: v2(92.98,33.82) 93.01,33.84 95.14,33.84 96.25,32.73 107.7,32.73 110.11,30.31 126.7,30.31 127.53,31.14 127.53,31.66 128.64,32.77 158.41,32.77 159.93,34.29 165.98,34.29 168.23,32.04 168.23,31.09 169.6,29.72 171.54,29.72 173.08,31.26 180.65,31.26 182.83,29.08 195.79,29.08 195.97,28.9 199.78,28.9 200.55,29.67 206.84,29.67 208.04,28.48 219.22,28.48 219.81,29.07 220.79,29.07 226.23,29.07 227.12,29.96 230.6,29.96 230.8,29.75 250.39,29.75 254.96,34.32 254.96,39.38 255.79,40.21 255.79,47.13 256.68,48.02 256.68,49.64 256.23,50.1 v2(256.23,50.12)
  IN3 w0.061: v2(32.71,62.19) 32.71,62.2 32.89,62.39 32.89,62.94 33.14,63.19 33.95,63.19 34.68,62.47 34.68,61.86 35.3,61.23 35.3,60.5 36.17,59.63 36.77,59.63 37.19,59.21 37.19,55.3 37.04,55.15 37.04,51.13 37.17,50.99 37.17,49.68 36.65,49.16 36.31,49.16 35.13,47.99 35.13,45.91 35.45,45.59 35.45,42.43 35.92,41.97 35.92,41.59 v4(35.55,41.22)
  GND5 w0.086: v5(36.39,40.86) 36.38,40.86 36.02,41.22 v4(35.55,41.22)
  BOTTOM w0.086: v2(32.71,62.19) 32.71,62.2 33.01,62.5 UT1.M4 ; v2(92.98,33.82) 92.98,31.99 91.79,30.79 71.26,30.79 70.27,29.8 67.15,29.8 66.67,30.29 66.67,33.64 66.31,33.99 64.79,33.99 61.87,31.08 46.12,31.08 45.27,31.94 45.27,33.78 44.82,34.22 44.82,39.06 43.35,40.53 40.08,40.53 38.61,42 38.14,42 37.9,41.75 37.9,41.12 RT33.1 RT169.2 36.39,40.85 v5(36.39,40.86)
TBTB_HPD_R: length 7.4
  BOTTOM w0.076: 32,42.96 31.57,43.38 30.59,43.38 30.47,43.27 30.47,42.88 UT11.C10
  BOTTOM w0.086: 32,42.96 32.57,42.39 34.07,42.39 34.46,42 34.46,41.41 v1(34.52,41.35) 35.15,40.73 RT169.1
TBTB_I2C_INT: length 52
  TOP w0.086: v3(32.17,63.92) 32.03,63.78 RT409.2
  GND1 w0.086: v4(32.66,63.59) 32.33,63.92 v3(32.17,63.92)
  IN1 w0.051: v4(30.26,69.13) 30.57,69.13 33,66.71 33,63.93 v4(32.66,63.59)
  IN2 w0.061: v4(25.16,42.68) 25.16,41.82 24.32,40.97 23.15,40.97 22.97,41.16 21.86,41.16 20.2,42.82 20.12,42.82 19.45,43.49 19.45,48.75 19.92,49.22 19.92,64.82 24.61,69.51 27.06,69.51 28.02,68.55 29,68.55 29.58,69.13 v4(30.26,69.13)
  GND5 w0.086: v4(25.16,42.68) 25.6,42.68 v5(25.65,42.62)
  BOTTOM w0.086: UT11.C1 v5(25.65,42.62)
TBTB_I2C_INT_R: length 1.4
  GND1 w0.086: v4(31.72,63.22) 31.56,63.06 v3(31.12,63.06)
  GND5 w0.086: v4(31.72,63.22) 31.73,63.21 v5(31.73,62.5)
TBTB_LSRX: length 34.4
  TOP w0.088: v3(28.74,43.14) 28.47,43.42 RT184.1 RT186.1 ; v3(29.27,61.69) 29.18,61.6 RT32.1
  GND1 w0.088: v3(29.27,61.69) 29.22,61.69 v4(28.89,62.03) ; v4(29.25,43.14) 29.25,43.14 v3(28.74,43.14)
  IN3 w0.083: v4(29.25,43.14) 29.25,44.68 31.81,47.24 33.59,47.24 36.09,49.74 36.43,49.74 36.6,49.91 36.6,50.76 34.23,53.14 34.23,59.53 33.6,60.16 33.6,61.45 33.37,61.68 32.61,61.68 32.28,62.01 32.28,62.59 32.19,62.68 31.07,62.68 30.98,62.59 29.31,62.59 28.95,62.23 28.95,62.09 v4(28.89,62.03)
  GND5 w0.088: v4(28.89,62.03) 28.84,61.98 28.26,61.98 v5(27.97,62.27)
TBTB_LSRX_R: length 2.9
  TOP w0.088: RT184.2 27.68,44.33 v3(27.68,44.93)
  GND1 w0.088: v3(27.68,44.93) 27.75,45 28.15,45 28.25,45.11 v4(28.25,45.12)
  GND5 w0.088: v4(28.25,45.12) 28.06,45.31 28.06,45.53 v5(28.03,45.55)
  BOTTOM w0.088: v5(28.03,45.55) 28.03,45.82 UT11.K4
TBTB_LSTX: length 35.1
  TOP w0.088: RT31.1 28.87,62.3 v3(28.4,61.83) ; v3(24.65,47.17) 24.69,47.2 RT183.1 RT185.1
  GND1 w0.088: v3(28.4,61.83) v4(28.78,61.45) ; v3(24.65,47.17) 24.65,47.87 v4(24.48,48.04)
  IN3 w0.083: v4(28.78,61.45) 28.95,61.63 30.65,61.63 31.26,61.02 32.17,61.02 32.45,61.29 33.01,61.29 33.21,61.1 33.21,60 33.84,59.37 33.84,53.65 32.61,52.42 32.61,50.99 33.28,50.31 33.28,48.63 v4(33.27,48.62)
  IN4 w0.062: v4(24.48,48.04) 24.82,47.7 25.91,47.7 26.28,48.08 28.01,48.08 28.17,47.92 28.89,47.92 29.15,48.18 29.15,48.83 29.34,49.02 32.88,49.02 v4(33.27,48.62)
  GND5 w0.088: v5(27.97,61.82) 28.34,61.45 v4(28.78,61.45)
TBTB_LSTX_R: length 2.7
  GND1 w0.088: v3(25.95,46.62) 25.95,46.67 v4(26.48,47.2)
  GND5 w0.088: v5(26.85,47.51) 26.8,47.51 v4(26.48,47.2)
  BOTTOM w0.088: UT11.L4 27.73,46.82 27.04,47.51 v5(26.85,47.51)
TBTB_MRESET: length 2.4
  TOP w0.086: v3(31.72,44.48) 31.06,45.14 RT182.1
  GND1 w0.086: v3(31.72,44.48) 31.69,44.48 31.69,44.03 v4(31.62,43.95)
  GND5 w0.086: v5(31.23,43.62) 31.29,43.62 v4(31.62,43.95)
TBTB_RESET_N_EC_R: length 5
  BOTTOM w0.086: RT203.1 35.04,43.06 32.73,43.06 31.67,44.12 UT11.F11
TBTB_ROM_CLK_PD: length 25.3
  IN4 w0.051: v4(26.62,40.76) 26.52,40.67 26.52,39.98 27.13,39.37 29.35,39.37 32.54,42.55 32.54,43.61 34.64,45.7 35.29,45.7 35.62,45.37 37.76,45.37 41.09,48.7 v4(42.24,48.7)
  GND5 w0.086: v4(26.62,40.76) 26.62,40.82 v5(26.98,41.18) ; v5(42.35,48.23) 42.35,48.6 v4(42.24,48.7)
  BOTTOM w0.086: UT11.A3 27.02,41.41 27.02,41.22 v5(26.98,41.18) ; v5(42.35,48.23) 42.68,48.57 43.69,48.57 44.06,48.19 RT54.1
TBTB_ROM_CLK_PD_R: length 1.7
  BOTTOM w0.086: UT6.6 42.75,47.72 RT54.2
TBTB_ROM_CS#_PD: length 28.2
  IN4 w0.051: v4(27.12,41.65) 26.76,41.65 26.19,41.08 26.19,39.72 26.7,39.21 29.42,39.21 32.69,42.49 32.69,43.54 34.7,45.55 35.22,45.55 35.55,45.22 37.83,45.22 40.93,48.32 42.4,48.32 42.62,48.54 42.62,50.37 v4(42.3,50.69)
  GND5 w0.086: v5(42.3,51.18) v4(42.3,50.69) ; v4(27.12,41.65) 27.23,41.76 v5(27.23,42.12)
  BOTTOM w0.086: v5(42.3,51.18) 42.3,51.43 42.65,51.79 RT57.1
TBTB_ROM_CS#_PD_R: length 12.7
  BOTTOM w0.086: RT51.1 43.96,50.39 43.48,50.87 RT57.2 42.63,50.87 42.2,50.44 40.81,50.44 38.94,48.58 38.94,48.16 36.66,45.88 35.91,45.88 35.21,45.18 UT6.1
TBTB_ROM_DI_PD: length 24.7
  IN4 w0.051: v4(27.73,41.56) 27.63,41.56 27.04,40.98 27.04,40.57 28.1,39.52 29.29,39.52 32.39,42.62 32.39,43.67 34.57,45.86 35.35,45.86 35.67,45.53 37.71,45.53 41.7,49.53 v4(42.23,49.53)
  GND5 w0.086: v5(27.73,42.12) v4(27.73,41.56) ; v5(42.71,49.53) v4(42.23,49.53)
  BOTTOM w0.086: RT55.1 44.06,49.17 43.71,49.53 v5(42.71,49.53)
TBTB_ROM_DI_PD_R: length 1.6
  BOTTOM w0.086: UT6.5 43.12,48.99 RT55.2
TBTB_ROM_DO_PD: length 23.7
  IN4 w0.051: v4(27.43,40.73) 27.43,40.56 28.33,39.67 29.23,39.67 32.24,42.68 32.24,43.73 34.51,46.01 35.41,46.01 35.74,45.68 37.64,45.68 41.39,49.44 41.39,50.85 v4(42.23,51.69)
  GND5 w0.086: v4(27.43,40.73) 27.43,41.15 v5(27.37,41.21) ; v5(41.7,51.79) 42.13,51.79 v4(42.23,51.69)
  BOTTOM w0.086: v5(27.37,41.21) 27.73,41.57 UT11.A4
TBTB_ROM_DO_PD_R: length 9.5
  BOTTOM w0.086: RT56.2 40.91,50.87 RT52.1 40.91,50.85 38.73,48.67 38.73,48.25 36.93,46.45 UT6.2
TBTB_ROM_HOLD#_PD: length 6.6
  BOTTOM w0.086: UT6.7 42.45,46.45 42.64,46.26 42.64,44.57 42.4,44.33 41,44.33 40.76,44.09 40.76,43.51 40.16,42.91 RT50.1
TBTB_ROM_WP#_PD: length 7.5
  BOTTOM w0.086: RT53.1 39.73,50.58 39.73,49.97 38.52,48.76 38.52,48.48 37.76,47.72 UT6.3
TBTB_ROSC: length 5.4
  BOTTOM w0.076: UT11.G2 26.57,44.62 26.33,44.87 26.13,44.87 25.54,44.87
  BOTTOM w0.086: 25.54,44.87 24.45,44.87 23.82,45.5 v1(22.78,45.5) 22.17,45.5 RT194.1
TBTB_RX1N: length 36
  TOP w0.156: v2(6.71,70.06) 6.71,70.06 arc(6.58,69.99) 6.43,70 6.24,70.07 JUSBC2.B10 ; v2(27.07,53.48) 27.03,53.51 arc(26.89,53.61) 26.71,53.64 26.56,53.64 arc(26.35,53.69) 26.18,53.8 25.71,54.27 arc(25.53,54.54) 25.47,54.85 arc(25.25,55.94) 24.63,56.87 23.24,58.26 arc(22.91,58.76) 22.79,59.35 22.79,63.73 arc(22.78,63.87) 22.72,63.99 21.81,65.66 arc(21.16,66.8) 20.49,67.93 arc(19.9,68.86) 19.29,69.78 19.12,70.04 arc(19.09,70.07) 19.06,70.1 18.71,70.48 18.35,70.86 arc(18.32,70.89) 18.29,70.91 17.42,71.6 arc(17.39,71.62) 17.36,71.63 17.01,71.85 arc(16.92,71.89) 16.82,71.91 16.59,71.91 arc(16.57,71.91) 16.55,71.91 arc(16.36,71.86) v2(16.18,71.78)
  BOTTOM w0.076: v2(27.07,53.48) 27.07,53.54 27.27,53.74 27.34,53.81 arc(27.37,53.83) 27.4,53.83 27.76,54.2 arc(27.78,54.22) 27.8,54.22 arc(27.87,54.24) 27.93,54.25 28.02,54.25 arc(28.05,54.25) 28.07,54.27 28.1,54.29 arc(28.12,54.4) 28.03,54.46 UT1.A21
  BOTTOM w0.156: v2(6.71,70.06) 6.73,70.07 arc(6.81,70.15) 6.91,70.2 7.11,70.25 arc(7.15,70.25) 7.19,70.26 7.31,70.26 arc(7.7,70.33) 8.04,70.56 8.98,71.5 arc(9.25,71.68) 9.57,71.74 12.5,71.74 arc(12.8,71.66) DT31.1 13.15,71.64 arc(13.25,71.73) 13.37,71.76 14.38,71.76 arc(14.53,71.79) 14.66,71.87 14.66,71.88 arc(14.71,71.92) 14.77,71.95 arc(14.83,71.97) 14.9,71.98 15.92,71.98 arc(15.98,71.97) 16.03,71.93 v2(16.18,71.78)
TBTB_RX1P: length 36
  TOP w0.156: v2(27.07,54.06) 27.02,54.01 arc(26.88,53.92) 26.71,53.88 26.56,53.88 arc(26.45,53.91) 26.35,53.97 25.88,54.44 arc(25.75,54.63) 25.71,54.85 arc(25.47,56.03) 24.8,57.04 23.41,58.43 arc(23.13,58.85) 23.03,59.35 23.03,63.73 arc(23.01,63.93) 22.93,64.11 22.02,65.77 arc(20.8,67.87) 19.49,69.92 19.49,69.92 19.31,70.17 arc(19.28,70.22) 19.24,70.27 18.52,71.02 arc(18.48,71.06) 18.44,71.1 17.56,71.79 arc(17.53,71.81) 17.49,71.84 17.14,72.06 arc(16.99,72.12) 16.82,72.14 16.59,72.14 arc(16.35,72.2) v2(16.18,72.37) ; JUSBC2.B11 6.55,70.57 arc(6.64,70.59) v2(6.71,70.64)
  BOTTOM w0.076: v2(27.07,54.06) 27.08,54.05 arc(27.2,53.99) 27.32,54.01 arc(27.36,54.03) 27.39,54.05 27.54,54.2 arc(27.56,54.24) 27.57,54.28 27.57,54.44 arc(27.59,54.52) 27.63,54.59 27.7,54.66 arc(27.76,54.69) 27.82,54.71 27.96,54.71 arc(28.17,54.67) 28.35,54.55 UT1.B21
  BOTTOM w0.156: v2(16.18,72.37) 16.1,72.29 arc(16.02,72.24) 15.92,72.22 14.9,72.22 arc(14.68,72.17) 14.49,72.05 14.49,72.04 arc(14.44,72.01) 14.38,72 13.36,72 arc(13.17,72.03) DT30.1 arc(12.76,72.02) 12.5,71.98 9.57,71.98 arc(9.16,71.9) 8.81,71.67 7.87,70.73 arc(7.61,70.55) 7.31,70.49 7.28,70.49 arc(7.24,70.49) 7.19,70.5 7.16,70.5 7.12,70.5 arc(7.03,70.52) 6.93,70.54 6.84,70.57 arc(6.77,70.6) v2(6.71,70.64)
TBTB_RX2N: length 26.2
  TOP w0.156: JUSBC2.A10 8.09,66.32 arc(8.17,66.31) 8.23,66.27 8.26,66.24 arc(8.32,66.2) 8.4,66.19 8.73,66.19 arc(9.03,66.13) 9.28,65.96 10.33,64.91 arc(10.91,64.52) 11.59,64.39 12.38,64.39 arc(12.71,64.45) DT26.1 13.13,64.51 arc(13.19,64.47) 13.26,64.46 15.15,64.46 arc(15.22,64.47) 15.29,64.51 15.33,64.56 arc(15.56,64.71) 15.83,64.77 16.44,64.77 arc(17.17,64.62) 17.78,64.21 18.66,63.34 arc(19.28,62.92) 20.01,62.78 20.39,62.78 arc(20.63,62.82) v2(20.83,62.96)
  BOTTOM w0.076: UT1.B15 28.42,57.22 28.35,57.3 arc(28.16,57.42) 27.94,57.47 27.89,57.47 arc(27.8,57.45) 27.72,57.4 27.71,57.39 arc(27.64,57.33) 27.55,57.29 arc(27.5,57.28) 27.44,57.27 27.2,57.27 27.16,57.31 27.14,57.31
  BOTTOM w0.156: 27.14,57.31 25.81,57.31 arc(24.6,57.55) 23.58,58.23 23.54,58.27 arc(23.16,58.84) 23.03,59.51 23.03,60.08 arc(22.77,61.39) 22.03,62.51 21.98,62.55 arc(21.74,62.71) 21.45,62.77 21.17,62.77 arc(21.03,62.8) 20.91,62.88 v2(20.83,62.96)
TBTB_RX2P: length 26.2
  TOP w0.156: JUSBC2.A11 8.13,65.82 arc(8.2,65.84) 8.25,65.88 8.27,65.9 arc(8.33,65.93) 8.39,65.95 8.73,65.95 arc(8.94,65.91) 9.11,65.79 10.16,64.74 arc(10.82,64.3) 11.59,64.15 12.71,64.15 arc(12.77,64.14) 12.82,64.1 DT27.1 13.14,64.07 arc(13.3,64.18) 13.49,64.22 15.15,64.22 arc(15.31,64.25) 15.46,64.35 15.5,64.39 arc(15.65,64.49) 15.83,64.53 16.44,64.53 arc(17.08,64.4) 17.61,64.04 18.49,63.17 arc(19.18,62.7) 20.01,62.54 20.43,62.54 arc(20.65,62.5) v2(20.83,62.37)
  BOTTOM w0.076: UT1.A15 28.08,57.22 arc(28.15,57.2) 28.17,57.14 28.17,57.12 arc(28.15,57.06) 28.11,57.02 arc(28.07,57.01) 28.04,57.01 27.91,57.01 arc(27.82,57.02) 27.74,57.06 arc(27.72,57.07) 27.7,57.09 arc(27.69,57.09) 27.69,57.09 27.69,57.09 arc(27.52,57.11) 27.35,57.12 27.2,57.12 27.16,57.08 27.14,57.08
  BOTTOM w0.156: v2(20.83,62.37) 20.86,62.41 arc(21,62.5) 21.17,62.53 21.45,62.53 arc(21.65,62.5) 21.81,62.38 21.86,62.34 arc(22.55,61.3) 22.79,60.08 22.79,59.51 arc(22.94,58.75) 23.37,58.11 23.41,58.07 arc(24.51,57.33) 25.81,57.08 27.14,57.08
TBTB_SBU1: length 41.6
  TOP w0.088: v3(27.67,46.67) RT201.2 ; v2(13.56,66.32) DT43.1 DT43.9 11.46,67.03 10.71,67.78 8.42,67.78 7.97,67.32 JUSBC2.A8
  GND1 w0.088: v3(27.67,46.67) 27.72,46.62 v4(27.72,46.11)
  IN2 w0.083: v2(13.56,66.32) 13.6,66.36 13.6,67.22 14.05,67.67 15.25,67.67 15.58,67.34 15.58,64.94 14.72,64.09 14.72,60.32 v4(14.79,60.26)
  IN4 w0.062: v4(27.72,46.11) 27.37,46.47 24.86,46.47 24.5,46.82 22.92,46.82 22.74,47 21.64,47 20.79,47.85 20.79,48.51 20.28,49.02 20.28,54.26 15.51,59.02 15.51,59.53 v4(14.79,60.26)
  BOTTOM w0.088: v2(13.56,66.32) 13.97,66.32 v1(14.05,66.24)
TBTB_SBU1_R: length 3.4
  TOP w0.088: RT201.1 28.28,46.66 27.81,46.19 v3(27.81,45.63)
  GND1 w0.088: v4(28.57,45.63) 27.81,45.63 v3(27.81,45.63)
  GND5 w0.088: v5(29.02,45.81) 28.74,45.81 v4(28.57,45.63)
  BOTTOM w0.088: UT11.K8 29.62,46.13 29.3,45.81 v5(29.02,45.81)
TBTB_SBU2: length 48.4
  TOP w0.088: v2(6.7,69.1) 6.67,69.07 JUSBC2.B8
  IN4 w0.062: v4(16.13,58.95) 16.13,58.92 20.65,54.41 20.65,49.27 21.2,48.71 21.2,47.96 21.79,47.37 22.9,47.37 23.07,47.19 24.18,47.19 24.33,47.34 26.06,47.34 26.43,47.71 27.86,47.71 28.02,47.55 29.04,47.55 29.57,48.08 29.57,48.6 v4(29.56,48.61)
  GND5 w0.088: v4(29.56,48.61) 29.16,49.01 v5(29.07,49.01) ; v4(16.13,58.95) v5(16.48,59.29)
  BOTTOM w0.088: v2(6.7,69.1) 7,68.8 11.05,68.8 11.41,69.16 DT44.9 DT44.1 14.07,69.43 14.36,69.72 17.71,69.72 19,68.42 19,61.82 v6(17.97,60.78) v5(16.48,59.29)
TBTB_SBU2_R: length 1.8
  BOTTOM w0.088: RT202.1 29.81,47.35 29.81,46.71 UT11.L8
TBTB_TOP_N: length 30.9
  TOP w0.088: v2(18.06,66.91) 17.85,67.12 16.97,67.12 16.79,67.3 16.79,67.55 16.35,67.99 15.83,67.99 RT215.1
  IN3 w0.083: v2(28.7,47.16) 28.72,47.16 28.98,47.43 28.98,47.52 28.9,47.6 28.06,47.6 27.39,48.27 27.39,50.41 25.78,52.02 25.78,55.73 21.66,59.85 21.66,64.79 19.14,67.31 18.58,67.31 18.49,67.23 18.49,66.99 18.41,66.91 v2(18.06,66.91)
  BOTTOM w0.076: UT11.L6 28.74,46.63 28.81,46.7 28.81,46.78 29.05,47.01 29.05,47.31 28.98,47.38 28.82,47.38 28.7,47.25 v2(28.7,47.16)
TBTB_TOP_N_R: length 7.3
  TOP w0.088: JUSBC2.A7 7.93,67.82 8.07,67.97 11.95,67.97 12.39,67.53 DT43.8 DT43.2 14.45,67.53 RT215.2
TBTB_TOP_P: length 30.9
  TOP w0.088: RT214.1 15.86,68.16 16.42,68.16 16.96,67.62 16.96,67.37 17.04,67.29 17.86,67.29 v2(18.06,67.49)
  IN3 w0.083: v2(18.06,67.49) 19.22,67.49 21.84,64.87 21.84,59.93 25.97,55.8 25.97,52.1 27.58,50.49 27.58,48.35 28.14,47.79 28.98,47.79 29.17,47.6 29.17,47.42 29.41,47.18 v2(29.44,47.18)
  BOTTOM w0.076: v2(29.44,47.18) 29.4,47.18 29.21,46.98 29.21,46.95 28.97,46.71 28.97,46.37 UT11.K6
TBTB_TOP_P_R: length 7.3
  TOP w0.088: JUSBC2.A6 7.96,68.32 8.13,68.14 11.88,68.14 12.27,68.53 DT43.7 DT43.4 14.56,68.53 RT214.2
TBTB_TX1N: length 3.4
  BOTTOM w0.076: 27.33,55.35 27.36,55.35 27.4,55.39 27.47,55.39 arc(27.53,55.38) 27.58,55.35 27.62,55.31 arc(27.65,55.29) 27.67,55.27 arc(27.78,55.19) 27.92,55.17 28.06,55.17 arc(28.2,55.19) 28.31,55.27 UT1.B19
  BOTTOM w0.156: 27.33,55.35 27.04,55.35 arc(26.97,55.34) 26.92,55.33 26.88,55.31 arc(26.82,55.28) 26.78,55.24 26.65,55.11 arc(26.61,55.06) 26.58,55.01 26.42,54.68 arc(26.36,54.59) 26.29,54.5 26.28,54.49 arc(26.15,54.4) 26,54.37 arc(26,54.37) 26,54.37 arc(25.82,54.32) CT160.1
TBTB_TX1N_C: length 30.5
  TOP w0.156: v2(24.57,54.24) 24.54,54.27 arc(24.39,54.37) 24.21,54.41 24.12,54.41 arc(23.77,54.55) 23.63,54.9 23.63,55.34 arc(23.42,56.41) 22.81,57.33 22.43,57.7 arc(21.98,58.37) 21.83,59.16 21.83,63.01 arc(21.76,63.55) 21.56,64.06 21.28,64.55 19.12,68.23 arc(18.96,68.46) 18.78,68.66 18.42,69.03 arc(18.22,69.18) 17.98,69.27 16.43,69.57 arc(15.7,69.82) 15.09,70.28 15.08,70.29 arc(14.98,70.45) 14.91,70.62 14.82,71.06 arc(14.77,71.2) 14.67,71.33 14.5,71.5 arc(14.39,71.58) 14.25,71.6 13.24,71.6 arc(13.18,71.59) 13.13,71.56 DT23.1 12.8,71.62 12.75,71.65 arc(12.72,71.66) 12.68,71.67 10.93,71.67 arc(10.71,71.62) 10.52,71.5 9.32,70.3 arc(9.09,70.14) 8.81,70.09 8.3,70.09 arc(8.24,70.08) 8.19,70.04 8.02,69.87 arc(7.97,69.84) 7.91,69.82 JUSBC2.A3
  BOTTOM w0.156: CT160.2 25.11,54.2 arc(25.06,54.33) 24.93,54.38 24.79,54.38 arc(24.72,54.37) 24.66,54.33 v2(24.57,54.24)
TBTB_TX1P: length 3.4
  BOTTOM w0.076: 27.33,55.59 27.36,55.59 27.4,55.55 27.64,55.55 arc(27.66,55.55) 27.68,55.55 arc(27.68,55.55) 27.69,55.56 arc(27.72,55.57) 27.74,55.59 27.74,55.59 arc(27.78,55.62) 27.83,55.63 28.06,55.63 arc(28.19,55.5) 28.06,55.38 27.98,55.38 UT1.A19
  BOTTOM w0.156: 27.33,55.59 27.04,55.59 arc(26.93,55.58) 26.82,55.55 26.79,55.53 arc(26.69,55.48) 26.61,55.41 26.48,55.28 arc(26.41,55.2) 26.36,55.11 26.2,54.79 arc(26.17,54.72) 26.12,54.67 26.11,54.66 arc(26.01,54.61) 25.91,54.64 25.7,54.79 CT159.1
