# Allegro board LAF292PR10-1114.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 278.33,91.41 278.7,90.5 278.7,89.6 261.31,89.6 261.31,91.8 277.43,91.8
GND on BOTTOM (solid shape): 65.65,66.19 65.64,66.08 65.63,65.99 65.63,65.81 65.63,65.62 65.65,65.37 65.68,65.12 65.85,64.46 66.11,63.84 66.2,63.67 66.3,63.51 66.3,63.01 66.24,62.95 64.69,62.95 64.56,63.08 64.56,66.13 64.69,66.25 65.59,66.25
GND on BOTTOM (solid shape): 299.36,39.35 299.54,39.35 299.57,39.34 299.69,39.28 299.83,39.26 300.34,39 300.55,38.47 300.55,38.05 286.45,38.05 286.45,38.06 286.05,38.06 285.92,38.19 285.92,39.58 286.05,39.71 299,39.71
GND on BOTTOM (solid shape): 20.6,29.28 29.17,29.28 29.17,21.24 27.97,21.24 27.97,28.08 19.89,28.08 17.69,32.08 8.5,32.08 8.5,33.28 18.4,33.28
GND on BOTTOM (solid shape): 63.1,76.73 63.1,76.09 63.1,75.03 62.65,74.59 62.65,73.63 63.03,73.26 63.03,71.72 62.65,71.35 62.65,70.33 63.16,69.82 63.16,69.31 63.03,69.19 62.76,69.19 62.35,69.59 62.35,70.2 62.4,70.25 62.4,71.41 62.27,71.54 61.92,71.54 61.57,71.88 61.57,73.14 61.94,73.5 61.94,74.53 61.51,74.97 60.32,74.97 60.11,74.76 58.97,74.76 58.84,74.89 58.84,76.67 59.22,77.05 62.78,77.05
GND on BOTTOM (solid shape): 53.56,76.62 53.56,76.34 53.41,76.18 53.17,76.18 52.89,75.9 52.89,74.08 52.37,73.55 52.37,72.06 52.81,71.61 52.81,70.6 52.37,70.15 52.37,69.01 53.56,67.81 53.56,67.67 53.41,67.52 53.09,67.52 52.05,68.56 52.05,68.84 52.11,68.9 52.11,70.15 51.67,70.6 51.67,72.25 51.67,72.25 51.67,73.05 51.22,73.49 51.1,73.49 50.97,73.62 50.97,75.27 52.39,76.69 53.48,76.69
GND on BOTTOM (solid shape): 241.49,56.41 241.49,56.08 241.4,55.99 237.31,55.99 236.63,55.31 236.63,52.63 237.09,52.16 239.1,52.16 239.23,52.29 239.23,53.41 239.16,53.47 238.71,53.47 238.61,53.57 238.61,54.85 238.91,55.15 239.23,55.15 239.58,54.81 241.39,54.81 241.49,54.71 241.49,54.51 241.31,54.33 240.31,54.33 239.67,53.69 239.67,52.09 239.23,51.64 236.64,51.64 236.01,52.28 236.01,55.51 237.12,56.62 241.28,56.62
GND on BOTTOM (solid shape): 32.88,74.65 32.88,74.45 32.64,74.21 32.64,74.21 32.58,74.17 32.54,74.11 32.53,74.1 32.37,73.94 32.37,72.92 32.24,72.8 31.23,72.8 31.14,72.71 31.14,72.71 31.08,72.67 31.04,72.61 31.03,72.6 30.74,72.31 30.68,72.29 30.47,72.29 30.34,72.42 30.34,72.8 30.97,73.43 30.97,74.19 30.85,74.32 30.59,74.32 30.47,74.45 30.47,74.63 30.54,74.7 32.83,74.7
GND on BOTTOM (solid shape): 292.5,76.48 286.02,76.48 286.02,61.53 292.5,61.53 292.5,60.33 284.82,60.33 284.82,77.67 292.5,77.67
GND on BOTTOM (solid shape): 238.55,48.73 238.55,47.2 238.8,46.95 239.69,46.95 239.82,46.82 239.82,46.69 239.69,46.57 239.56,46.57 238.93,45.93 238.93,38.49 238.63,38.18 234.82,38.18 234.31,38.7 234.31,39.84 233.87,40.71 233.76,41.68 233.58,41.86 233.58,44.65 231.2,47.04 231.2,48.32 231.22,48.35 232.83,48.35 233.47,47.71 234.87,47.71 234.87,46.82 235.12,46.57 236.9,46.57 237.28,46.95 237.28,48.73 237.41,48.85 238.42,48.85
GND on BOTTOM (solid shape): 77.18,49.92 77.18,48.81 76.92,48.55 76.92,48.19 77.18,47.93 77.18,47.04 76.6,46.46 76.54,46.42 76.48,46.37 75.69,46.37 75.36,46.7 74.72,46.7 74.21,46.19 74.21,45.32 74.62,44.92 74.62,43.54 74.21,43.14 74.21,42.27 74.24,42.25 74.24,42.22 74.52,41.94 74.52,41.66 74.36,41.51 74.11,41.51 73.96,41.67 73.96,43.01 73.96,43.04 73.53,43.47 73.53,45.29 73.5,45.32 73.5,45.37 73.51,45.38 73.51,45.39 73.5,45.4 73.5,48.08 74,48.57 74,49.53 74.46,50 77.11,50
GND on BOTTOM (solid shape): 165.65,32.62 165.73,32.53 166.99,32.53 167.38,32.14 169.04,32.14 169.21,31.97 169.21,31.4 169.06,31.26 166.85,31.26 166.33,31.78 165.84,31.78 165.81,31.8 163.95,31.8 163.95,32.09 163.76,32.28 162.65,32.28 162.54,32.17 162.54,32.17 162.44,32.06 162.42,32.06 162.22,31.96 162.12,31.76 162.12,31.75 161.88,31.5 161.74,31.5 161.58,31.66 161.58,31.97 162.15,32.53 163.61,32.53 163.76,32.53 163.95,32.71 163.95,33.5 165.65,33.5
GND on BOTTOM (solid shape): 92.5,61.82 92.5,60.7 92.44,60.64 91.91,60.64 91.84,60.56 91.8,60.56 91.8,60.52 91.8,60.52 91.8,60.01 91.8,60.01 91.8,59.95 92.64,59.95 92.64,59.97 93.47,59.97 93.98,60.49 94.53,60.49 94.56,60.46 94.56,59.93 94.48,59.85 93.95,59.85 93.73,59.64 92.65,59.64 92.5,59.48 92.5,58.29 92.43,58.23 91.4,58.23 91.39,58.22 91.27,58.22 90.98,57.93 90.98,57.29 90.9,57.2 90.74,57.2 90.64,57.3 90.64,58.08 90.8,58.24 90.8,59.54 90.66,59.68 90.65,59.68 90.55,59.78 87.91,59.78 86.94,58.81 81.67,58.81 80.9,58.23 80.79,58.17 80.74,58.24 79.29,60.11 79.39,60.2 81.67,61.92 82.43,61.02 82.48,60.96 83.56,60.96 83.61,60.96 87.2,60.96 87.68,61.44 87.68,61.82 87.78,61.92 92.4,61.92
GND on BOTTOM (solid shape): 28.53,45.13 28.53,45.08 28.61,44.96 28.74,44.92 28.77,44.92 28.77,44.92 29.25,44.92 29.27,44.93 29.38,44.98 29.43,45.08 29.43,45.1 29.63,45.3 30.3,45.3 30.49,45.11 30.49,44.4 30.48,44.4 30.48,43.68 30.27,43.46 30.27,42.78 29.86,42.38 29.86,41.99 29.82,41.95 29.82,41.5 29.81,41.49 29.15,41.49 29.14,41.5 29.14,41.95 29.1,41.99 29.1,42.2 29.51,42.6 29.51,43.14 29.25,43.39 28.11,43.39 27.98,43.52 27.98,44.92 27.91,44.99 27.68,44.99 27.6,45.07 27.6,45.22 27.68,45.3 28.36,45.3
GND on BOTTOM (solid shape): 81.11,70.04 81.11,69.04 81.53,68.63 87.62,68.63 87.76,68.48 87.76,67.34 87.75,67.33 87.18,67.33 87.11,67.25 87.11,66.73 87.2,66.64 87.96,66.64 88.03,66.71 88.83,66.71 89.01,66.89 89.01,67.13 89.2,67.32 89.83,67.32 89.86,67.3 89.86,66.72 89.83,66.7 89.24,66.7 88.91,66.37 88.07,66.37 87.81,66.11 87.81,64.99 87.69,64.87 86.42,64.87 86.31,64.75 86.31,63.39 86.43,63.27 86.43,61.35 86.35,61.27 85.78,61.27 85.71,61.35 85.71,63.31 85.99,63.59 85.99,64.82 86.09,64.92 86.09,66.27 86,66.37 83.69,66.37 83.35,66.71 81.7,66.71 81.54,66.87 80.04,66.87 79.82,66.65 79.23,66.65 78.04,67.84 76.55,67.84 72.39,63.69 70.43,63.69 70.08,63.34 67.21,63.34 66.33,64.22 66.33,67.63 67.33,68.63 76.05,68.63 76.52,69.1 77.33,69.1 78.4,70.16 80.99,70.16
GND on BOTTOM (solid shape): 202.73,46.85 205.49,46.85 205.9,46.44 205.9,46.2 203.28,44.19 203.28,40.84 203.13,40.69 199.55,38.92 197.97,42.58 197.97,47.8 198.29,48.12 201.46,48.12
GND on BOTTOM (solid shape): 97.54,85.66 97.54,81.98 97.23,81.67 94.8,81.67 93.99,82.47 93.99,83.29 93.86,83.42 92.33,83.42 92.23,83.33 92.23,81.57 92.38,81.42 93.17,81.42 94.53,80.06 94.53,77.26 93.73,76.46 93.44,76.46 93,76.03 93,76.02 92.8,75.82 92.8,72.25 92.74,72.19 91.62,72.19 91.57,72.24 91.57,72.87 91.51,72.93 91.09,72.93 90.91,72.75 90.91,70.9 91,70.81 91,70.06 90.88,69.94 90.46,69.94 90.43,69.98 90.43,70.66 90.6,70.84 90.6,71.95 90.44,72.12 89.31,72.12 89.23,72.21 89.23,73.33 88.97,73.58 88.16,73.58 87.61,73.03 86.94,73.03 86.9,73.06 86.9,73.58 87,73.68 87.65,73.68 87.87,73.9 89.05,73.9 89.11,73.84 90.56,73.84 90.71,73.99 90.71,76.42 91.11,76.83 91.63,76.83 92.8,78 92.8,80.42 92.74,80.48 92.74,80.47 84.66,80.47 82.17,77.98 80.13,77.98 80,78.11 80,83.18 88.76,83.18 88.76,81.65 89.04,81.37 90.93,81.37 91.07,81.52 91.07,83.29 90.93,83.43 89.01,83.43 88.76,83.18 80,83.18 80,84.67 81.18,85.85 97.35,85.85
GND on BOTTOM (solid shape): outline of 82 points within 22.4,32.22 26.33,39.07
GND on BOTTOM (solid shape): 179.45,88.15 179.46,87.93 179.52,87.72 179.65,87 179.52,86.27 179.46,86.07 179.45,85.85 179.45,84 177.48,84 174.5,87 177.48,90 179.45,90
GND on BOTTOM (solid shape): 139.01,66.63 139.11,66.57 139.08,66.46 139.05,66.42 138.99,66.42 138.81,66.24 138.8,66.24 138.63,65.88 139.02,65.84 139.11,65.8 139.11,65.68 139.06,65.54 139.1,65.4 139.11,65.39 139.11,65.37 139.06,65.28 138.96,65.28 138.77,65.29 138.62,65.17 138.62,65.16 138.42,64.99 138.36,64.99 138.33,64.98 138.24,65 138.21,65.08 138.21,65.51 138.06,65.65 138.03,65.73 138.07,65.81 138.17,65.97 138.12,66.15 138.12,66.53 138.22,66.63
GND on BOTTOM (solid shape): outline of 99 points within 40.6,34.31 52.08,43.35
GND on BOTTOM (solid shape): 86.15,94.57 86.15,89.83 86.09,89.74 85.98,89.75 85.71,89.83 85.47,89.69 85.38,89.65 85.3,89.69 85.11,89.83 84.87,89.82 84.63,89.7 84.55,89.44 84.55,89.42 84.5,89.37 84.37,89.49 84.37,91.04 84.4,91.11 84.47,91.14 85.03,91.07 84.94,91.64 84.76,91.81 84.51,91.81 84.41,91.82 84.37,91.91 84.37,94.57 84.63,94.83 85.9,94.83
GND on BOTTOM (solid shape): 57.47,39.52 57.56,39.47 57.55,39.37 57.85,38.82 58.15,39.37 58.15,39.47 58.24,39.52 61.27,39.52 61.56,39.24 61.56,37.29 61.42,37.14 58.86,37.14 58.23,36.92 58.86,36.69 61.56,36.69 61.56,34.78 61.17,34.39 54.93,34.39 54.09,35.23 54.09,38.19 55.08,39.17 55.11,39.16 55.45,39.18 55.62,39.47 55.62,39.52
GND on BOTTOM (solid shape): 100.97,72.95 100.97,72.62 101.06,72.53 101.23,72.53 101.42,72.47 101.61,72.52 101.62,72.53 101.68,72.53 101.77,72.62 101.77,72.75 101.78,72.83 101.77,72.95 101.88,73.05 102.13,73.05 102.24,72.95 102.24,72.53 103.36,72.53 103.4,72.49 103.4,71.88 103.38,71.87 102.42,71.87 102.18,71.63 102.18,70.39 101.98,70.19 101.7,70.19 101.65,70.2 101.61,70.24 101.62,70.42 101.61,70.6 101.45,70.77 101.26,70.77 101.06,70.77 100.92,70.63 100.92,70.5 100.91,70.42 100.92,70.25 100.88,70.21 100.82,70.19 100.53,70.19 100.49,70.2 100.45,70.24 100.45,70.59 100.26,70.77 99.9,70.77 99.87,70.81 99.86,70.86 99.86,72.48 99.9,72.53 99.96,72.53 99.98,72.52 100.16,72.47 100.34,72.52 100.35,72.53 100.39,72.53 100.52,72.65 100.52,72.98 100.59,73.05 100.87,73.05
GND on BOTTOM (solid shape): 131.67,64.69 131.65,64.65 131.39,64.61 131.29,64.42 131.24,64.34 131.16,64.33 131.06,64.34 130.96,64.32 130.93,64.31 130.85,64.38 130.85,64.4 130.62,64.66 130.37,64.42 130.33,64.34 130.24,64.33 130.16,64.34 130.07,64.33 129.98,64.34 129.94,64.42 129.69,64.66 129.46,64.4 129.46,64.38 129.38,64.31 129.35,64.32 129.25,64.34 129.16,64.33 129.07,64.34 129.03,64.42 128.92,64.61 128.65,64.65 128.63,64.69 128.63,64.77 131.67,64.77
GND on BOTTOM (solid shape): 193.84,44.03 193.84,41.64 193.44,41.23 192.97,41.23 192.97,41.51 192.35,42.14 186.57,42.14 185.93,41.5 184.59,41.5 184.13,41.96 182.62,41.96 182.59,41.98 182.56,42.07 182.62,42.14 182.79,42.53 182.48,42.81 182.42,42.84 182.39,42.9 181.89,43.2 181.77,42.63 181.8,42.59 181.76,42.55 181.76,42.09 182.41,41.44 183.92,41.44 184.38,40.99 186.14,40.99 186.78,41.62 188.9,41.62 188.97,41.59 189,41.51 188.99,41.44 188.93,41.39 188.89,41.38 187.63,41.38 187.53,41.28 186.86,41.28 186.7,41.12 186.68,41.12 186.45,41.03 186.33,40.82 186.32,40.78 183.81,40.78 183.38,41.21 183.38,41.3 182.57,41.3 182.57,41.28 181.93,41.28 181.88,41.33 181.86,41.36 181.42,41.79 181.42,42.97 181.4,43 181.4,43.52 182.11,44.23 193.64,44.23
GND on BOTTOM (solid shape): 299.09,1.5 298.73,0.62 297.85,0.26 294.64,0.26 294,0.2 293.36,0.26 291.05,0.26 290.52,0.47 290.3,1 290.3,3.11 290.3,3.12 290.3,4.88 290.3,4.89 290.3,6.25 289.3,7.26 288.29,6.25 288.29,1 288.08,0.47 287.55,0.26 283.95,0.26 281.5,0.25 280.62,0.62 280.25,1.5 280.25,8.09 298.59,8.09 298.59,8.36 299.09,8.36
GND on BOTTOM (solid shape): outline of 134 points within 247.44,32.98 260.01,35.77
GND on BOTTOM (solid shape): 129.06,77.9 129.13,77.9 129.23,77.87 129.33,77.89 129.36,77.89 129.43,77.82 129.5,77.82 129.59,77.73 129.72,77.71 129.79,77.68 129.82,77.61 129.83,77.57 129.79,77.54 129.74,77.54 129.62,77.53 129.52,77.46 129.46,77.33 129.49,77.18 129.5,77.15 129.48,77.11 129.45,77.08 129.43,77.06 129.4,77.04 129.36,77.05 129.24,77.08 129.12,77.05 129.09,77.04 129.06,77.06 128.99,77.12 128.9,77.14 128.67,77.14 128.58,77.12 128.51,77.06 128.48,77.04 128.45,77.05 128.33,77.08 128.21,77.05 128.17,77.04 128.14,77.06 128.12,77.08 128.09,77.11 128.07,77.15 128.09,77.2 128.14,77.25 128.22,77.26 128.52,77.3 128.64,77.58 128.65,77.61 128.76,77.71 128.78,77.71 128.91,77.74 129,77.85
GND on BOTTOM (solid shape): 152.95,81.39 152.95,81.15 153.07,81.03 153.07,80.95 153.24,80.74 153.49,80.87 153.56,80.94 153.65,80.91 153.7,80.86 153.68,80.82 153.63,80.7 153.65,80.57 153.66,80.54 153.62,80.5 153.54,80.47 153.47,80.5 153.19,80.57 153.05,80.31 153.02,80.23 152.95,80.19 152.78,80.19 152.69,80.25 152.59,80.26 152.51,80.29 152.47,80.37 152.47,80.43 152.53,80.43 152.54,80.43 152.74,80.45 152.83,80.63 152.83,80.72 152.71,80.91 152.38,80.88 152.32,80.98 152.32,81.02 152.38,81.11 152.71,81.09 152.83,81.28 152.83,81.42 152.92,81.42
GND on BOTTOM (solid shape): 155.5,81.33 155.6,81.31 155.63,81.27 155.66,81.17 155.59,81.1 155.46,80.65 155.91,80.78 155.98,80.85 156.08,80.83 156.5,80.41 156.46,80.36 156.29,80.18 155.76,80.18 155.75,80.23 155.32,80.38 155.48,79.95 155.55,79.92 155.58,79.85 155.58,79.78 155.52,79.73 155.44,79.7 155.36,79.74 155.22,79.85 155.05,79.83 155.02,79.82 154.85,79.98 154.85,80.05 154.95,80.15 154.99,80.21 155,80.28 155,80.43 155.05,80.44 155.27,80.72 154.98,80.94 154.96,80.94 154.9,80.99 155.01,81.1 155.05,81.09 155.28,81.08 155.43,81.26
GND on BOTTOM (solid shape): 131.8,78.53 131.87,78.53 131.97,78.51 132.08,78.52 132.11,78.53 132.18,78.45 132.25,78.45 132.35,78.38 132.48,78.36 132.56,78.34 132.6,78.25 132.59,78.22 132.59,78.18 132.6,78.12 132.63,78.06 132.63,77.93 132.01,77.31 131.96,77.31 131.91,77.33 131.84,77.34 131.78,77.32 131.7,77.27 131.68,77.23 131.64,77.18 131.58,77.14 131.51,77.14 131.42,77.12 131.34,77.06 131.28,77.02 131.21,77.04 131.08,77.08 130.95,77.05 130.91,77.04 130.88,77.06 130.82,77.12 130.73,77.14 130.5,77.14 130.41,77.12 130.34,77.06 130.31,77.04 130.28,77.05 130.16,77.08 130.04,77.05 130,77.02 129.97,77.06 129.95,77.13 129.98,77.19 130.05,77.27 130.08,77.26 130.37,77.32 130.48,77.6 130.51,77.68 130.59,77.71 130.75,77.75 130.84,77.88 130.89,77.94 130.97,77.94 130.99,77.93 131.1,77.92 131.2,77.95 131.23,77.96 131.29,77.92 131.29,77.9 131.47,77.72 131.71,77.79 131.74,78.06 131.5,78.19 131.43,78.21 131.39,78.28 131.39,78.31 131.4,78.36 131.45,78.37 131.52,78.36 131.58,78.37 131.68,78.41 131.74,78.49
GND on BOTTOM (solid shape): 142.59,64.84 142.64,64.83 142.66,64.78 142.65,64.58 142.76,64.42 142.79,64.35 142.76,64.27 142.64,64.02 142.75,63.78 142.79,63.7 142.75,63.63 142.68,63.23 143.06,63.08 143.14,63.08 143.31,62.89 143.5,62.89 143.55,62.88 143.56,62.83 143.56,62.79 143.52,62.72 143.44,62.7 143.25,62.64 143.17,62.46 143.17,62.44 143.11,62.39 143.09,62.41 142.78,62.38 142.64,62.09 142.62,62.05 142.57,62.04 142.52,62.05 142.36,62.16 142.35,62.18 142.2,62.38 141.96,62.41 141.87,62.42 141.83,62.49 141.74,62.65 141.48,62.72 141.44,62.79 141.44,62.83 141.5,62.88 141.53,62.88 141.83,63.1 141.56,63.35 141.48,63.37 141.44,63.44 141.44,63.47 141.51,63.53 141.53,63.53 141.83,63.75 141.55,64 141.48,64.02 141.43,64.11 141.51,64.18 141.54,64.18 141.7,64.2 141.81,64.32 141.86,64.37 141.94,64.37 142.21,64.4 142.36,64.64 142.36,64.66 142.56,64.83
GND on BOTTOM (solid shape): outline of 81 points within 286.81,42.95 300.75,64
GND on BOTTOM (solid shape): outline of 277 points within 28.49,29.29 65.7,38.95
GND on BOTTOM (solid shape): outline of 284 points within 207.86,41.21 222.03,49.39
GND on BOTTOM (solid shape): outline of 292 points within 105.43,24.94 145.81,28.64
GND on BOTTOM (solid shape): 299.75,28.2 300.28,27.98 300.49,27.45 300.49,18 300.28,17.47 299.75,17.25 295.35,17.25 294.46,16.89 294.09,16 294.09,13 294.46,12.11 295.35,11.74 298.35,11.74 298.88,11.53 299.09,11 299.09,1.5 298.73,0.62 297.85,0.26 291.05,0.26 290.52,0.47 290.3,1 290.3,6.25 289.3,7.26 288.29,6.25 288.29,1 288.08,0.47 287.55,0.26 281.5,0.26 280.62,0.62 280.25,1.5 280.25,23 279.89,23.89 279,24.26 273.97,24.26 273.97,24.76 279,24.76 280.25,24.25 280.76,23 280.76,1.5 280.98,0.98 281.5,0.76 287.55,0.76 287.72,0.83 287.79,1 287.79,6.25 289.3,7.76 290.81,6.25 290.81,1 290.88,0.83 291.05,0.76 297.85,0.76 298.37,0.98 298.59,1.5 298.59,11 298.52,11.17 298.35,11.24 295.35,11.24 294.1,11.75 293.59,13 293.59,16 294.1,17.25 295.35,17.76 299.75,17.76 299.92,17.83 299.99,18 299.99,27.45 299.92,27.62 299.75,27.69 296.4,27.69 296.4,28.2
GND on BOTTOM (solid shape): outline of 368 points within 152.79,68.33 156.03,71.34
GND on BOTTOM (solid shape): outline of 219 points within 21.38,55.76 32.01,69.55
GND on BOTTOM (solid shape): outline of 650 points within 131.77,77.38 138.12,81.11
GND on BOTTOM (solid shape): outline of 648 points within 123.02,78.19 131.73,81.08
GND on BOTTOM (solid shape): outline of 262 points within 129.4,62.04 138.22,65.65
GND on BOTTOM (solid shape): outline of 193 points within 0.5,0.25 277.54,28.76
GND on BOTTOM (solid shape): outline of 1140 points within 115.66,75.37 124.01,81.09
GND on BOTTOM (solid shape): outline of 1279 points within 30.28,54.37 38.27,63.84
GND on BOTTOM (solid shape): outline of 2243 points within 0.25,47.45 300.5,97.75
GND on BOTTOM (solid shape): outline of 2622 points within 253.79,52.16 283.44,90.74
GND on BOTTOM (solid shape): outline of 3002 points within 114.72,59.22 132.3,69.88
GND on BOTTOM (solid shape): outline of 11114 points within 131.77,58.25 156.43,81.11
GND on IN1 (solid shape): 50.46,54.23 50.46,52.04 50.28,51.86 46.45,51.86 46.45,52.94 46.43,52.95 45.33,52.95 45.33,54.48 50.21,54.48
GND on IN1 (solid shape): 71.49,51.27 71.49,49.28 71.07,48.86 67.26,48.86 66.83,49.28 66.83,49.66 66.6,49.89 65.94,49.89 65.55,50.28 65.18,50.28 65.07,50.39 65.07,51.13 65.32,51.37 71.39,51.37
GND on IN1 (solid shape): 87.72,63.17 87.81,63.13 87.81,63.03 88.07,62.52 88.49,62.9 88.56,62.98 88.56,63.17 93.8,63.17 93.8,58.46 93.59,58.25 91.06,58.25 90.82,58.49 90.82,59.51 90.53,59.8 83.76,59.8 83.57,59.99 83.57,61.02 83.68,61.13 87.45,61.13 87.57,61.25 87.58,61.25 87.58,63.17
GND on IN1 (solid shape): 94.2,70.8 89.44,70.8 89.15,70.95 88.86,70.8 88.42,70.8 88.28,70.92 88.09,70.95 88.01,70.97 87.97,71.05 87.97,73.23 88,73.25 88.18,73.44 88.18,73.71 90.14,73.71 90.68,74.25 90.68,74.71 90.8,74.83 90.8,76.84 90.97,77.02 94.2,77.02
GND on IN1 (solid shape): 299.75,28.2 300.28,27.98 300.49,27.45 300.49,18 300.28,17.47 299.75,17.25 298.75,17.25 298.75,17.76 299.75,17.76 299.92,17.83 299.99,18 299.99,27.45 299.92,27.62 299.75,27.69 296.4,27.69 296.4,28.2
GND on IN1 (solid shape): 299.09,1.5 298.73,0.62 297.85,0.26 291.05,0.26 290.52,0.47 290.3,1 290.3,6.25 289.3,7.26 288.29,6.25 288.29,1 288.08,0.47 287.55,0.26 282.47,0.26 281.5,0.25 280.62,0.62 280.25,1.5 280.25,8.34 298.59,8.34 298.59,8.36 299.09,8.36
GND on IN1 (solid shape): outline of 207 points within 82.59,63.62 88.11,69.84
GND on IN1 (solid shape): 290.47,64 290.64,63.92 290.71,63.75 290.71,62.55 290.94,62.02 291.47,61.79 293.57,61.79 293.87,61.86 294.13,62.05 299.75,62.05 300.28,61.83 300.49,61.3 300.49,60.8 300.27,60.28 299.75,60.06 298.9,60.05 298.37,59.83 298.14,59.3 298.14,58.8 298.37,58.27 298.9,58.05 299.75,58.05 300.28,57.83 300.49,57.3 300.49,56.67 300.53,56.36 300.65,56.07 300.72,55.9 300.75,55.71 300.75,52.9 300.74,52.9 300.74,42.97 300.74,42.95 300.24,42.95 300.24,42.97 300.24,55.08 299.99,55.33 299.2,55.33 299.03,55.51 299.03,55.84 299.18,55.99 299.99,55.99 299.99,57.3 299.92,57.47 299.75,57.54 298.9,57.54 298.01,57.91 297.64,58.8 297.64,59.3 298.01,60.19 298.9,60.56 299.75,60.56 299.92,60.63 299.99,60.8 299.99,61.3 299.92,61.47 299.75,61.54 298.92,61.54 298.92,61.12 298.72,60.92 297.63,60.92 297.48,61.07 297.48,61.54 295.01,61.54 295.01,61.07 294.78,60.84 293.81,60.84 293.36,61.29 291.47,61.29 290.58,61.66 290.21,62.55 290.21,64
GND on IN1 (solid shape): outline of 210 points within 54.79,47.45 300.49,97.75
GND on IN1 (solid shape): outline of 307 points within 0.5,0.26 300.49,28.76
GND on IN1 (solid shape): outline of 4613 points within 0.25,29.6 55.82,94.15
GND on IN2 (solid shape): 89.09,65.26 86.85,65.26 85.68,66.43 83.07,66.43 82.87,66.62 82.87,69.84 89.09,69.84
GND on IN2 (solid shape): 71.43,51.32 71.43,49.22 71.02,48.81 66.96,48.81 66.61,49.17 66.61,49.64 66.31,49.95 65.88,49.95 65.57,50.25 65.21,50.25 65.09,50.38 65.09,51.46 65.15,51.53 71.22,51.53
GND on IN2 (solid shape): 63.17,76.15 63.17,75.08 63.11,75.02 63.11,69.17 63.03,69.1 61.79,69.1 61.65,69.24 61.65,74.86 61.51,75 59.24,75 58.97,75.27 58.97,76.16 59.22,76.41 62.91,76.41
GND on IN2 (solid shape): 94.2,70.8 89.44,70.8 89.15,70.95 88.86,70.8 88.42,70.8 88.28,70.92 88.09,70.95 88.01,70.97 87.97,71.05 87.97,73.23 88,73.25 88.18,73.44 88.18,73.71 90.14,73.71 90.68,74.25 90.68,74.7 90.8,74.82 90.8,76.84 90.97,77.02 94.2,77.02
GND on IN2 (solid shape): 93.8,61.43 93.8,57.09 93.65,56.95 93.32,56.95 93.3,56.98 93.05,57.17 92.74,57.08 92.68,57.06 92.61,57.08 92.31,57.14 92.08,56.95 87.58,56.95 87.58,57.75 87.71,57.88 90.55,57.88 90.78,58.12 90.78,59.52 90.54,59.76 83.75,59.76 83.63,59.88 83.63,61.13 83.85,61.34 87.65,61.34 88.26,61.95 93.28,61.95
GND on IN2 (solid shape): 299.09,1.5 298.73,0.62 297.85,0.26 291.05,0.26 290.52,0.47 290.3,1 290.3,6.25 289.3,7.26 288.29,6.25 288.29,1 288.08,0.47 287.55,0.26 282.47,0.26 281.5,0.25 280.62,0.62 280.25,1.5 280.25,8.34 298.59,8.34 298.59,8.36 299.09,8.36
GND on IN2 (solid shape): 290.47,64 290.64,63.92 290.71,63.75 290.71,62.55 290.94,62.02 291.47,61.79 293.57,61.79 293.87,61.86 294.13,62.05 299.75,62.05 300.28,61.83 300.49,61.3 300.49,60.8 300.27,60.28 299.75,60.06 298.9,60.05 298.37,59.83 298.14,59.3 298.14,58.8 298.37,58.27 298.9,58.05 299.75,58.05 300.28,57.83 300.49,57.3 300.49,56.68 300.54,56.37 300.72,55.9 300.75,55.71 300.75,52.74 300.74,52.74 300.74,42.97 300.74,42.95 300.24,42.95 300.24,42.97 300.24,55.05 299.99,55.3 299.15,55.3 299,55.46 299,55.89 299.13,56.02 299.96,56.02 299.99,56.04 299.99,57.3 299.92,57.47 299.75,57.54 298.9,57.54 298.01,57.91 297.64,58.8 297.64,59.3 298.01,60.19 298.9,60.56 299.75,60.56 299.92,60.63 299.99,60.8 299.99,61.3 299.92,61.47 299.75,61.54 298.87,61.54 298.87,61.1 298.72,60.94 297.65,60.94 297.5,61.1 297.5,61.54 294.99,61.54 294.99,61.1 294.81,60.92 293.59,60.92 293.51,60.99 293.51,61.29 291.47,61.29 290.58,61.66 290.21,62.55 290.21,64
GND on IN2 (solid shape): outline of 876 points within 0.25,29.6 55.82,94.15
GND on IN2 (solid shape): outline of 217 points within 54.79,47.45 300.49,97.75
GND on IN2 (solid shape): outline of 307 points within 0.5,0.26 300.49,28.76
GND on IN3 (solid shape): 50.46,54.23 50.46,52.04 50.28,51.86 46.45,51.86 46.45,52.94 46.43,52.95 45.33,52.95 45.33,54.48 50.21,54.48
GND on IN3 (solid shape): 71.5,51.12 71.5,49.04 71.02,48.56 67.43,48.56 66.88,49.1 66.88,49.64 66.58,49.95 66,49.95 65.68,50.28 65.13,50.28 65.03,50.37 65.03,51.06 65.4,51.43 71.19,51.43
GND on IN3 (solid shape): 94.2,70.93 94.06,70.8 89.48,70.8 89.42,70.86 89.11,70.97 88.83,70.8 88.42,70.8 88.28,70.92 88.09,70.95 88.01,70.97 87.97,71.05 87.97,73.23 88,73.25 88.19,73.45 88.17,73.73 90.25,73.73 90.71,74.19 90.71,74.88 90.8,74.97 90.8,76.84 90.97,77.02 94.2,77.02
GND on IN3 (solid shape): 87.72,63.17 87.81,63.13 87.81,63.03 88.13,62.52 88.45,63.03 88.46,63.13 88.55,63.17 90.14,63.17 90.62,62.69 92.79,62.69 93.8,61.69 93.8,56.95 93.32,56.95 93.3,56.98 93.05,57.17 92.74,57.08 92.68,57.06 92.61,57.08 92.31,57.14 92.08,56.95 87.58,56.95 87.58,57.83 87.66,57.91 90.59,57.91 90.78,58.11 90.78,59.53 90.55,59.76 83.74,59.76 83.62,59.88 83.62,60.81 83.8,61 87.46,61 87.58,61.12 87.58,63.17
GND on IN3 (solid shape): 299.09,1.5 298.73,0.62 297.85,0.26 291.05,0.26 290.52,0.47 290.3,1 290.3,6.25 289.3,7.26 288.29,6.25 288.29,1 288.08,0.47 287.55,0.26 282.47,0.26 281.5,0.25 280.62,0.62 280.25,1.5 280.25,8.34 298.59,8.34 298.59,8.36 299.09,8.36
GND on IN3 (solid shape): outline of 199 points within 82.87,63.62 89.09,69.84
GND on IN3 (solid shape): 290.47,64 290.64,63.92 290.71,63.75 290.71,62.55 290.94,62.02 291.47,61.79 293.57,61.79 293.87,61.86 294.13,62.05 299.75,62.05 300.28,61.83 300.49,61.3 300.49,60.8 300.27,60.28 299.75,60.06 298.9,60.05 298.37,59.83 298.14,59.3 298.14,58.8 298.37,58.27 298.9,58.05 299.75,58.05 300.28,57.83 300.49,57.3 300.49,57.03 300.49,56.68 300.54,56.37 300.72,55.9 300.75,55.71 300.75,52.74 300.74,52.74 300.74,42.98 300.74,42.95 300.24,42.95 300.24,42.97 300.24,55.16 299.99,55.41 299.1,55.41 298.95,55.56 298.95,55.89 299.08,56.02 299.99,56.02 299.99,57.3 299.92,57.47 299.75,57.54 298.9,57.54 298.01,57.91 297.64,58.8 297.64,59.3 298.01,60.19 298.9,60.56 299.75,60.56 299.92,60.63 299.99,60.8 299.99,61.3 299.92,61.47 299.75,61.54 298.87,61.54 298.87,61.07 298.67,60.87 297.6,60.87 297.43,61.05 297.43,61.54 294.99,61.54 294.99,61.05 294.76,60.82 293.67,60.82 293.49,60.99 293.49,61.29 291.47,61.29 290.58,61.66 290.21,62.55 290.21,64
GND on IN3 (solid shape): outline of 900 points within 0.25,29.6 57.71,94.5
GND on IN3 (solid shape): outline of 197 points within 57.36,47.45 300.49,97.75
GND on IN3 (solid shape): outline of 307 points within 0.5,0.26 300.49,28.76
GND on IN4 (solid shape): 41.7,54.7 41.7,54.57 40.68,53.55 40.68,53.43 40.56,53.3 39.55,53.3 39.41,53.43 39.41,54.31 39.54,54.44 41.06,54.44 41.44,54.82 41.57,54.82
GND on IN4 (solid shape): 71.43,51.32 71.43,49.22 71.02,48.81 66.96,48.81 66.61,49.17 66.61,49.64 66.31,49.95 65.88,49.95 65.57,50.25 65.21,50.25 65.09,50.38 65.09,51.46 65.15,51.53 71.22,51.53
GND on IN4 (solid shape): 51.88,54.88 51.88,52.98 51.73,52.84 50.65,52.84 50.46,52.64 50.46,52.04 50.28,51.86 46.45,51.86 46.45,52.94 46.43,52.95 45.33,52.95 45.33,54.48 50.32,54.48 50.75,54.91 51.85,54.91
GND on IN4 (solid shape): 40.85,61.31 40.85,60.37 40.99,60.23 41.12,60.23 41.13,60.23 41.28,60.2 41.43,60.23 41.44,60.23 41.52,60.16 41.52,59.83 41.42,59.72 41.32,59.73 41.25,59.72 41.06,59.72 40.94,59.6 40.94,58.53 41.04,58.43 41.39,58.43 41.52,58.3 41.52,58.05 41.44,57.97 40.94,57.97 40.84,57.87 40.84,56.79 40.68,56.49 40.84,56.19 40.84,56.04 40.81,56.02 40.81,55.68 40.79,55.66 40.79,55.18 40.68,55.08 39.54,55.08 39.41,55.2 39.41,61.1 39.74,61.43 40.73,61.43
GND on IN4 (solid shape): 92.85,76.99 92.85,71.46 92.18,70.8 89.44,70.8 89.15,70.95 88.86,70.8 88.42,70.8 88.28,70.92 88.1,70.95 88.02,70.98 87.98,71.05 87.98,73.24 88.01,73.25 88.19,73.45 88.18,73.71 90.13,73.71 90.68,74.26 90.68,74.5 90.68,74.5 90.68,74.71 90.77,74.8 90.77,75.79 90.75,75.83 90.74,75.91 90.75,75.99 90.77,76.04 90.77,77.02 92.82,77.02
GND on IN4 (solid shape): 89.09,63.62 88.22,63.62 88.21,63.66 87.97,63.92 87.62,63.84 87.55,63.82 87.49,63.84 87.26,63.93 87.02,63.84 86.96,63.82 86.89,63.84 86.56,63.91 86.32,63.66 86.31,63.62 86,63.94 86,66.16 85.74,66.41 83.97,66.41 83.09,67.28 83.09,68.88 84.06,69.84 89.09,69.84
GND on IN4 (solid shape): 87.72,63.17 87.81,63.13 87.81,63.03 88.13,62.52 88.45,63.03 88.46,63.13 88.55,63.17 93.8,63.17 93.8,56.95 93.32,56.95 93.3,56.98 93.05,57.17 92.74,57.08 92.68,57.06 92.61,57.08 92.31,57.14 92.08,56.95 87.58,56.95 87.58,57.82 87.64,57.88 90.55,57.88 90.78,58.11 90.78,59.52 90.52,59.78 83.8,59.78 83.57,60.01 83.57,60.89 83.74,61.05 87.46,61.05 87.58,61.17 87.58,63.17
GND on IN4 (solid shape): 299.09,1.5 298.73,0.62 297.85,0.26 291.05,0.26 290.52,0.47 290.3,1 290.3,6.25 289.3,7.26 288.29,6.25 288.29,1 288.08,0.47 287.55,0.26 282.47,0.26 281.5,0.25 280.62,0.62 280.25,1.5 280.25,8.34 298.59,8.34 298.59,8.36 299.09,8.36
GND on IN4 (solid shape): 43.22,60.41 43.22,60.33 43.22,60.32 43.2,60.2 43.22,60.07 43.22,60.06 43.22,59.75 43.22,59.74 43.26,59.41 43.57,59.26 43.61,59.26 43.73,59.14 43.73,58.88 43.69,58.8 43.61,58.78 43.24,58.61 43.28,58.2 43.3,58.14 43.28,58.07 43.24,57.67 43.61,57.49 43.69,57.47 43.73,57.39 43.73,57.11 43.47,56.84 43.45,56.84 43.21,56.6 43.27,56.27 43.3,56.2 43.27,56.14 43.19,55.91 43.3,55.61 43.28,55.55 43.2,55.39 43.22,55.21 43.2,55.12 43.12,55.08 42.59,55.08 42.08,55.58 42.08,60.35 42.27,60.54 43.1,60.54
GND on IN4 (solid shape): 290.47,64 290.64,63.92 290.71,63.75 290.71,62.55 290.94,62.02 291.47,61.79 293.57,61.79 293.87,61.86 294.13,62.05 299.75,62.05 300.28,61.83 300.49,61.3 300.49,60.8 300.27,60.27 299.75,60.06 298.9,60.05 298.37,59.83 298.14,59.3 298.14,58.8 298.37,58.27 298.9,58.05 299.75,58.05 300.28,57.83 300.49,57.3 300.49,56.68 300.54,56.37 300.72,55.9 300.75,55.71 300.75,52.72 300.74,52.72 300.74,42.97 300.74,42.95 300.24,42.95 300.24,42.97 300.24,53.07 300.23,53.08 300.23,55.08 299.99,55.33 299.18,55.33 298.98,55.53 298.98,55.84 299.1,55.97 299.99,55.97 299.99,57.3 299.92,57.47 299.75,57.54 298.9,57.54 298.01,57.91 297.64,58.8 297.64,59.3 298.01,60.19 298.9,60.56 299.75,60.56 299.92,60.63 299.99,60.8 299.99,61.3 299.92,61.47 299.75,61.54 298.92,61.54 298.92,60.94 298.85,60.87 297.58,60.87 297.48,60.97 297.48,61.54 294.96,61.54 294.96,60.97 294.84,60.84 293.67,60.84 293.49,61.02 293.49,61.29 291.47,61.29 290.58,61.66 290.21,62.55 290.21,64
GND on IN4 (solid shape): outline of 310 points within 31.06,65.41 35.96,67.83
GND on IN4 (solid shape): outline of 459 points within 28.59,49.23 39.67,54.06
GND on IN4 (solid shape): outline of 208 points within 52.23,47.45 300.49,97.75
GND on IN4 (solid shape): outline of 307 points within 0.5,0.26 300.49,28.76
GND on IN4 (solid shape): outline of 3630 points within 0.25,53.04 53.41,94.15
GND on GND1: 87.98,77.02 87.98,70.8 94.21,70.8 94.21,77.02
GND on GND1: outline of 366 points within 0.26,0.25 300.75,97.75 ; 7 cut-outs
GND on GND2: outline of 366 points within 0.26,0.25 300.75,97.75 ; 5 cut-outs
GND on GND3: outline of 370 points within 0.26,0.25 300.75,97.75 ; 6 cut-outs
GND on VCC: 267.1,78.57 257.07,88.6 255.33,88.6 252.79,86.06 240.51,86.06 240.51,88.63 240.97,89.76 240,90.51 233.68,90.51 233.24,90.41 232.89,90.13 231.54,90.13 231.16,90.51 229.13,90.51 226.85,92.78 224.22,92.78 224.22,92.95 223.82,93.35 223.82,93.41 223.93,93.51 224.05,93.59 224.46,94 224.65,94.56 224.65,94.56 224.65,95.2 225.02,96.08 225.9,96.44 230.79,96.44 231.43,96.62 231.89,97.1 232.35,97.57 232.99,97.75 235.8,97.75 236.33,97.63 236.75,97.3 241.01,92.2 241.44,91.86 241.97,91.75 244.75,91.75 244.92,91.68 244.99,91.51 246.5,90.04 248,91.51 248.08,91.68 248.25,91.75 253.67,91.75 254.36,91.95 255.09,92.82 255.5,92.94 257.5,92.94 257.91,92.82 258.65,91.95 259.33,91.75 277.4,91.75 278.28,91.38 278.64,90.5 278.64,85.5 278.65,85.39 278.65,85.39 278.74,85.02 278.93,84.7 278.93,84.39 278.83,84.29 272.48,84.29 271.32,83.12 271.31,79.69 270.19,78.57 ; 1 cut-out
GND on VCC: 287.8,59.52 287.32,60.01 287.32,83.93 287.63,84.24 299.25,84.24 300.13,83.88 300.49,83 300.49,76.7 300.33,76.23 299.91,75.97 299.83,75.96 299.75,75.95 294.13,75.95 293.93,76.11 293.68,76.2 293.67,76.2 293.57,76.21 291.47,76.21 291.36,76.2 291.36,76.2 290.94,75.98 290.72,75.56 290.72,75.56 290.71,75.45 290.71,74.25 290.64,74.08 290.47,74.01 290,74.01 289.89,74 289.89,74 289.25,73.32 289.74,72.54 289.74,65.46 289.25,64.68 289.89,64 289.89,64 290.47,64 290.64,63.92 290.71,63.75 290.71,62.55 290.72,62.44 290.72,62.44 290.94,62.02 291.36,61.8 291.36,61.8 291.47,61.79 293.57,61.79 293.67,61.8 293.68,61.8 293.92,61.88 294.13,62.05 299.75,62.05 300.28,61.83 300.49,61.3 300.49,60.8 300.28,60.27 299.75,60.06 299.04,60.06 298.08,60.23 297.42,59.52
GND on VCC: outline of 88 points within 0.5,0.25 14.2,54.95
GND on VCC: 281.5,0.25 280.62,0.62 280.25,1.5 280.25,22.02 280.52,22.13 280.75,22.31 297.71,22.31 299.51,24.11 299.51,26.1 298.34,27.26 296.44,27.26 296.33,27.37 296.33,27.43 296.42,27.43 297.01,28.03 297.01,28.19 299.75,28.19 300.28,27.98 300.49,27.45 300.49,18 300.28,17.47 299.75,17.25 295.35,17.25 294.46,16.89 294.1,16 294.1,13 294.46,12.11 295.35,11.75 298.35,11.75 298.88,11.53 299.09,11 299.09,1.5 298.73,0.62 297.85,0.25 291.05,0.25 290.52,0.47 290.31,1 290.31,6.25 289.3,7.26 288.29,6.25 288.29,1 288.08,0.47 287.55,0.25
GND on GND4: outline of 377 points within 0.26,0.25 300.75,97.75 ; 3 cut-outs
GND on GND5: outline of 370 points within 0.26,0.25 300.75,97.75 ; 23 cut-outs
GNDA on TOP (solid shape): 282.61,42.67 282.61,42.38 282.63,42.36 282.63,41.49 282.5,41.36 281.45,41.36 281.07,41.74 280.89,41.92 280.89,42.53 281.07,42.71 281.35,42.71 281.35,42.15 281.36,42.15 281.79,42.15 281.81,42.15 281.81,42.71 282.2,42.71 282.58,42.71
GNDA on GND1, GND2, GND3, GND4, GND5: 285.64,26.5 283.99,28.15 267.1,28.15 265.66,29.59 265.66,32.3 265.71,32.34 269.39,32.34 269.92,32.87 269.92,37.15 269.39,37.68 268.37,37.68 268.27,37.78 268.27,38.33 269.66,39.73 269.66,42.5 269.66,43.41 269.9,43.65 272.86,43.65 274.26,42.25 283.53,42.25 286.07,39.71 299.19,39.71 299.43,39.37 299.82,39.21 300.3,38.97 300.49,38.47 300.49,37.25 300.28,36.72 299.75,36.51 287,36.51 286.26,35.88 286.74,35.04 286.74,29.66 286.26,28.82 287,28.19 295.83,28.19 295.83,27.11 295.21,26.5
GNDA on VCC: 285.64,26.5 283.99,28.15 267.1,28.15 265.66,29.59 265.66,32.3 265.71,32.34 269.39,32.34 269.92,32.87 269.92,37.15 269.39,37.68 268.37,37.68 268.27,37.78 268.27,38.33 269.66,39.73 269.66,42.5 269.66,43.41 269.9,43.65 272.86,43.65 274.26,42.25 283.53,42.25 286.07,39.71 298.4,39.71 298.86,38.86 299.73,38.45 299.73,37.27 287,37.27 286.7,37.24 286.41,37.15 285.5,36 285.98,34.62 285.98,30.08 285.51,28.65 286.49,27.52 286.58,27.43 295.83,27.43 295.83,27.11 295.21,26.5
VCCSA_B+ on TOP (solid shape): 85.11,54.13 85.11,52.87 84.9,52.66 83.59,52.66 83.42,52.83 83.42,54.08 83.56,54.22 85.03,54.22
VCCSA_B+ on BOTTOM (solid shape): 85.14,54.05 85.14,53.64 85.42,53.36 88.17,53.36 88.22,53.31 88.22,52.73 87.46,52.73 87.35,52.62 87.35,52.12 87.24,52.01 83.84,52.01 83.09,52.76 81.75,52.76 81.74,52.76 81.59,52.76 81.42,52.92 81.42,53.76 81.54,53.88 81.83,53.88 81.83,53.35 82.27,53.35 82.27,53.88 82.69,53.88 83.06,54.25 84.94,54.25
VDDP_ISL9538 on TOP (solid shape): 51.29,41.12 51.29,40.62 51.68,40.24 52.22,40.24 53.6,38.86 53.95,38.86 54.05,38.96 54.05,38.98 54.09,39.01 54.17,39.01 54.24,38.95 54.24,38.17 54.2,38.14 54.09,38.14 54.02,38.21 54.02,38.41 53.95,38.48 53.49,38.48 52.3,39.67 51.56,39.67 51.46,39.78 51.46,39.85 50.91,40.4 50.45,40.4 50.33,40.52 50.33,41.15 50.39,41.2 51.21,41.2
VIN_1.8VALW on TOP (solid shape): 208.7,30.69 209.59,30.69 209.69,30.6 209.69,29.9 209.59,29.8 208.58,29.8 208.32,29.55 208.32,28.03 207.64,27.34 207.64,26.22 207.59,26.17 206.57,26.17 206.52,26.22 206.52,27.52 207.08,28.08 207.36,28.08 207.56,28.28 207.56,28.81 207.1,28.81 207.1,28.91 207.56,28.91 207.56,29.8 207.31,30.06 207.31,31.07 207.43,31.2 208.2,31.2
VIN_1V_PRIM on BOTTOM (solid shape): 167.73,38.26 167.73,36.04 167.42,35.72 167.42,34.74 166.67,33.99 165.91,33.99 165.65,33.74 164.51,33.74 164.38,33.87 164.38,34.76 164.19,34.95 163.5,34.95 163.34,35.11 163.34,36.31 163.57,36.53 166.76,36.53 167.01,36.79 167.01,37.6 166.96,37.65 166.59,37.65 166.54,37.7 166.54,37.94 166.96,38.36 167.63,38.36
VIN_1V_PRIM on GND1: 165.58,37.17 165.4,37.35 165.4,38.13 165.58,38.31 166.23,38.31 166.79,37.75 166.79,37.35 166.61,37.17
VIN_1V_PRIM on GND5: 165.58,37.3 165.4,37.48 165.4,37.75 165.58,37.93 166.21,37.93 166.59,38.31 167.12,38.31 167.12,38.31 167.45,38.31 167.53,38.23 167.53,37.93 166.89,37.3
VIN_1VS_VCCIO on TOP (solid shape): 172.18,31.34 172.18,30.34 172.46,30.06 172.88,30.06 173.02,29.92 173.02,29.32 173.17,29.17 174.59,29.17 174.74,29.02 176.09,29.02 176.19,28.91 176.19,27.64 176.06,27.52 175.09,27.52 174.71,27.9 174.56,27.9 174.56,27.9 171.37,27.9 171.32,27.95 171.32,28.63 171,28.95 171,29.97 171.07,30.04 171.07,31.35 171.21,31.49 172.03,31.49
+AC1_IN on TOP (solid shape): outline of 148 points within 51.05,77.83 55.57,83.86
+AC2_IN on TOP (solid shape): 43.1,50.38 43.1,47.2 43.98,46.31 43.98,45.04 43.79,44.84 43.16,44.84 42.93,44.62 42.93,44.5 42.26,43.83 41.11,43.83 40.72,43.44 38.84,43.44 38.73,43.55 38.73,45.08 38.86,45.2 39.57,45.2 39.79,45.42 39.79,45.68 39.92,45.81 41.32,45.81 41.57,46.06 41.57,46.69 40.99,47.28 40.99,48.7 41.55,48.7 41.55,49.23 40.99,49.23 40.99,49.51 41.55,49.51 41.55,50.02 40.99,50.02 40.99,50.55 41.32,50.89 42.59,50.89
+BL_PWR_SRC on TOP (solid shape): 224.07,38.31 224.07,36.92 223.69,36.53 222.09,36.53 221.79,36.84 221.79,38.31 222.04,38.57 223.82,38.57
+BL_PWR_SRC on BOTTOM (solid shape): 222.9,39.18 222.9,37.95 223.18,37.66 223.37,37.66 223.82,37.21 223.82,36.79 223.05,36.03 223.05,33.49 223.31,33.23 223.51,33.23 223.8,33.09 224.1,33.23 224.83,33.23 225.09,32.98 225.09,31.71 224.83,31.45 221.4,31.45 221.15,31.71 221.15,33.86 221.97,34.68 221.97,37.63 221.61,37.99 221.61,39.15 221.71,39.25 222.83,39.25
+CHARGER_SRC on TOP (solid shape): 54.86,62.42 54.86,61.42 54.86,61.42 54.86,61.29 53.41,59.84 53.41,57.18 51.83,55.6 51.83,55.58 51.64,55.4 47.9,55.4 47.79,55.51 47.79,58.34 48.03,58.58 50.7,58.58 51.12,59 51.12,61.49 52.17,62.53 54.75,62.53
+CHARGER_SRC on BOTTOM (solid shape): 54.84,62.45 54.84,61.11 54.71,60.71 55.04,60.46 55.06,60.46 55.15,60.37 55.15,59.61 54.6,59.61 54.6,58.85 55.15,58.85 55.15,58.41 54.6,58.41 54.6,57.66 55.15,57.66 55.15,55.87 55.03,55.75 52.08,55.75 51.5,55.17 50.12,55.17 49.76,54.81 45.32,54.81 45.29,54.84 45.29,56.03 45.32,56.06 47.38,56.06 47.6,56.28 47.6,57.08 47.17,57.5 47.17,60.2 47.23,60.26 49.09,60.26 49.41,59.94 49.41,59.06 49.51,58.96 51.27,58.96 51.63,59.32 51.63,61.71 52.48,62.56 54.74,62.56
+CHARGER_SRC on IN3 (solid shape): 51.43,57.69 51.43,57.11 49.62,55.3 48.07,55.3 47.85,55.52 47.85,56.46 49.26,57.87 51.25,57.87
+CHARGER_SRC on IN4 (solid shape): 49.41,59.94 49.41,59.06 49.51,58.96 51.27,58.96 51.63,59.32 51.63,59.91 51.74,60.03 55.05,60.03 55.22,59.86 55.22,56.34 54.97,56.09 52.42,56.09 51.87,55.54 50.53,55.54 49.78,54.79 47.35,54.79 47.17,54.96 47.17,60.2 47.23,60.26 49.09,60.26
+EDP_VDD on BOTTOM (solid shape): 230.01,28.69 230.01,27.57 230.29,27.29 231.26,27.29 231.54,27.01 231.54,26.45 231.36,26.27 230.17,26.27 229.92,26.52 229.92,27.01 229.85,27.07 229.16,27.07 229.05,27.19 229.05,28.18 228.52,28.18 228.52,28.38 229.08,28.38 229.08,28.81 229.1,28.84 229.86,28.84
+LCDVDD on BOTTOM (solid shape): 216.39,39.16 216.39,37.93 216.6,37.72 217.97,37.72 218.48,37.21 218.48,36.66 218.74,36.41 218.74,36.03 218.99,35.77 219.5,35.77 219.62,35.65 219.62,34.76 219.55,34.67 219.52,34.56 219.52,34.54 218.73,33.74 218.61,33.74 217.72,32.85 216.83,32.85 215.94,31.96 215.94,30.51 215.91,30.48 215.89,30.46 215.78,30.3 215.75,30.12 215.75,29.94 215.78,29.76 215.89,29.6 215.91,29.58 215.94,29.55 215.94,28.91 216.2,28.66 218.37,28.66 218.5,28.54 224.53,28.54 224.65,28.66 228.03,28.66 228.21,28.84 228.92,28.84 228.95,28.81 228.95,28.51 228.39,28.51 228.39,28.05 228.92,28.05 228.92,27.13 228.92,26.22 228.57,25.87 226.41,25.87 226.15,26.13 226.15,27.06 225.95,27.26 214.8,27.26 214.55,27.52 214.55,31.57 214.65,31.57 214.65,32.57 216.2,34.12 217.47,34.12 217.72,34.38 217.72,36.93 217.71,36.94 217.71,36.97 217.68,36.97 217.61,37.04 217.3,37.04 217.14,37.2 216.46,37.2 215.77,37.88 215.68,37.88 215.61,37.95 215.61,39.17 215.66,39.23 216.32,39.23
+PBATT on TOP (solid shape): 63.64,54.34 63.64,53.59 64.11,53.12 64.11,47.48 63.58,46.95 61.53,46.95 60.5,47.98 60.5,54.64 60.67,54.82 63.16,54.82
+PWR_SRC on TOP (solid shape): 128.89,28.42 128.89,27.33 128.64,27.08 125.57,27.08 125.39,27.26 125.39,28.28 125.65,28.53 128.78,28.53
+PWR_SRC on TOP (solid shape): 84.85,45.55 85.39,45.55 87.17,43.77 87.16,43.44 87.16,42.45 87.17,42.12 87.93,41.36 87.93,40.9 87.85,40.67 87.93,40.45 87.93,40.29 87.86,40.14 87.86,39.97 88.06,39.74 88.36,39.74 88.39,39.76 88.56,39.58 90.21,37.93 90.21,34.88 89.71,34.38 89.2,34.38 88.69,34.88 88.69,38.29 88.56,38.41 87.34,38.41 85.51,40.24 85.51,43.11 84.62,44.01 84.52,44.12 84.41,44.22 83.89,44.74 83.45,44.74 83.42,44.75 81.09,47.08 79.9,47.08 79.62,47.35 79.62,48.12 79.48,48.26 79.48,48.58 79.63,48.73 81.68,48.73
+PWR_SRC on TOP (solid shape): outline of 87 points within 60.37,54.73 70.69,59.68
+PWR_SRC on BOTTOM (solid shape): 158.54,26.63 158.54,25.74 158.16,25.36 155.24,25.36 155.11,25.49 155.11,27.14 155.26,27.29 157.88,27.29
+PWR_SRC on BOTTOM (solid shape): 172.49,47.62 172.49,46.59 172.35,46.45 171.32,46.45 170.82,46.94 170.25,46.94 170.22,46.98 170.22,47.47 170.33,47.58 171.16,47.58 171.35,47.78 172.33,47.78
+PWR_SRC on BOTTOM (solid shape): 211.75,30.95 211.75,29.55 210.69,28.48 200.86,28.48 199.9,27.53 199.55,27.53 199.18,27.9 199.18,29.8 199.43,30.06 207.43,30.06 208.7,31.33 211.37,31.33
+PWR_SRC on BOTTOM (solid shape): 56.81,78.83 56.81,76.42 57.34,76.42 57.34,76.17 56.81,76.17 56.81,75.62 57.34,75.62 57.34,75.37 57.34,75.37 56.81,75.37 56.79,75.37 56.79,74.23 56.56,74 54.78,74 54.65,74.13 54.65,75.4 54.53,75.52 54.14,75.52 54.02,75.65 54.02,76.64 53.81,76.84 48.94,76.84 48.68,77.1 48.68,77.81 49.19,78.32 49.19,78.7 49.83,79.33 56.3,79.33
+PWR_SRC on BOTTOM (solid shape): 223.18,31.07 223.18,31.06 223.56,30.69 223.56,30.67 223.65,30.52 223.81,30.43 223.82,30.43 223.89,30.36 223.89,30.03 223.72,29.86 223.3,29.86 223.18,29.74 223.18,29.17 223.16,29.15 221.55,29.15 221.43,29.27 221.39,29.33 221.32,29.37 221.02,29.68 221.02,31.07 221.15,31.2 223.06,31.2
+PWR_SRC on BOTTOM (solid shape): outline of 195 points within 61.36,46.68 82.02,61.57
+PWR_SRC on IN2 (solid shape): 129.58,27.14 129.58,26.12 129.33,25.87 128.14,25.87 127.42,26.58 127.42,27.47 127.55,27.59 129.13,27.59
+PWR_SRC on IN2 (solid shape): 155.25,26.5 156,26.5 156.38,26.12 156.38,25.74 156.25,25.61 154.63,25.61 154.16,26.08 154.16,26.99 154.28,27.1 154.65,27.1
+PWR_SRC on IN2 (solid shape): 221.79,30.2 221.79,29.41 221.66,29.28 210.72,29.28 210.63,29.37 210.63,30.06 210.89,30.31 221.35,30.31 221.42,30.37 221.61,30.37
+PWR_SRC on IN2 (solid shape): outline of 358 points within 61.73,51.84 72.17,61.44
+PWR_SRC on IN3 (solid shape): outline of 3705 points within 52.37,44.54 81.32,78.06
+PWR_SRC on IN4 (solid shape): outline of 389 points within 61.73,50.26 78.2,61.44
+PWR_SRC_AC on TOP (solid shape): 55.83,56.93 55.83,55.76 55.54,55.47 53.73,55.47 53.47,55.72 53.47,56.83 53.73,57.08 55.68,57.08
+PWR_SRC_AC on BOTTOM (solid shape): 58.22,60.03 58.22,58.61 58.33,58.49 58.34,58.47 58.59,58.14 58.98,58.28 59.66,58.28 59.66,57.73 60.01,57.37 60.37,57.73 60.37,58.27 60.37,58.28 61.05,58.28 61.16,58.17 61.16,55.84 61.05,55.74 55.4,55.74 55.3,55.84 55.3,57.81 54.76,57.81 54.76,58.25 55.3,58.25 55.3,59.01 54.76,59.01 54.76,59.45 55.3,59.45 55.3,60.13 55.34,60.17 58.07,60.17
+SDC_IN on TOP (solid shape): 47.29,49.62 50.84,49.62 51.73,48.73 51.73,45.68 50.59,44.54 50.2,44.54 49.91,44.82 49.91,47.35 49.67,47.58 47.01,47.58 46.14,48.45 46.14,49.62 46.42,49.89 47.01,49.89
+SDC_IN on TOP (solid shape): 45.69,77.1 45.69,76.83 45.74,76.77 45.74,76.62 45.76,76.5 45.76,76.16 45.89,76.03 48.94,76.03 49.19,75.78 49.19,69.81 48.94,69.55 44.37,69.55 41.95,71.97 41.95,73.49 41.19,74.25 41.19,75.14 41.7,75.65 42.21,75.65 43.2,76.64 43.77,77.21 45.58,77.21
+SDC_IN on BOTTOM (solid shape): 51.55,47.74 51.55,45.5 50.72,44.66 47.36,44.66 47.06,44.97 47.06,47.66 47.19,47.79 51.5,47.79
+SDC_IN on BOTTOM (solid shape): 47.41,76.67 47.41,73.11 47.92,72.6 48.43,72.6 49.19,71.84 49.19,69.68 49.06,69.55 45.87,69.55 44.44,70.98 44.44,76.87 44.62,77.05 47.03,77.05
+SDC_IN on BOTTOM (solid shape): 62.07,61.63 62.07,61.1 61.76,60.79 61.76,59.9 61.14,59.28 60.37,59.28 60.37,59.28 60.37,59.81 60.01,60.17 59.66,59.81 59.66,59.27 59.09,59.27 59,59.35 59,59.63 57.7,60.93 57.7,61.81 57.83,61.93 61.76,61.93
+SDC_IN on VCC: 50.19,45.42 45.26,50.36 45.26,51.14 45.25,51.39 45.25,58 45.26,60.69 48.68,64.11 48.68,69.02 47.92,69.79 47.92,76.81 48.15,77.05 53.28,77.05 53.64,76.69 53.64,75.16 54.14,74.66 54.14,74.02 54.67,73.49 55.69,73.49 56.43,72.75 56.43,62.72 57.21,61.93 61.91,61.93 62.15,61.7 62.15,60.39 61.71,59.95 61.08,59.32 60.5,58.74 60.5,55.82 53.51,48.83 53.51,45.66 53.28,45.42
+TBT_SVR_IND on BOTTOM (solid shape): 28.84,69.32 28.84,65.59 29.38,65.06 29.38,64.45 29.38,64.45 29.38,63.97 29.44,63.91 29.44,63.52 29.34,63.42 29.33,63.42 29.2,63.36 29.13,63.23 29.13,63.21 29,63.08 28.82,63.08 28.69,63.2 28.69,64.02 28.62,64.09 27.16,65.55 27.16,69.39 27.19,69.42 28.74,69.42
+TBTA_VBUS on TOP (solid shape): 15.65,82 15.65,80.48 15.66,80.46 15.66,80.35 15.54,80.22 14.39,80.22 14.27,80.35 14.27,82 14.38,82.11 15.54,82.11
+TBTA_VBUS on TOP (solid shape): 11.39,84.7 11.39,84.25 10.65,83.51 8.48,83.51 8.46,83.51 8.38,83.59 7.93,83.59 7.93,83.59 7.25,83.59 7.09,83.75 7.09,83.87 7.19,83.97 7.94,83.97 7.95,83.98 9.31,83.98 10.41,85.07 11.02,85.07
+TBTA_VBUS on TOP (solid shape): 11.55,81.23 11.55,81.02 10.98,80.45 10.61,80.45 9.62,81.44 8.42,81.44 8.38,81.39 8.31,81.42 8.22,81.45 8.17,81.49 8.17,81.55 8.19,81.61 8.43,81.85 10.94,81.85
+TBTA_VBUS on TOP (solid shape): 51.59,91.83 51.59,91.54 51.6,91.31 51.61,91.23 51.61,90.26 51.6,90.25 51.6,89.46 51.58,89.39 51.51,89.36 51.28,89.1 51.53,88.85 51.55,88.85 51.6,88.8 51.6,87.21 51.48,87.08 47.16,87.08 47.03,87.21 47.03,89.11 47.29,89.37 48.18,89.37 48.3,89.49 48.3,90.22 48.85,90.77 48.96,90.98 48.92,91.22 48.92,91.23 48.92,91.93 49.1,92.11 51.31,92.11
+TBTA_VBUS on BOTTOM (solid shape): 11.57,81.26 11.57,80.93 11.04,80.4 10.89,80.4 10.48,80.81 9.24,80.81 9.09,80.96 9.09,81.85 9.11,81.87 10.96,81.87
+TBTA_VBUS on BOTTOM (solid shape): 15.3,81.72 16.42,81.72 16.67,81.47 16.67,79.01 16.36,78.7 15.4,78.7 14.34,79.77 14.34,81.78 14.52,81.97 15.05,81.97
+TBTA_VBUS on BOTTOM (solid shape): 11.45,84.49 11.45,84.29 10.66,83.5 8.6,83.5 8.5,83.6 8.5,83.96 9.11,84.57 10.41,84.57 10.56,84.72 10.56,84.9 10.69,85.02 10.91,85.02
+TBTA_VBUS on IN1 (solid shape): 51.61,92.54 51.61,91.87 51.58,91.55 51.61,91.23 51.61,90.51 51.35,90.26 49.57,90.26 49.06,90.77 49.06,91.12 48.74,91.44 47.57,91.44 47.53,91.4 34.59,91.4 30.9,87.72 26.97,87.72 26.21,86.95 21.51,86.95 21.25,87.21 21.25,88.48 21.51,88.73 25.06,88.73 25.82,89.49 30.4,89.49 33.95,93.05 51.1,93.05
+TBTA_VBUS on IN2 (solid shape): outline of 516 points within 8.68,79.46 24.68,88.73
+TBTA_VBUS on IN3 (solid shape): outline of 166 points within 8.68,79.46 24.68,88.73
+TBTA_VBUS on IN4 (solid shape): outline of 165 points within 21.25,86.95 51.61,93.05
+TBTA_VBUS on VCC: 1.02,75.78 1.02,87.71 1.2,88.17 1.27,88.68 1.27,92.2 1.41,92.54 1.75,92.68 3.71,92.68 4.18,89.01 7.73,90.09 8.47,89.32 9.5,89.03 23.5,89.03 24.93,89.62 25.52,91.05 25.52,92.9 25.66,93.24 26,93.38 26.53,93.38 26.53,93 28.7,90.83 30.87,93 30.87,93.38 51.86,93.38 51.86,92.69 51.59,91.63 51.79,90.55 50.86,89.62 50.06,89.62 50.06,89.62 50,89.62 48.87,90.75 48.87,91 48.47,91.4 46.8,91.4 45.25,89.85 45.25,87.71 45.26,81.85 45.02,81.62 25.97,81.62 25.13,80.78 25.13,74.56 24.73,74.16 24.13,74.16 23.32,73.35 20.32,73.35 20.17,73.51 20.17,75.63 19.52,76.29 5.15,76.29 4.64,75.78
+TBTA_VBUS_1 on TOP (solid shape): outline of 152 points within 35.97,75.91 56.56,87.38
+TBTA_VBUS_1 on BOTTOM (solid shape): 28.62,78.83 28.62,77.56 28.85,77.33 28.85,77.3 29.2,77.3 29.41,77.1 29.68,77.1 29.69,77.09 29.85,77.09 30.81,76.12 30.81,75.81 30.73,75.73 30.71,75.73 30.58,75.67 30.52,75.54 30.52,75.52 30.34,75.34 30.21,75.34 29.29,76.26 28.66,76.26 27.73,77.19 27.73,78.82 27.86,78.95 28.49,78.95
+TBTA_VBUS_1 on IN4 (solid shape): outline of 670 points within 28.62,74.51 38.02,79.71
+TBTB_VBUS on TOP (solid shape): 11.35,66.58 11.35,66.38 10.78,65.81 10.66,65.81 9.77,66.69 7.17,66.69 7.1,66.75 7.1,66.89 7.18,66.97 7.94,66.97 8.37,67.4 10.54,67.4
+TBTB_VBUS on TOP (solid shape): 15.64,66.99 15.64,65.47 15.55,65.37 15.51,65.36 15.03,65.36 14.76,65.09 14.33,65.09 14.19,65.24 14.19,66.94 14.38,67.13 15.51,67.13
+TBTB_VBUS on TOP (solid shape): 11.39,70.2 11.39,69.75 10.65,69.01 8.21,69.01 8.12,69.09 7.25,69.09 7.09,69.25 7.09,69.37 7.19,69.47 7.94,69.47 7.95,69.48 9.34,69.48 9.42,69.55 9.84,69.55 10.86,70.57 11.02,70.57
+TBTB_VBUS on TOP (solid shape): outline of 354 points within 10.96,47.44 37.25,61.43
+TBTB_VBUS on BOTTOM (solid shape): 11.35,70.24 11.35,69.66 10.74,69.05 8.78,69.05 8.76,69.07 8.76,69.43 8.78,69.45 8.93,69.45 9.01,69.53 9.01,69.96 9.06,70.01 10.25,70.01 10.79,70.54 11.04,70.54
+TBTB_VBUS on BOTTOM (solid shape): 9.64,67.27 10.1,67.27 10.23,67.14 10.81,67.14 11.35,66.61 11.35,66.35 10.79,65.79 10.61,65.79 10.15,66.25 9.16,66.25 9.03,66.38 9.03,66.79 8.88,66.94 8.68,66.94 8.65,66.96 8.65,67.32 8.7,67.37 9.54,67.37
+TBTB_VBUS on BOTTOM (solid shape): 14.71,62.11 14.71,59.72 14.68,59.68 14.67,59.68 14.56,59.62 14.48,59.52 12.77,59.52 12.62,59.37 12.62,58.24 12.36,57.97 10.7,57.97 10.38,58.29 10.38,59.42 10.39,59.51 10.4,59.6 10.4,60.11 10.39,60.19 10.38,60.29 10.38,60.6 10.43,60.69 10.53,60.69 11.07,60.99 10.53,61.3 10.43,61.3 10.38,61.39 10.38,61.62 11.14,62.38 13.31,62.38 13.44,62.51 14.32,62.51
+TBTB_VBUS on IN3 (solid shape): outline of 378 points within 8.87,58.01 14.9,70.6
+TBTB_VBUS on VCC: 9.87,55.46 9.79,55.5 9.71,55.53 9.38,55.74 9,55.82 1.87,55.82 1.87,56.39 1.71,57.17 1.27,57.82 1.27,62.22 1.2,62.73 1.02,63.19 1.02,75.27 4.85,75.27 5.36,75.78 19.3,75.78 19.66,75.42 19.66,69.54 19.35,69.23 17.54,69.23 16.93,68.62 16.93,53.51 16.84,53.41 14.19,53.41 13.89,53.72 13.89,54.93 13.36,55.46
+TBTB_VBUS_1 on TOP (solid shape): outline of 153 points within 31.54,43.14 41.4,53.43
+TBTB_VBUS_1 on BOTTOM (solid shape): 33.14,46.49 33.14,45.07 32.91,44.84 31.49,44.84 31.41,44.92 31.02,44.92 30.93,44.96 30.92,45.05 30.88,45.27 30.66,45.32 30.57,45.33 30.52,45.41 30.52,45.68 30.77,45.92 30.78,45.93 30.88,45.98 30.93,46.07 30.93,46.09 31.27,46.42 31.28,46.43 31.36,46.47 31.42,46.54 31.42,46.55 31.69,46.82 32.81,46.82
+TBTB_VBUS_1 on IN2 (solid shape): 33.14,46.72 33.14,44.33 32.99,44.18 32.05,44.18 31.53,44.69 31.53,44.72 31.52,44.84 31.46,44.95 31.44,45.05 31.51,45.11 31.73,45.36 31.66,45.68 31.64,45.74 31.66,45.81 31.71,46.17 31.41,46.39 31.37,46.4 31.36,46.44 31.36,46.68 31.57,46.88 32.97,46.88
+USB_EX2_PWR on BOTTOM (solid shape): 15.79,31.2 15.79,28.92 16.81,27.9 16.81,27.39 15.79,26.37 14.34,26.37 14.34,27.2 13.28,28.27 13.28,31.31 13.42,31.45 15.54,31.45
+USB_EX2_PWR on IN1 (solid shape): outline of 115 points within 11.27,25.99 14.9,31.33
+UZ12_TPM on BOTTOM (solid shape): 166.49,39.81 166.49,38.97 166.69,38.77 166.69,38.44 166.44,38.19 166.44,38.06 166.41,38.03 166.06,38.03 166.01,38.08 166.01,38.49 165.93,38.57 165.73,38.57 165.57,38.72 165.57,38.97 165.8,39.2 166.16,39.2 166.18,39.23 166.18,39.81 166.26,39.89 166.41,39.89
+VCHGR on TOP (solid shape): 59.35,57.84 59.35,56.98 58.83,56.98 58.47,56.63 58.83,56.27 59.35,56.27 60.37,55.25 60.37,53.17 60.24,53.04 59.22,53.04 58.97,52.79 58.08,52.79 57.95,52.92 57.95,55.03 57.71,55.27 56.93,55.27 56.79,55.41 56.79,58 56.91,58.12 59.07,58.12
+VHDMI_IN on BOTTOM (solid shape): 18.97,55.97 19.24,55.97 19.24,55.91 19.88,55.91 19.92,55.96 19.92,56.54 19.98,56.6 20.49,56.6 20.62,56.47 20.62,56.18 20.6,56.16 20.58,55.42 20.52,55.36 19.93,55.36 19.93,55.33 18.2,55.33 17.82,55.71 17.82,56.47 17.95,56.6 18.33,56.6
+VHDMI_VCC on TOP (solid shape): 16.68,51.9 16.68,50.89 16.55,50.76 13.76,50.76 13.63,50.62 13.26,50.62 13.25,50.63 13.14,50.63 13.09,50.63 12.49,50.63 12.24,50.89 12.23,51.77 12.49,52.03 16.55,52.03
