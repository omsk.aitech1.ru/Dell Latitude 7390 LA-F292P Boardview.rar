# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.0VO_DSW: length 2.7
  TOP w0.102: CC204.1 155.57,66 v1(155.26,65.69)
  TOP w0.254: CC204.1 156.22,65.6 v2(156.54,65.28)
  BOTTOM w0.254: UC1.AL1 155.83,65.2 156.46,65.2 v2(156.54,65.28)
+1.0VS_VCCIO: length 147.9
  TOP w0.254: v2(109.24,92.06) 109.24,90.71 v6(109.66,90.29) 114.58,85.37 118.31,85.37 118.63,85.04 v3(118.63,82.46)
  TOP w0.508: QE11.1 v3(252.77,47.66)
  GND1 w0.508: v3(118.63,82.46) 118.82,82.46 118.84,82.43 118.86,82.43 119.22,82.08 119.22,82.06 119.24,82.03 v4(119.24,81.51) ; v3(125.41,78.93) 125.75,78.93 v4(125.95,78.72) ; v4(252.67,48.32) 252.67,47.76 v3(252.77,47.66)
  IN2 w0.508: v4(252.67,48.32) 253.31,47.68 253.31,43.81 252.53,43.04 252.53,40.22 252.03,39.71 v4(251.83,39.71)
  IN3 w0.254: v4(72.92,92.85) 72.92,92.8 73.45,92.26 81.73,92.26 82.13,92.66 85.08,92.66 85.9,91.85 87.12,90.62 88.16,90.62 88.91,89.87 89.22,89.87 94.21,89.87 95.78,91.45 105.39,91.45 106.48,92.54 108.75,92.54 v2(109.24,92.06) ; 196.11,31.71 196.56,31.71 197.48,32.62 198.82,32.62 201,34.8 204.05,34.8 204.76,35.51 217.61,35.51 218.47,36.37 223.83,36.37 225.43,37.96 239.61,37.96 240.21,37.36 240.21,35 240.73,34.48 248.56,34.48 249.52,35.44 250.91,35.44 252.04,36.57 252.04,37.45 251.53,37.96 251.53,39.38 251.83,39.69 v4(251.83,39.71)
  IN4 w0.508: v4(125.95,78.72) 125.14,79.54 121.22,79.54 v4(119.24,81.51)
  GND5 w0.508: v4(72.92,92.85) 72.92,92.64 73.55,92 v5(73.7,92)
  BOTTOM w0.203: UC1.AK30 139.07,66.23 v2(139.3,66.23) ; UC1.AK28 139.53,66.23 v2(139.3,66.23) ; v2(139.3,66.23) UC1.AL30 v2(139.3,64.67)
  BOTTOM w0.254: UC1.AL42 v2(132.9,64.67) 132.55,64.97 UC1.AM42 v2(131.99,64.67) ; UC1.AM30 138.39,64.68 v2(138.39,64.64) ; UC1.AM28 v2(139.3,64.67)
  vias: v2(188.32,30.67) v2(188.93,30.67) v2(189.54,30.67) v2(190.2,30.67) v2(190.78,30.67)
+1.2V_DDR_B+:
  vias: v1(83.63,47.25) v2(83.24,48.46)
+1.2V_DDRP: length 26.1
  TOP w0.508: PC210.1 v2(87.25,36.47)
  IN1 w0.254: v2(79.6,44.08) 80.1,43.57 80.1,34.3 80.36,34.04 v2(87.22,34.04)
  BOTTOM w0.254: v2(79.6,44.08) 79.81,44.08 79.99,43.9 PR204.1 80.48,44.74 PC208.1
  BOTTOM w0.508: 89.07,36.79 89.07,38.62 88.43,39.25 v1(88.18,39.25) 87.42,39.25 86.91,39.76 86.91,41.42 86.97,41.49
  vias: v2(87.22,33.04)
+1.2V_LDO: length 3.1
  TOP w0.203: UR1.6 276.45,56.99
  TOP w0.508: CR5.1 274.64,56.47 CR6.1 275.62,56.47 v1(276.01,56.86) 276.13,56.99 276.45,56.99
+1.2V_MEM: length 109.7
  TOP w0.254: 143.55,56.68 v2(144.26,56.68) ; CD83.1 138.52,35.28 v2(138.44,35.37) ; CD3.1 116.84,35.61 v2(117.12,35.34)
  TOP w0.508: v2(92.65,42.88) 92.55,42.99 RZ119.1
  GND1 w0.203: v4(137.23,64.7) 137.23,64.96 136.86,65.32 v3(136.86,65.68)
  IN4 w0.152: v4(137.23,64.7) 137.23,64.8 136.82,65.21 135.5,65.21 135.19,64.89 135.19,62.56 v2(135.64,62.1)
  IN4 w0.254: v2(92.65,42.88) 92.65,38.74 v2(92.75,38.64)
  BOTTOM w0.152: v2(131,62.13) 131,62.13 132.12,62.13 UC1.AU42 ; UC1.BB23 143.32,59.07 143.32,58.27 143.7,57.89 143.7,57.23 v2(144.26,56.68)
  BOTTOM w0.203: UC1.BB32 138.32,59.09 138.32,58.07 138.31,58.06 v2(138.31,58.03)
  BOTTOM w0.254: v2(152.92,35.19) 152.92,35.59 UD4.G2 ; UC1.BB51 127.28,58.98 127.28,58.21 v2(127.2,58.14) ; UD2.E12 120.94,43.92 120.47,44.39 ; v2(138.76,40.26) UD3.E8 ; 118.34,42.45 117.72,43.08 UD2.K11 117.9,43.29 117.9,43.74 UD2.K12 ; UD2.J6 v2(118.69,38.69) UD2.H5 ; UD2.J6 UD2.K6 118.05,38.69 UD2.J5 ; UD2.J6 118.37,39.29 ; UD3.P6 132.85,38.69 UD3.P5 ; UD1.J10 102.45,42.66 102.45,42.81 UD1.K11 ; UD1.J10 103.14,41.91 ; UD1.J10 UD1.H11 ; UD1.N8 v2(99.85,40.32) ; UD1.A9 UD1.A8 ; v2(120.57,35.39) 120.57,35.66 UD2.F2 ; v2(152.95,37.11) 152.95,37.06 152.6,36.71 UD4.H3 ; v2(104.1,35.43) UD1.G2 ; UD1.G2 104.1,36.06 UD1.H3 ; UD1.G2 UD1.F2 ; UD1.J9 102.52,41.17 102.52,41.16 v2(102.48,41.13) ; UD2.D5 121.26,37.91 ; UD1.L5 v2(101.81,38.69) UD1.K5 ; UD1.M2 100.57,35.64 v2(100.57,35.37) ; v2(133.45,40.29) 133.55,40.39 UD3.N8 ; UD4.H5 v2(152.91,38.7) ; v2(152.91,38.7) UD4.H6 ; v2(152.91,38.7) UD4.G5 ; UD2.J10 UD2.J9 v2(118.71,41.11) UD2.H9 ; UD2.J10 118.37,42.42 ; UD2.J10 118.34,42.32 ; UD2.J10 118.69,42.71 ; UD4.E8 154.55,40.54 v2(154.25,40.24) ; UD1.D5 v2(106.37,38.69) UD1.D6 ; 121.3,37.9 UD2.D4 121.62,37.47 v2(121.29,37.14) ; v2(127.06,40.83) 127.91,40.83 128.15,40.59 CD98.1 129.83,40.59 129.99,40.75 131.2,40.75 UD3.U8 ; v2(142.19,40.5) 141.85,40.5 UD3.A8 ; UD3.H9 v2(136.79,41.11) UD3.J9 UD3.J10 ; 127.07,40.32 v2(127.07,39.56) ; UD4.J5 152.27,38.69 ; v2(138.44,35.37) 138.38,35.43 UD3.F2 ; UD2.U9 112.75,41.52 v2(112.23,41) 112.52,40.72 UD2.U8 ; UD4.G12 UD4.H12 UD4.H11 152.6,42.97 UD4.J10 UD4.J9 ; v2(124.09,41.13) UD2.A9 ; UD2.E8 v2(120.69,40.27) ; UD4.D6 155.2,39.04 v2(155.54,38.7) ; UD2.D6 v2(121.94,38.69) ; v2(145.98,43.32) 146.54,43.32 UD4.U11 ; v2(119.82,35.44) 119.82,35.51 119.67,35.67 UD2.G2 119.14,36.44 119.14,36.51 119.02,36.63 UD2.H3 ; 137.08,44.66 UD3.H12 ; v2(154.86,38.69) 155.2,38.35 UD4.D5 ; v2(151.64,41.11) 151.95,41.42 UD4.J9 ; UD3.D4 v2(139.33,37.92) ; UD2.P5 v2(114.8,38.69) UD2.P6 ; UD1.K12 UD1.L12 ; 135.48,38.57 UD3.L5 ; v2(129.53,58.23) 129.63,58.32 129.63,58.96 UC1.BB47 ; UD1.K8 v2(101.74,40.24) ; CD113.1 145.66,41.11 v2(146.12,40.65) 146.16,40.6 146.64,40.6 UD4.U8 146.64,40.83 146.64,41.4 UD4.U9 ; UD4.P5 UD4.P6 148.7,39.52 v2(149.4,40.23) 149.38,40.25 149.38,40.26 149.35,40.29 UD4.N8 ; v2(133.13,58.49) 133.13,58.89 UC1.BB41 ; UD1.U11 97.53,43.18 v2(96.43,43.18) ; UD3.G12 137.08,43.27 UD3.H11 ; UD4.J9 UD4.H9 ; UD1.E8 v2(105.08,40.3) ; 118.64,39.56 v2(118.62,39.58) 118.62,39.54 ; UD4.P4 v2(149.01,37.89) ; UD3.L2 135.13,35.75 135.43,35.45 v2(135.43,35.15) ; v2(153.52,35.19) 153.52,35.54 UD4.F2 ; UD3.K8 v2(135.57,40.27) ; v2(114.79,40.28) 115.23,40.28 ; UD2.M2 116.42,35.32 v2(116.41,35.31) ; UD2.K5 v2(117.39,38.69) UD2.L5 ; 118.71,42.73 UD2.H11 ; v2(139.3,62.1) UC1.AU28 ; v2(155.51,37.94) UD4.D4 ; UD1.L2 v2(101.44,35.42) ; v2(133.12,44.43) 133.04,44.43 UD3.R12 ; UD3.H3 137.73,36.06 UD3.G2 137.64,35.91 137.24,35.51 v2(137.24,35.35) ; UD3.M2 134.48,35.42 134.25,35.2 v2(134.25,35.13) ; UD1.P6 v2(99.23,38.69) UD1.P5 ; UD4.K8 UD4.K6 v2(150.97,38.69) UD4.L5 ; UD3.P4 v2(133.52,37.11) ; UD2.A11 124.1,43.12 124.25,43.27 CD18.1 126.28,43.27 v2(127.06,44.04) ; 114.78,37.9 v2(114.77,37.91) ; UD3.H5 137.4,38.69 UD3.G5 ; 140,38.66 UD3.D6 ; UD3.D5 v2(140.02,37.92) ; UD2.G5 v2(119.35,38.69) UD2.H6 ; UD1.U9 v2(97.09,40.85) UD1.U8 ; UD4.H8 v2(152.45,40.19) ; v2(117.12,35.34) 117.07,35.38 UD2.L2 ; v2(135.64,62.1) UC1.AU35 ; UD3.A9 142.05,41.09 v2(142.2,41.09) ; 115.67,40.72 UD2.N8 ; UD1.C12 v2(107,43.52) ; v2(142.04,62.1) UC1.AU23 ; v2(149.74,35.37) 149.74,35.5 149.93,35.68 149.93,35.78 149.93,35.78 149.93,35.85 UD4.M2 UD4.L2 ; v2(142.21,42.95) v2(142.21,43.53)
  BOTTOM w0.508: RD75.1 v2(110.12,50.37)
  vias: v2(92.75,38.06) v2(92.78,37.47) v2(92.8,36.89) v2(92.8,36.31) v2(92.8,35.72) v2(93.36,38.64) v2(93.36,38.06) v2(93.36,37.47) v2(93.39,36.89) v2(93.39,36.31) v2(93.39,35.72) v2(99.5,45.14) v2(99.56,39.73) v2(100.18,39.72) v2(100.71,45.59) v2(100.81,39.71) v2(100.93,46.16) v2(102.74,39.65) v2(102.82,46.27) v2(102.87,45.46) v2(103.38,39.68) v2(105.53,39.69) v2(106.24,45.16) v2(112.23,41.82) v2(114.04,46.16) v2(115.03,44.5) v2(115.88,44.47) v2(116.04,39.59) v2(116.7,39.6) v2(119.22,39.58) v2(119.63,46.28) v2(121.21,46.22) v2(122.27,45.58) v2(123.26,40.26) v2(124.07,40.49) v2(127.07,42.82) v2(135.36,44.36) v2(135.67,39.65) v2(136.33,39.65) v2(136.99,39.65) v2(139.6,45.01) v2(140.25,45.48) v2(140.26,44.83) v2(142.2,39.91) v2(145.93,44.64) v2(147.06,44.32) v2(148.43,44.4) v2(149.88,44.48) v2(150.21,39.67) v2(150.8,39.65) v2(152.31,39.59) v2(155.42,45.04) v2(155.84,44.62) v6(116.87,52.47)
+1.2V_MEM_CPUCLK: length 2.9
  TOP w0.203: RC231.1 v3(134.96,65.68)
  GND1 w0.254: v4(134.3,65.46) 134.74,65.46 v3(134.96,65.68)
  GND5 w0.254: v4(134.3,65.46) 134.26,65.46 134.26,65.32 134,65.07 v5(133.36,65.07)
  BOTTOM w0.254: UC1.AM40 v5(133.36,65.07)
+1.8V_3.3V_ALW_VTR3: length 33.4
  TOP w0.254: RE553.1 261.42,48.17 261.66,48.41 261.66,50.1 261.79,50.22 ; UE10.5 v2(245.15,60.96) ; v2(256.86,54.26) 256.86,54.27 256.84,54.29 RE554.1 RE529.2 RE340.2 ; 262.11,51.58 262.11,52.49 261.85,52.74 261.71,52.74 CE21.1 ; CE21.1 261.74,53.02 261.74,53.12 262.59,53.97 UE1.N5 ; CE21.1 261.59,52.92 261.28,53.22 261.28,53.37 v2(261.26,53.4)
  IN4 w0.254: v2(245.15,60.96) 245.66,61.48 249.38,61.48 v2(250.02,62.11)
  BOTTOM w0.102: v1(249.48,62.73) 250.02,62.2 v2(250.02,62.11)
  BOTTOM w0.254: v2(261.26,53.4) 260.77,52.92 257.97,52.92 256.86,54.03 v2(256.86,54.26) 254.97,56.15 254.97,58.42 252.47,60.93 251.2,60.93 v2(250.02,62.11)
+1.8V_MEM: length 33.9
  TOP w0.254: v2(112.24,42.67) 112.18,42.72 CD75.1 110.75,42.72 110.32,42.29 v6(110.32,41.61) 110.32,40.57 110.91,39.98 111.94,39.98 v2(112.25,39.67) ; v2(97.1,38.39) 97.4,38.69 CD52.1 ; v2(124.01,38.69) 124.07,38.63 CD42.1 ; CD76.1 96.94,39.07 v2(97.01,39) ; v2(131.02,40.22) 131.02,41.67 130.55,42.15 v2(130.45,42.15)
  TOP w0.508: v2(108.42,37.27) 108.07,37.63 CD41.1 ; v2(130.45,42.15) 129.76,42.15 CD111.1 ; CD74.1 123.99,43.06 124.11,42.95 v2(124.11,41.81) ; CD112.1 130.87,38.69 v2(130.6,38.97)
  BOTTOM w0.254: UD3.U10 130.61,42.32 v2(130.45,42.15) ; UD1.A10 109.01,41.3 109.01,39.54 108.58,39.12 UD1.A6 ; UD1.A3 v2(108.42,37.27) UD1.A4 ; UD2.A5 v2(124.01,38.69) UD2.A6 123.58,39.12 ; UD1.U6 v2(97.01,39) ; v2(142.22,37.91) 142.13,37.91 141.74,37.52 UD3.A4 UD3.A3 ; UD2.U4 112.88,37.23 v2(112.71,37.23) ; v2(112.57,38.77) 112.59,38.8 112.9,38.81 UD2.U6 ; UD2.U3 v2(112.8,36.3) ; UD2.U10 112.82,42.67 v2(112.24,42.67) ; UD2.A3 v2(123.2,37.12) 123.49,37.43 UD2.A4 ; UD2.U5 113.17,38.28 v2(112.7,37.81) ; UD4.A4 v2(156.82,37.12) UD4.A3 ; UD1.A5 108.64,38.32 109.02,38.7 109.83,38.7 CD43.1 ; v2(124.11,41.81) UD2.A10
  vias: v2(78.53,48.45) v2(79.11,48.45) v2(111.72,39.37) v2(124.07,39.34) v2(127.04,38.97) v2(142.23,39.32) v2(142.18,38.74) v2(143.9,37.34) v2(144.5,37.33) v2(145.25,38.93) v2(145.74,38.5) v2(157.52,38.69) v2(157.7,36.79) v2(157.88,37.4)
+1.8V_PGPPF: length 8.5
  TOP w0.381: v3(148.12,69.35) 148.63,69.35 148.81,69.17 v1(152.39,69.17) 154.13,69.17 154.23,69.27 RC304.2
  GND1 w0.254: v4(147.69,68.89) 147.69,68.97 148.07,69.35 v3(148.12,69.35)
  GND5 w0.254: v4(147.69,68.89) 147.69,68.84 147.36,68.51 v5(147.36,68.34)
+1.8V_PRIM: length 228.8
  TOP w0.254: UZ8.2 220.46,43.23 v2(220.31,43.38) 220.31,43.42 220.63,43.73 UZ8.1
  TOP w0.356: RC313.1 152.46,71.75 152.97,71.23 153.96,71.23 155,70.19 RC304.1
  TOP w0.508: v2(171.03,66.43) 171.03,65.93 173,63.97 174.16,63.97 174.71,63.41 RC212.1 ; v2(218.03,40.09) 218.03,40.04 217.95,39.97 217.95,38.19 218.84,37.3 v2(219.12,37.3) ; RC506.1 250.16,83.52 250.8,84.17 v2(250.85,84.17) ; QC3.2 248.06,83.96 247.32,83.23 246.13,83.23 245.23,82.33 245.23,81.48 244.44,80.7 v2(244.44,80.69)
  IN1 w0.381: v2(262.93,48.85) 262.93,50.22 263.2,50.49 263.2,52.35 v4(263.24,52.38)
  IN1 w0.508: 165.05,65.12 v4(165.67,65.12) ; 165.05,65.12 164.88,65.12 162.13,67.88 161.68,67.88 161.13,68.44 161.13,68.72 160.47,69.38 157.69,69.38 156.7,70.37 v2(156.68,70.37) ; 165.05,65.12 164.03,64.09 164.03,56.4 167.73,52.69 169.88,52.69 171.31,51.26 171.31,50.19 175.45,46.06 176.19,46.06 178,44.26 178,43.47 179.6,41.87 181.88,41.87 182.12,41.62 184.81,41.62 186.54,39.89 211.79,39.89 212.21,39.47 217.49,39.47 218,39.98 218,40.06 v2(218.03,40.09)
  IN2 w0.508: v4(165.67,65.12) 165.93,65.12 167.54,66.73 170.73,66.73 v2(171.03,66.43)
  IN3 w0.508: v4(254.45,60.87) 252.57,58.99 248.28,58.99 248.25,59.01 248.23,59.01 247.93,59.31 241.69,59.31 241.01,58.63 241.01,57.06 240.24,56.3 239.3,56.3 238.27,55.26 238.27,54.21 237.76,53.7 237.76,49.43 236.69,48.36 236.69,46.3 230.43,40.04 226.64,40.04 224.33,37.73 221.85,37.73 221.41,37.28 220.64,37.28
  GND5 w0.254: v5(254.31,60.05) 254.45,60.19 v4(254.45,60.87)
  GND5 w0.381: v4(263.24,52.38) v5(263.24,52.89)
  GND5 w0.508: v4(165.67,65.12) 165.52,64.97 v5(165.52,64.47)
  BOTTOM w0.203: v2(156.68,70.37) 155.96,70.37 UC1.AA1
  BOTTOM w0.381: v2(250.85,84.17) 250.85,83.78 249.39,82.32 249.39,81.02 248.79,80.41 247.01,80.41 246.73,80.69 v2(244.44,80.69) 244.38,80.69 242.18,78.5 242.18,68.4 246.18,64.4 248.69,64.4 251.72,61.38 252.65,61.38 253.98,60.05 254.31,60.05 v5(254.31,60.05) 254.65,60.05 257.06,57.65 257.06,55.65 258.6,54.1 261.5,54.1 262.7,52.89 v5(263.24,52.89)
  BOTTOM w0.508: v2(218.03,40.09) 218.03,40.14 218.61,40.73 219.85,40.73 220.67,41.54 220.67,43.03 v2(220.31,43.38) ; RC389.1 RC388.1 RC390.1 164.07,62.55 RC392.1 RC391.1 164.83,63.58 165.52,64.27 v5(165.52,64.47)
  vias: v2(219.73,37.28) v6(220.71,36.85)
+1.8V_RUN: length 264.1
  TOP w0.254: RC363.2 165.34,69.5 RC362.2 164.43,67.63 164.71,67.34 164.71,66.43 164.94,66.2 v3(165.45,66.2)
  TOP w0.356: Q1.2 242.25,76.73 v3(241.8,77.17)
  TOP w0.508: v2(236.29,64.55) 235.47,64.55 RZ502.2 ; 266.22,26.56 266.67,26.12 v6(268.37,26.12) 277.59,26.12 278.91,27.44 v2(278.91,28.46) ; v2(236.15,66.54) 236,66.39 RZ501.2 ; RZ504.2 236.22,55.36 236.73,55.87 236.73,56.59 236.18,57.14 RZ503.2 235.94,57.31 235.44,57.82 v2(235.27,57.82) ; v2(276.9,85.68) 276.9,85.33 RZ513.2 ; RZ512.2 250.06,80.48 v2(250.28,80.25) ; RZ510.1 254.24,27.69 259.35,27.69 260.14,26.91 264.05,26.91
  GND1 w0.254: v3(165.45,66.2) 165.67,65.98 v4(165.67,65.74)
  GND1 w0.508: v4(242.05,76.69) 241.8,76.95 v3(241.8,77.17)
  IN1 w0.508: v4(242.05,76.69) 242.74,76.01 242.74,73.16 241.98,72.41 241.98,68.9 240.01,66.93 237.06,66.93 236.68,66.54 v2(236.15,66.54) ; v4(165.67,65.74) 165.92,65.74 166.29,65.37 166.29,64.87 165.93,64.51 165.59,64.51 164.99,63.91 v4(164.99,60.56) ; v2(250.28,80.25) 254.02,80.25 256.38,82.61 267.99,82.61 269.44,84.06 276.55,84.06 v2(277.16,84.67) ; v4(240.07,57.01) 239.73,56.68 236.42,56.68 v2(235.27,57.82)
  IN2 w0.508: v2(250.28,80.25) 249.55,79.51 246.52,79.51 244.21,77.2 242.56,77.2 v4(242.05,76.69) ; v2(236.29,64.55) 233.57,64.55 230.98,61.96 v2(230.98,60.56)
  IN3 w0.508: v2(180.94,42.91) 180.93,42.92 v2(179.99,42.92) 179.99,44.02 177.32,46.69 177.32,49.52 175.91,50.93 175.13,50.93 171.61,54.45 167.28,54.45 v2(165.83,52.99) 164.84,53.98 164.84,54.62 163.79,55.66 163.79,59.36 v4(164.99,60.56) ; v2(235.27,57.82) 233.93,59.17 232.38,59.17 v2(230.98,60.56) ; 286.98,41.15 283.76,37.93 283.76,35.01 278.91,30.16 v2(278.91,28.46) ; v2(182.33,39.52) 183.37,39.52 185.02,37.88 186.53,37.88 187.22,37.19 188.18,37.19 189.7,35.67 193.57,35.67 193.82,35.42 203.95,35.42 206,37.47 210.25,37.47 211.23,38.46 219.02,38.46 219.97,39.4 225.1,39.4 226.37,40.67 230.17,40.67 234.53,45.04 234.53,48.17 237.13,50.76 237.13,54.27 237.64,54.78 237.64,55.58 239.07,57.01 v4(240.07,57.01)
  BOTTOM w0.406: RC511.1 180.99,41.96 QC4.5 ; QC4.2 180.99,38.85 181.45,38.39 182.01,38.39 182.31,38.69 182.31,39.51 v2(182.33,39.52)
  BOTTOM w0.508: v2(225.26,48.75) 225.52,49.01 225.52,49.56 228.16,52.21 228.16,55.58 230.98,58.4 v2(230.98,60.56) ; v2(236.29,64.55) 236.29,66.4 v2(236.15,66.54) ; v2(180.94,42.91) 181.04,42.81 RC511.1 ; QC4.5 180.99,40.7 181.39,40.31 181.79,40.31 182.24,39.86 182.24,39.62 v2(182.33,39.52) ; v2(165.83,52.99) 165.83,52.46 165.6,52.23 RC370.2 ; RC510.1 179.39,41.7 179.39,42.36 179.9,42.87 179.94,42.87 v2(179.99,42.92)
+1.8V_RUN_AUDIO: length 10.2
  TOP w0.203: CA57.1 265.68,30.28 265.68,30.92 266.17,31.42 UA1.16 ; UA1.21 268.17,31.17 268.7,30.64 268.7,29.99
  TOP w0.356: CA69.1 266.03,29.7 265.87,29.87 CA57.1
  TOP w0.508: v2(266.79,29.17) 266.62,29.34 CA69.1 ; CA58.1 268.7,29.99 268.63,29.99 268.03,30.6 267.98,30.6 267.96,30.62 v2(267.86,30.62)
  BOTTOM w0.102: v2(267.86,30.62) v1(269.19,30.62)
  BOTTOM w0.508: v2(266.79,29.17) 267.86,30.24 v2(267.86,30.62)
+1.8V_RUN_CARD: length 2.8
  TOP w0.102: v1(280.59,49.53) 280.59,51.85 280.31,52.13 v2(280.2,52.13)
  vias: v2(279.6,52.13) v2(289.86,51.52) v2(290.62,51.52)
+1.8V_RUN_UZ8: length 1.1
  TOP w0.127: 224.9,44.93 224.2,44.93 v6(223.91,45.22)
+1.8V_VIN: length 1.8
  TOP w0.127: v6(78.03,56.51) 78.34,56.21 78.34,54.87
+1.8VALWP: length 10.3
  TOP w0.254: PC503.1 PR501.1 210.74,25.49 217.47,25.49 217.85,25.87 v6(217.85,26.88)
+1VALWP: length 6.3
  BOTTOM w0.254: 64.05,66.25 66.49,68.69 66.49,70.34 PC307.1 65.45,70.5 PR306.1
  vias: v1(62.51,62.78) v2(63.03,66) v2(63.03,65.36) v2(63.42,63.41) v2(63.42,62.77) v2(63.42,62.19) v2(64,63.41) v2(64,62.77) v2(64,62.19)
+1VALWP_B+:
  vias: v1(58.69,72.34) v2(59.48,72.86) v2(59.48,72.27)
+1VS_VCCIOP: length 16
  TOP w0.254: PC406.1 184.83,26.12 184.28,25.57 v6(179.67,25.57) 179.37,25.88 179.37,27.59 179.19,27.77 PU401.1 ; PR421.1 186.07,31.33 187.22,30.18 187.22,28.43
+3.3V_1.8V_ESPI: length 15.7
  TOP w0.254: 173.52,60.28 172.64,60.28 v6(172.19,59.83) 171.73,59.38 171.73,56.79 169.09,54.15 166.25,54.15 164.76,52.66 v3(164.76,52.38)
  GND1 w0.254: v3(164.76,52.38) 164.74,52.36 v4(164.74,51.9)
  GND5 w0.508: v5(164.03,51.9) v4(164.74,51.9)
  BOTTOM w0.254: RC21.2 v5(164.03,51.9)
+3.3V_1.8V_PGPPA: length 31.2
  TOP w0.254: 175.04,61.39 175.37,61.39 175.72,61.03 RC550.1
  IN2 w0.254: v2(168.3,64.7) 168.7,65.11 170.48,65.11 172.53,63.06 v2(172.53,62.09)
  IN3 w0.254: v4(148.44,65.39) 149,65.94 150.85,65.94 151.63,65.16 154.55,65.16 156.48,63.23 163.88,63.23 164.75,62.37 166.94,62.37 168.3,63.72 168.3,64.7 v2(168.3,64.7)
  GND5 w0.254: v5(148.01,65.83) v4(148.44,65.39)
+3.3V_1.8V_PGPPG: length 15.5
  TOP w0.254: v3(158.61,68.16) 158.36,68.16 RC235.2 RC234.2 ; CC326.1 148.94,68.21 v2(148.33,68.82)
  GND1 w0.254: v4(159.22,67.67) 159.22,67.73 158.79,68.16 v3(158.61,68.16)
  IN1 w0.254: v4(159.22,67.67) 158.15,68.74 157.42,68.74 156.96,69.2 150,69.2 149.56,68.76 148.39,68.76 v2(148.33,68.82)
  BOTTOM w0.254: UC1.AD15 148.29,68.82 v2(148.33,68.82)
+3.3V_ALW: length 379
  TOP w0.102: v2(103.04,90.79) 102.6,90.34 v6(102.46,90.34)
  TOP w0.254: CZ73.1 195.14,38.33 196.03,39.22 RZ9.1 ; UE4.5 264.75,72.71 264.3,73.16 263.97,73.16 RE21.2 ; RE519.2 258.18,50.49 CE60.1 ; 205.71,29.24 205.71,31.04 206.58,31.91 PR517.2 ; CE501.1 259.45,77.57 258.83,78.18 UE2.18
  TOP w0.305: 192.14,43.21 191.84,42.91 JAPS1.7 ; JAPS1.3 193.84,42.71 193.34,43.21 ; 193.03,43.72 195.55,43.72 v3(195.86,43.4) ; UE6.5 v2(252.55,54.67)
  TOP w0.356: UE3.5 262.04,72.75 262.36,73.07 CE53.1 ; UE5.5 255.57,73.08 255.31,72.83 254.99,72.83 CE61.1
  TOP w0.381: v2(195.28,36.95) 195.28,35.48 RE526.2 ; v3(156.79,49.56) 156.7,49.48 156.7,48.09 156.32,47.71 RC214.2
  TOP w0.508: RE79.1 272.45,57.97 v2(272.81,58.33) ; RE500.1 260.27,78.48 260.27,77.59 CE501.1 260.41,77.57 260.82,77.16 v2(260.88,77.16) ; v2(66.38,45.19) 66.81,45.61 PR1.1 ; UZ34.5 92.45,40.97 92.45,40.1 CZ104.1 91.97,39.93 91.58,40.31 v3(91.58,41.31) ; v2(170.3,32.93) 170.69,33.32 172.04,33.32 172.34,33.02 172.34,32.69 173.31,31.72 174.21,31.72 174.22,31.73 ; v2(267.5,53.5) RE25.1 RE562.2 ; v2(29.38,35.52) 28.99,35.91 RT164.2 ; RE519.2 257.27,48.69 257.97,47.99 RE69.1 258,47.66 RE561.2 ; v2(253.18,78.79) 252.98,79 CE502.1 ; v2(267.99,45.42) 267.76,45.65 RE83.2 ; CE61.1 CE52.1 254.61,74.52 v2(254.34,74.8) ; v2(251.06,66.1) 251.13,66.03 RE11.2 ; CZ58.1 CZ57.1 178.94,33.97 178.17,33.21 176.03,33.21 175.4,32.58 PR413.1 ; RE302.2 252.37,72.15 v2(252.82,72.6) RE68.2 ; v3(165.47,40.09) 165.47,41.16 PR418.1 ; v2(29.23,83.83) 29.3,83.75 29.3,82.87 29.23,82.8 29.23,82.63 29.2,82.6 29.2,82.33 28.62,81.75 28.62,81.7 QC7.3 28.08,81.42 26.47,81.42 RT48.2 25.49,82.39 RC432.1 25.16,82.76 24.76,83.17 24.76,85.12 24.25,85.63 22.98,85.63 22.62,85.27 21.17,85.27 19.95,86.5 v2(19.12,86.5) ; v2(268.44,51.2) 268.51,51.27 RE300.1 ; v2(260.58,84.03) 260.63,83.98 RE502.1 ; RZ8.1 RZ9.1 ; v2(259.06,84.1) 258.86,83.89 RE527.1 ; v2(163.54,37.45) 164.1,38.01 PL406.1 ; RC507.1 246.31,84.4 244.33,82.42 v2(244.33,81.48) ; v2(65.19,74.13) 65.75,74.13 66,74.38 PR307.1 ; v2(262.17,74.51) 262.17,74.23 262.36,74.04 CE53.1 RE21.2 ; RE92.2 RE8.2 257.97,68.88 v2(257.9,68.94) ; v2(59.45,33.69) 59.82,34.06 PR933.1 ; v2(246.42,78.06) 245.38,78.06 245.25,77.94 RE12.2 ; v2(61.92,77.56) 62.3,77.94 PR107.1 ; RE10.2 272.14,66.87 RE84.2 v2(272.76,65.91) ; RE303.2 v2(251.25,67.75) ; v2(103.04,90.79) CZ167.1 103.84,91.74 UZ1.2 ; RE504.1 v2(252.3,82.03) ; v2(34.74,33.61) 34.74,32.9 PR1265.2 PR1260.2 ; v2(272.87,61.16) 272.42,61.16 RE5.2 RE365.2 RE301.2 ; v2(253.53,64.83) 254.04,64.83 RE362.2 RE505.2 ; RT451.1 v3(38.69,91.33) ; v2(272.39,52.99) 272.28,53.1 RE35.2 RE38.2
  GND1 w0.117: v3(263.9,44.38) 263.9,44.48 v4(264.23,44.81)
  GND1 w0.254: v3(195.86,43.4) 196.09,43.4 196.33,43.16 v4(196.36,43.16)
  GND1 w0.381: v3(235.45,61.81) 235.33,61.93 235.33,62.5 v4(235.31,62.52)
  GND1 w0.508: v3(277.79,67.22) 278.15,67.22 278.27,67.09 278.3,67.09 v4(278.48,66.91) ; v4(157.32,50.29) 157.32,50.1 v3(156.79,49.56) ; v4(255.68,87.78) 256.01,88.11 v3(256.33,88.11) ; v3(73.97,54.36) v4(73.49,54.36) ; v4(90.82,41.36) 91.53,41.36 v3(91.58,41.31) ; v4(15.93,51.79) 16.21,51.79 16.55,52.13 v3(16.55,52.37) ; v3(37.63,86.67) v4(38.82,86.67) ; v3(38.69,91.33) v4(38.69,90.71) ; v3(253.33,60.92) 253.51,61.1 253.71,61.1 v4(253.89,61.27) ; v3(165.47,40.09) v4(165.47,39.07)
  IN1 w0.508: v4(53.99,74.58) 53.99,73.08 54.5,72.58 55.72,72.58 57.14,74 57.14,76.18 58.06,77.1 61.46,77.1 v2(61.92,77.56) 62.73,78.37 65.02,78.37 v4(65.37,78.01) ; v4(66.77,39.48) 64.13,36.84 60.57,36.84 59.92,36.19 59.92,34.16 v2(59.45,33.69) ; v2(66.38,45.19) 66.38,46.14 67.07,46.83 70.74,46.83 73.49,49.58 v4(73.49,54.36)
  IN2 w0.508: v4(66.77,39.48) 65.81,40.44 65.81,44.62 v2(66.38,45.19) 66.59,45.4 69.45,45.4 71.56,43.29 76.29,43.29 79.62,43.29 80.69,42.22 ; 81.35,41.69 90.49,41.69 v4(90.82,41.36) ; v2(29.23,83.83) 30.22,84.82 35.07,84.82 36.16,85.91 37.23,85.91 37.99,86.67 v4(38.82,86.67) ; 81.15,42.83 81.15,44.51 80.43,45.22 v2(80.43,46.31) ; v2(23.56,35.16) 23.59,35.19 26.64,35.19 27.09,34.73 28.59,34.73 v2(29.38,35.52)
  IN3 w0.508: v4(157.32,50.29) 157.87,50.29 159.07,49.08 160.93,49.08 161.21,48.8 161.71,48.8 161.96,49.05 163.6,49.05 v4(163.92,48.73) ; v4(38.82,86.67) 37.56,87.94 37.56,89.58 v4(38.69,90.71) ; v2(34.74,33.61) 35.29,33.61 38.11,36.44 38.11,37.66 v4(39.63,39.18) ; v4(278.71,64.55) 279.19,65.03 279.19,66.2 v4(278.48,66.91) ; v4(25.49,25.46) 25.49,25.02 25.24,24.76 22.8,24.76 21.14,23.1 18.93,23.1 13.11,17.28 v4(13.11,14.98)
  IN4 w0.508: v4(38.82,86.67) 41.11,86.67 42.71,88.27 47.54,88.27 48.33,87.48 53.44,87.48 54.22,86.7 v4(54.22,86.63) 55.42,85.43 58.64,85.43 59.28,84.79 64.15,84.79 64.9,85.54 v4(64.9,86.01) ; v2(34.74,33.61) 34.66,33.69 30.98,33.69 29.38,35.29 v2(29.38,35.52) ; v4(15.93,51.79) 15.38,51.24 15.38,43.39 17.14,41.64 17.14,38.69 20.62,35.21 v2(22.24,35.21) ; v4(13.11,14.98) 13.11,18.83 13.77,19.49 13.77,27.14 15.8,29.17 19.3,29.17 22.88,32.75 v2(22.88,33.89)
  GND5 w0.254: v4(179.07,36.64) 179.07,37 v5(179.24,37.17) 179.7,36.71 v4(179.7,36.64)
  GND5 w0.508: v4(163.92,48.73) 163.42,49.23 v5(163.31,49.23) ; v4(53.99,74.58) 54.21,74.8 v5(54.21,75.12) ; v5(12.57,14.75) 12.81,14.98 v4(13.11,14.98) ; v5(65.19,82.43) 65.19,82.03 v4(65.35,81.87) ; v5(25.62,26.32) 25.62,25.59 v4(25.49,25.46) ; v5(156.63,50.3) 157.31,50.3 v4(157.32,50.29) ; v4(72.94,86.76) 72.94,87.51 v5(73.14,87.72) ; v4(54.22,86.63) 54.22,86.77 54.48,87.03 v5(54.48,87.79) ; v5(81.27,41.22) v4(80.73,41.22)
  BOTTOM w0.203: PR1268.2 73.4,84.01 72.84,84.01 72.66,84.18 72.66,86.06 73.32,86.72 73.32,87.54
  BOTTOM w0.254: PU200.13 82.37,42.22 82.06,41.92 82.06,41.73 81.56,41.23 81.28,41.23 v5(81.27,41.22) ; v2(62.04,89.39) 61.63,88.99 60.01,88.99 PR1229.2 ; JKBTP1.6 179.75,35.57 180.07,35.89 180.07,36.25 179.24,37.08 v5(179.24,37.17) ; PR205.2 80.54,46.21 v2(80.43,46.31)
  BOTTOM w0.381: UT33.5 CT237.1 ; v2(170.35,85) 170.57,85.22 UZ35.5 ; UT32.5 3.98,10.25 CT238.1 ; UZ6.5 163.47,47.97 163.59,48.1 CZ82.1 163.59,48.68 163.31,48.95 v5(163.31,49.23)
  BOTTOM w0.508: v2(82.57,89.49) 82.58,89.51 CZ188.1 81.47,90.63 UZ28.2 ; v5(25.62,26.32) 25.66,26.36 CT237.1 ; v2(170.3,32.93) 170,32.63 168.73,32.63 PR410.1 ; v2(232.88,27.19) 233.32,26.76 UV24.5 ; v2(233.14,32.58) 234.21,31.52 RZ518.1 ; RE74.1 RE73.1 v2(242.47,33.56) ; v5(12.57,14.75) 12.13,14.75 10.58,13.2 6.78,13.2 5.47,11.9 4.45,11.9 3.94,11.39 CT238.1 ; v2(19.12,86.5) RC431.2 ; v2(20.66,37.65) 20.21,38.1 RT453.1
  vias: v2(22.29,34.58) v2(22.9,35.16) v2(22.9,34.53) v2(23.54,34.5) v2(64.76,70.08) v2(70.53,37.63) v2(70.53,37.04) v2(70.53,36.41) v2(70.53,35.77) v2(71.29,37.63) v2(71.29,37.04) v2(71.29,36.41) v2(71.29,35.77) v2(72.05,37.65) v2(72.05,37.04) v2(72.05,36.41) v2(72.05,35.77) v2(169.69,49.77) v2(169.69,49.16) v2(195.11,37.59) v2(205.15,38.46) v2(205.41,27.63) v2(205.66,38.16) v2(206.04,27.64) v2(206.22,38.4) v2(206.8,38.46) v2(232.52,32.6) v2(232.69,33.18) v2(233.32,33.18) v2(236.09,34.15) v2(245.79,33.61) v2(246.4,33.61) v2(258.06,51.22) v2(258.67,51.19) v2(259.25,51.19) v2(262.12,69.45) v2(262.7,69.45) v2(264.33,49.49) v2(264.33,48.85) v2(264.84,45.25) v3(179.47,35.38) v3(179.85,35.38) v6(70.73,34.4) v6(206.49,38.97)
+3.3V_ALW2: length 240.4
  TOP w0.254: RE57.2 250.51,64.98 250.74,64.98 v2(251.1,64.62) ; v3(251.48,32.55) 251.25,32.32 v6(251.25,28.77) 251.25,27.68 252.46,26.48 255.69,26.48 v2(255.82,26.6)
  GND1 w0.254: v4(251.83,32.9) 251.83,32.9 v3(251.48,32.55)
  IN1 w0.254: v4(251.83,32.9) 252.04,32.9 254.53,35.39 254.53,39.56 255.36,40.39 255.36,47.27 255.74,47.65 255.74,54.19 256.13,54.57 256.13,56.91 255.01,58.02 255.01,61.02 251.41,64.62 v2(251.1,64.62)
  IN3 w0.254: v4(165.37,31.2) 165.35,31.2 164.71,30.57 160.3,30.57 160.2,30.67 160.19,30.67 158.9,31.96 142.82,31.96 140.79,29.93 115.26,29.93 114.75,29.42 v4(114.75,29.27)
  IN4 w0.254: v2(255.82,26.6) 255.72,26.5 254.87,26.5 254.5,26.87 242.87,26.87 242.28,26.29 231.7,26.29 231.08,26.91 230.24,26.91 229.48,26.15 194.03,26.15 193.32,26.85 188.46,26.85 188.08,26.48 187.86,26.26 179.74,26.26 179.33,26.67 177.96,26.67 177.44,27.18 175.75,27.18 173.98,28.95 170.42,28.95 168.9,30.46 166.11,30.46 v4(165.37,31.2) ; v2(78.43,39.71) 78.68,39.71 79.42,38.97 79.42,31.53 80.38,30.57 92,30.57 92.81,29.75 105.82,29.75 106.83,28.74 114.47,28.74 114.75,29.02 v4(114.75,29.27)
  BOTTOM w0.254: v2(78.43,39.71) 78.36,39.78 PR104.2
+3.3V_ALW_DSW: length 192.1
  TOP w0.076: v6(155.57,50.31) 155.57,49.95 v2(155.24,49.62)
  TOP w0.254: RC439.1 v3(37.58,83.14)
  TOP w0.508: RC214.1 155.16,48.68 RC323.2 155.21,49.59 v2(155.24,49.62)
  GND1 w0.254: v4(36.82,84.13) 37.58,83.37 v3(37.58,83.14)
  GND1 w0.508: v4(154.35,53.17) 154.01,53.51 v3(154.01,53.53)
  IN2 w0.254: v4(159.3,73.41) 159.3,76.29 161.49,78.47 161.49,82.64 164.24,85.4 164.24,88.41 162.65,90 162.65,90.97 v4(161.79,91.83)
  IN3 w0.254: v2(64.18,92.87) 64.18,93.07 65.22,94.12 84.98,94.12 87.29,91.8 88.05,91.8 89.22,90.64 93.53,90.64 96.13,93.23 108.55,93.23 110.63,95.3 143.98,95.3 148.7,90.59 154.33,90.59 155.2,91.45 161.02,91.45 161.4,91.83 v4(161.79,91.83)
  IN4 w0.254: v4(146.22,67.14) 146.23,67.15 146.61,67.15 147.29,67.83 148.43,67.83 148.86,68.26 148.86,69.14 147.92,70.08 147.92,70.75 148.52,71.34 154.87,71.34 156.41,72.89 158.92,72.89 159.3,73.27 v4(159.3,73.41) ; v4(36.82,84.13) 36.14,84.81 36.14,86.19 35.6,86.72 35.6,87.61 37.37,89.38 38.04,89.38 39.96,91.3 46.29,91.3 46.68,90.91 46.68,90.84 47.49,90.03 47.69,90.03 48.87,88.85 56.51,88.85 59.33,91.67 59.33,92.8 60.01,93.48 63.87,93.48 64.18,93.18 v2(64.18,92.87)
  GND5 w0.254: v5(146.71,66.67) 146.23,67.14 v4(146.22,67.14)
  BOTTOM w0.254: UC1.AD18 146.33,68.84 v2(146.4,68.76) UC1.AD17 ; RC241.2 64.18,92.23 v2(64.18,92.87)
  BOTTOM w0.508: RC243.2 RC67.2 154.86,50 v2(155.24,49.62)
+3.3V_ALW_DSW_R: length 9.5
  TOP w0.508: RC439.2 36.16,82.25 v6(34.29,84.12) 33.67,84.74 30.9,84.74 30.29,84.13 QC7.1
+3.3V_ALW_PCH: length 447
  TOP w0.127: 163.42,89.42 v6(163.42,90.42)
  TOP w0.254: v2(158.06,70.32) 157.36,70.32 RC25.2 157.32,70.42 156.47,71.26 RC23.2 ; RC387.2 150.59,67.67 151.05,68.13 153.81,68.13 154.45,68.77 156.66,68.77 ; LC1.1 144.4,67.4 143.85,66.86 v2(143.68,66.86) 143.68,66.27 CC215.1 144.15,65.79 144.8,65.79 CC224.1 ; RC41.1 172.53,52.23 173.13,52.23 173.79,51.57 JSPI1.5 ; v2(156.13,49.59) 156.2,49.67 156.2,51.65 155.82,52.03 RC73.2 ; RC183.2 159.12,49.59 159.12,48.47 158.97,48.32 158.97,48.32 v3(158.62,47.96) 158.56,47.91 RC187.2 ; v2(58.44,92.77) 58.46,92.77 60.52,94.83 v2(77.96,94.83)
  TOP w0.381: v2(146.99,66.22) 146.81,66.04 CC223.1 146.44,66.07 CC224.1
  TOP w0.508: RC12.2 165.47,74.25 v2(165.88,73.85) 166,73.72 166,72.7 165.49,72.2 RC371.2 164.91,72.2 164.05,71.33 v3(163.49,71.33) RC308.1 RC306.1 RC307.1 RC305.1 ; RC503.2 171.25,51.38 171.25,52 171.58,52.33 RC41.1 173.32,53.22 173.32,53.7 173.84,54.22 174.66,54.22 175.3,53.58 175.3,49.85 v2(175.35,49.79) ; RC211.1 172.5,63.15 171.85,62.5 171.85,61.78 172.25,61.38 v2(172.81,61.38) ; v3(156.27,64.6) 156.27,64.6 RC184.2 ; v2(161.81,67.12) 161.71,67.01 RC330.2 161.16,67.02 RC331.2 161.16,68.09 161.09,68.16 RC557.2 ; v3(37.5,84.43) 36.67,83.6 RC440.2 ; v2(161.94,72.53) 161.94,72.27 161.45,71.78 RC400.2 RC17.2 161.14,70.22 RC348.2 ; v2(162.55,76.26) 162.1,75.8 RC14.2 ; RT391.2 RC559.2 39.26,72.09 38.74,72.61 38.74,76.34 v2(38.41,76.67) ; CC209.1 145.08,70.84 v2(145.08,71.22) ; v2(162.22,79) 162.2,78.98 161.25,78.98 RC347.2
  TOP w0.762: 237.84,39.53 233.47,43.9 v2(228.82,43.9)
  GND1 w0.254: v3(158.62,47.96) 158.62,47.46 158.72,47.35 158.72,47.36 v4(158.72,47.36)
  GND1 w0.508: v4(162.68,71.54) 163.28,71.54 v3(163.49,71.33) ; v3(194.85,42.28) 194.85,42.66 195.36,43.16 v4(195.37,43.16) ; v4(157.15,68.34) 157.14,68.34 157.14,68.33 v3(156.66,68.33) ; v3(37.5,84.43) 38.32,84.43 38.36,84.46 v4(38.4,84.46) ; v4(157.06,64.6) v3(156.27,64.6) ; v3(162.93,89.37) 163.16,89.59 v4(163.16,90.21)
  IN1 w0.254: v2(77.96,94.83) 78.86,94.83 79.83,93.86 86.14,93.86 89.35,90.65 91.56,90.65 95.36,94.45 95.95,94.45 115.46,94.45 115.94,94.93 122.14,94.93 122.4,94.67 v4(122.4,94.61)
  IN1 w0.508: v4(38.4,84.46) 38.4,84.92 41.09,87.61 48.91,87.61 50.08,88.78 55.26,88.78 58.44,91.96 v2(58.44,92.77) ; v4(158.72,47.36) 158.12,47.96 157.25,47.96 156.13,49.08 v2(156.13,49.59)
  IN2 w0.508: v2(167.35,65.64) 167.65,65.95 170.53,65.95 173.14,63.34 173.14,61.7 v2(172.81,61.38) ; v4(122.4,94.61) 129.44,94.61 130.88,93.18 130.88,92.06 133.29,89.65 136.9,89.65 138.04,90.79 138.04,92.49 139.23,93.68 145.66,93.68 149.47,89.87 152.8,89.87 v4(154.37,91.45) ; v2(162.55,76.26) 162.55,78.67 v2(162.22,79) 161.99,79.23 161.99,82.43 164.75,85.19 164.75,88.62 v4(163.16,90.21)
  IN3 w0.508: v2(167.35,65.64) 167.05,65.64 165.9,64.48 164.9,64.48 163.97,65.41 v4(162.68,65.41) ; v4(38.4,84.46) 38.4,84.39 37.38,83.37 37.38,81.8 35.48,79.89 35.48,77.71 36.52,76.67 v2(38.41,76.67)
  IN3 w0.762: 177.61,39.81 176.98,39.18 176.98,37.93 176.9,37.85 176.47,37.42 175.82,37.42 175.43,37.8 171.49,37.8 170.1,39.2 169.84,39.2 168.91,40.13 168.91,42.24 168.86,42.29 168.86,42.3 168.43,42.73 168.42,42.73 168.37,42.78 167.82,42.78 167.38,43.23 167.38,44.43 165.02,46.8 164.89,46.8 164.28,47.41 v4(163.8,47.41) 163.53,47.67 159.03,47.67 v4(158.72,47.36) ; 177.61,39.81 v4(177.61,41.44) 177.94,41.77 177.94,44.38 174.85,47.48 174.85,49.28 v2(175.35,49.79) ; 177.61,39.81 178.85,38.58 183.24,38.58 184.71,37.11 v4(186.21,37.11)
  IN4 w0.254: v4(150.51,66.46) 150.51,66.65 150.2,66.95 148.49,66.95 147.77,66.22 v2(146.99,66.22) 146.81,66.4 144.95,66.4 144.52,66.84 143.7,66.84 v2(143.68,66.86) 143.6,66.93 143.6,67.22 144.59,68.21 146.6,68.21 146.93,68.54 146.93,69.37 v2(145.08,71.22)
  IN4 w0.508: v4(154.37,91.45) 154.37,90.59 155.52,89.43 162.39,89.43 v4(163.16,90.21) ; v2(175.35,49.79) 175.35,53.7 173.02,56.04 173.02,61.17 v2(172.81,61.38)
  GND5 w0.508: v5(177.14,41.36) 177.15,41.36 177.16,41.36 177.53,41.36 v4(177.61,41.44) ; v4(163.8,47.41) 164.33,47.41 v5(164.52,47.21) ; v5(196.03,43.87) 195.9,43.75 195.9,43.7 v4(195.37,43.16) ; v4(186.21,37.11) 185.95,36.84 v5(185.95,36.64)
  BOTTOM w0.254: v2(145.08,71.22) UC1.V19 ; RC344.2 155.74,50 156.13,49.61 v2(156.13,49.59) ; UC1.AK17 146.74,65.83 146.99,66.08 v2(146.99,66.22) ; RC222.2 205.78,36.76 207.56,38.54 207.56,39.43 207.43,39.56 ; UC1.AJ21 143.78,66.88 v2(143.68,66.86)
  BOTTOM w0.508: 166.61,64.91 167.02,64.91 167.72,64.21 167.72,63.47 167.43,63.18 RC555.2 RC553.2 ; 166.61,64.91 RC283.2 ; 166.61,64.91 v2(167.35,65.64) ; 206.8,44.41 207.43,43.77 207.43,39.56 ; v2(165.88,73.85) 165.12,74.61 165.12,75.55 164.41,76.26 v2(162.55,76.26) ; RZ368.1 176.63,40.85 v5(177.14,41.36) ; RC133.2 59.34,92.2 58.77,92.77 v2(58.44,92.77)
  BOTTOM w0.762: v2(228.82,43.9) 226.98,43.9 223.93,46.95 222.85,46.95 221.38,48.42 221.38,49.13 220.62,49.89 215,49.89 211.22,46.11 208.2,46.11 206.8,44.71 206.8,44.41 204.77,42.38 204.77,40.98 201.81,38.02 200.48,38.02 200.03,37.58 199.42,37.58 199.32,37.68 199.31,37.68 196.32,40.66 196.32,43.58 v5(196.03,43.87) 195.9,44 195.9,44.79 193.34,47.35 190.7,47.35 189.25,48.8 188.75,48.8 187.83,49.73 187.83,50.52 186.6,51.75 177.31,51.75 v2(175.35,49.79)
+3.3V_ALW_PCH_UZ3: length 2.1
  TOP w0.102: 236.03,38.85 236.03,40.27 v1(235.55,40.75)
+3.3V_ALW_UE1: length 15.5
  TOP w0.254: CE20.1 263.91,53.56 264.58,54.24 264.58,59.4 UE1.G8 ; UE1.K2 v2(259.82,57.04) ; UE1.M9 v2(266.16,55.44) ; RE314.2 257.21,58.91 v3(257.22,58.92) ; UE1.B7 264.57,64.19 v2(264.58,64.19)
  TOP w0.356: v3(257.22,58.92) 259.3,58.92 UE1.H1 ; CE20.1 CE13.1 263.91,51.89 v2(263.82,51.8)
  GND1 w0.508: v3(257.22,58.92) 258.06,58.92 v4(258.07,58.94)
  BOTTOM w0.508: CE14.1 264.52,64.13 v2(264.58,64.19)
  vias: v2(267.58,71.05) v2(268,70.63)
+3.3V_ALW_UZ12: length 17.4
  TOP w0.508: 167.86,48.93 167.51,48.58 167.51,47.86 v6(168.6,46.76) 169.03,46.34 169.03,45.22 171.62,42.63 171.62,41.58 170.05,40 170.05,38.39 v3(169.99,38.34)
  GND1 w0.508: v4(169.81,37.76) 169.81,38.15 v3(169.99,38.34)
  GND5 w0.381: v5(170.07,36.88) 169.81,37.14 v4(169.81,37.76)
  BOTTOM w0.254: UZ12.1 169.88,38.74
  BOTTOM w0.508: 169.88,38.74 169.91,38.72 CZ51.1 169.92,37.82 169.92,37.03 170.07,36.88 v5(170.07,36.88)
+3.3V_ALWP: length 11.9
  TOP w0.127: v2(76.62,37.8) v6(76.62,38.39)
  IN1 w0.254: v2(78.61,42.15) 78.99,41.77 78.99,39.46 79.44,39 79.44,37.07 79.19,36.81 78.38,36.81 78.1,36.53 v2(77.39,36.53)
  BOTTOM w0.254: v2(78.61,42.15) 78.5,42.15 77.44,43.21 PR108.2 77,43.7 PU100.14
  vias: v2(76.62,37.17) v2(76.62,36.53) v2(76.62,35.9) v2(76.62,35.26) v2(76.62,34.63) v2(77.39,37.8) v2(77.39,37.17) v2(77.39,35.9) v2(77.39,35.26) v2(77.39,34.63)
+3.3V_CAM: length 5.6
  TOP w0.127: v2(227.33,37.41) v6(227.33,38.11)
  TOP w0.508: v2(227.33,37.41) 227.33,36.9 226.66,36.23 CV23.1 CV22.1
  BOTTOM w0.254: JEDP1.6 225.75,37.38 226.64,36.5
+3.3V_EC_PLL: length 8.7
  TOP w0.356: CE17.1 256.65,61.17 257.13,61.17 v3(257.22,61.08) 258.45,61.08 258.92,60.61 UE1.F1
  TOP w0.508: RE314.1 254.98,58.91 v3(254.98,58.33)
  GND1 w0.508: v4(255.54,59.09) 255.54,58.91 254.98,58.35 v3(254.98,58.33) ; v4(257.04,61.55) 257.22,61.38 v3(257.22,61.08)
  IN1 w0.508: v4(255.54,59.09) 255.54,60.18 256.91,61.55 v4(257.04,61.55)
+3.3V_HDD_M2: length 0.8
  TOP w0.508: v2(24.96,15.86) 24.55,15.45 RN37.1
  vias: v2(32.5,20.58) v2(32.5,19.95) v2(32.5,19.31) v2(33.14,20.58) v2(33.14,19.95) v2(33.14,19.31) v6(16.34,13.76) v6(29.51,17.71) v6(32,17.79)
+3.3V_M_TPM: length 24.9
  TOP w0.127: v2(175.44,41.76) v1(174.92,41.76)
  TOP w0.254: RZ367.1 v3(164.38,44.66)
  GND1 w0.254: v3(164.38,44.66) 164.3,44.66 v4(163.92,45.04)
  IN2 w0.254: v4(167.66,50) 167.63,50 167.38,49.74 167.38,48.91 168.86,47.43 169.56,47.43 v4(169.66,47.53) 170.5,47.53 172.69,45.35 172.69,44.08 174.97,41.79 175.4,41.79 175.43,41.76 v2(175.44,41.76)
  IN4 w0.254: v4(163.92,45.04) 161.36,47.61 161.36,49.31 v4(161.46,49.41)
  GND5 w0.254: v4(167.66,50) 167.38,50 v5(167.07,49.69) ; v5(168.95,47.28) 169.26,47.28 169.51,47.53 v4(169.66,47.53) ; v4(161.46,49.41) 162.22,49.41 v5(162.38,49.25)
  BOTTOM w0.254: v2(175.44,41.76) 175.4,41.76 175.34,41.7 175.18,41.7 174.72,41.24 RZ368.2 ; CZ60.1 167.07,49.12 v5(167.07,49.69) ; RZ369.2 v5(162.38,49.25)
+3.3V_MMI_IN: length 6.1
  TOP w0.203: UR1.8 276.87,56.19 276.6,55.91 ; UR1.11 278.58,54.82
  TOP w0.254: 278.58,54.82 277.69,53.93 CR30.1
  TOP w0.305: 275.46,54.93 275.61,54.93 276.6,55.91
  TOP w0.508: RR22.1 RR3.1 276.37,62.77 v2(276.37,63.36)
  vias: v2(273.91,53.96) v2(274.49,53.96) v2(276.98,53.04) v2(276.98,52.46) v2(280.64,62.92) v2(281.22,63.56) v2(281.22,62.95) v2(281.83,63.53)
+3.3V_PDA_VOUT: length 2.4
  BOTTOM w0.076: 30.97,70.69 30.97,70.7 30.97,71.28
  BOTTOM w0.127: 30.97,71.28 UT5.H2
  BOTTOM w0.254: CT83.1 30.14,69.71 30.97,70.54 30.97,70.69
+3.3V_PDB_VOUT: length 2.6
  TOP w0.102: v3(26.19,45.03) 27.07,45.03 v1(27.21,44.89)
  GND1 w0.254: v4(25.71,45.07) 25.74,45.03 v3(26.19,45.03)
  GND5 w0.254: v5(26.73,45.12) 25.77,45.12 v4(25.71,45.07)
+3.3V_PGPPB: length 17.7
  TOP w0.254: v2(159.68,66.5) 159.7,66.48 162.04,66.48 162.34,66.79 162.34,67.55 RC305.2
  GND1 w0.254: v3(148.7,66.84) 148.47,67.08 v4(147.79,67.08)
  IN1 w0.254: v2(159.68,66.5) 159.63,66.56 159.63,66.61 159.17,67.06 153.71,67.06 153.62,66.98 147.89,66.98 v4(147.79,67.08)
  GND5 w0.254: v5(148.01,67.5) 148.01,67.3 v4(147.79,67.08)
+3.3V_PGPPC: length 19.2
  TOP w0.254: v1(148.24,70.13) 148.08,69.98 147.8,69.69 CC207.1
  TOP w0.508: CC207.1 147.05,69.96 v2(147.05,70.44)
  GND1 w0.254: v3(162.57,69.55) 162.17,69.55 v4(161.91,69.81)
  IN1 w0.254: v2(147.05,70.44) 148.02,71.41 150.82,71.41 150.88,71.34 156.95,71.34 157.49,70.8 159.14,70.8 159.42,70.52 161.02,70.52 161.74,69.81 v4(161.91,69.81)
  BOTTOM w0.254: v2(147.05,70.44) 147.05,70.44 UC1.Y16
+3.3V_PGPPD: length 16.9
  GND1 w0.254: v3(162.57,68.67) v4(161.86,68.67)
  IN1 w0.254: v4(161.86,68.67) 161.86,68.92 160.72,70.06 159.31,70.06 159.09,69.85 157.89,69.85 156.86,70.88 155.2,70.88 154.52,70.19 152.51,70.19 151.78,70.93 150.81,70.93 150.69,71.05 149.04,71.05 v4(148.42,70.44)
  GND5 w0.254: v5(148.01,70.86) v4(148.42,70.44)
+3.3V_PGPPE: length 27.6
  TOP w0.254: v2(147.05,72.11) 147.05,71.37 CC208.1
  GND1 w0.254: v3(162.57,70.44) v4(161.96,70.44)
  IN1 w0.254: v2(147.05,72.11) 147.04,72.12 145.52,72.12 145.03,72.6 144.09,72.6 143.79,72.91 143.79,73.96 144.25,74.42 148.4,74.42 148.81,74.01 148.81,72.63 149.04,72.4 156.58,72.4 157.21,71.76 160.97,71.76 161.96,70.77 v4(161.96,70.44)
  BOTTOM w0.254: v2(147.05,72.11) UC1.T16
+3.3V_RTC_LDO: length 227.2
  TOP w0.102: v2(257.9,27.09) v6(258.49,27.09)
  IN3 w0.254: v4(164.58,31.2) 164.33,30.95 160.46,30.95 159.06,32.34 142.67,32.34 140.63,30.31 114.98,30.31 114.14,29.47 v4(114.14,29.27)
  IN4 w0.254: v4(164.58,31.2) 165.68,30.11 168.75,30.11 170.27,28.59 173.84,28.59 175.6,26.83 177.29,26.83 177.81,26.31 179.19,26.31 179.6,25.9 188,25.9 188.22,26.12 188.6,26.5 193.17,26.5 193.88,25.79 229.63,25.79 230.39,26.55 230.93,26.55 231.55,25.93 242.43,25.93 243.02,26.52 254.35,26.52 254.94,25.93 256.75,25.93 v2(257.9,27.09) ; v2(79.6,39.76) 79.98,39.76 82.11,41.89 86.08,41.89 87.04,40.94 87.04,39.64 88.34,38.33 88.34,33.92 91.27,31 92.07,31 92.96,30.11 105.96,30.11 106.8,29.27 v4(114.14,29.27)
  BOTTOM w0.254: PD3.3 287.1,22.26 285.66,22.26 281.9,26.02 260.09,26.02 259.34,26.77 258.22,26.77 v2(257.9,27.09) ; PR105.2 79.24,40.11 v2(79.6,39.76)
+3.3V_RUN: length 485.9
  TOP w0.203: 252.6,32.66 UZ5.6 ; RC137.2 62.25,85.58 61.8,86.03 61.8,87.1 v2(61.64,87.26) ; UZ5.7 252.48,32.26
  TOP w0.254: 165.95,65.77 165.95,65.41 165.28,64.74 RPC5.6 ; 165.95,65.77 166.16,65.98 v2(166.16,66.91) ; 165.95,65.77 165.93,65.74 RPC5.8 164.33,65.74 163.82,66.25 RC278.2 ; RC50.2 RC237.2 RC282.2 ; RZ506.2 236.01,62.98 236.01,61.29 235.79,61.07 ; RC282.2 153.95,65.02 153.95,64.13 154.3,63.79 RC190.2 RC51.2 ; RC282.2 153.64,65.79 154.14,65.79 154.37,65.57 v3(154.86,65.57) 154.86,65.81 155.68,66.63 156.51,66.63 156.76,66.89 159.04,66.89 RC402.2 ; RC279.2 173.83,65.13 172.05,66.91 172.05,73.49 v2(174.36,75.8) ; UC8.14 83.31,85.72 83.56,85.47 84,85.47 84.6,86.06 86.03,86.06 CC30.1 ; RC59.2 161.21,50.81 161.21,50.06 v2(161.03,49.88)
  TOP w0.305: LGA1.9 274.79,88.6 276.13,87.27 CZ169.1
  TOP w0.356: v2(226.56,37.42) 226.53,37.42 226.23,37.73 226.23,37.75 CA7.1 ; CZ67.1 192.94,37.93 193.18,37.69 193.18,37.35 v3(193.58,36.96)
  TOP w0.381: QZ10.2 230.15,52.98 v3(230.52,52.61) ; QZ14.5 QZ14.2 227.5,47.66 v2(227.45,47.61) ; QC2.2 v3(153.77,75.78)
  TOP w0.508: RC319.2 162.6,74.79 162.93,75.12 164.2,75.12 v2(164.4,74.91) 167.12,74.91 168.23,76.02 v2(169.66,76.02) ; v2(166.16,66.91) 165.5,66.91 RE51.1 ; CA7.1 223.92,36.1 223.92,34.71 225.23,33.4 227.37,33.4 227.88,32.89 v2(227.88,32.4) v2(227.88,29.04) ; CC30.1 86.25,85.48 85.69,84.92 80.45,84.92 v2(79.81,85.56) ; RD83.2 96.16,48.85 v2(93.9,48.85) ; RE67.2 251.79,70.49 v2(251.46,70.82) ; RC189.2 RC186.2 RC267.2 158.54,53.22 158.53,53.22 158.31,53 158.31,52.84 RC47.2 157.8,52.33 157.62,52.33 157.39,52.11 157.39,51.93 157.27,51.81 v2(157.27,51.77) ; RZ515.2 v2(250.22,82.33) ; RV20.2 30.75,86.95 v2(30.83,86.88) ; v2(174.25,39.16) 174.25,39.82 174.85,40.42 178.14,40.42 178.31,40.6 v2(178.4,40.6) ; v2(233.15,58.43) 235.79,61.07 239.2,61.07 241.58,63.46 v2(241.7,63.46) ; v2(241.7,63.46) 240.43,64.73 237.74,64.73 236.97,65.5 RZ505.2 ; v2(241.7,63.46) 241.67,63.43 241.67,62.24 243.2,60.71 RE555.2 ; RA58.1 v2(296.03,19.57) ; 252.35,30.6 251.93,30.18 251.93,28.43 252.44,27.92 RZ509.1 ; v2(164.43,70.14) 164.73,70.44 RE48.1 ; v2(259.86,51.19) 259.88,51.22 RE557.2
  GND1 w0.254: v3(67.17,78.74) 66.84,79.08 v4(66.74,79.08) ; v4(155.54,65.41) 155.38,65.57 v3(154.86,65.57)
  GND1 w0.381: v4(154.74,75.7) 154.33,75.7 154.25,75.78 v3(153.77,75.78)
  GND1 w0.508: v4(193.06,36.56) 193.18,36.56 v3(193.58,36.96) ; v4(161.84,77.33) 161.84,76.72 v3(161.81,76.69) ; v3(235.94,56.25) v4(235.94,55.48) v3(235.94,54.48) ; v3(230.52,52.61) 230.52,52.91 v4(230.88,53.27) ; v3(230.15,51.37) v4(230.52,51.73)
  IN1 w0.254: v4(66.74,79.08) 66.39,79.43 61.49,79.43 60.55,78.49 v2(60.55,78.44)
  IN1 w0.508: v2(275.43,85.84) 275.43,85.26 274.83,84.67 269.18,84.67 267.74,83.22 256.13,83.22 255.65,82.74 250.63,82.74 v2(250.22,82.33) 249.57,81.68 249.57,80.1 251.38,78.29 251.38,73.36 252.21,72.53 252.21,71.84 251.46,71.09 v2(251.46,70.82) ; v2(169.66,76.02) 170.65,77.01 170.65,77.87 v4(170.45,78.07)
  IN2 w0.381: v2(157.29,74.99) 155.44,74.99 v4(154.74,75.7)
  IN2 w0.508: v4(92.14,35.82) 91.97,35.65 91.97,33 v4(93.6,31.37) ; v4(230.52,51.73) 230.85,52.07 230.85,53.24 v4(230.88,53.27) 230.88,53.55 v2(233.14,55.81) 233.04,55.91 232.9,55.91 232.48,56.33 232.48,57.76 v2(233.15,58.43) 235.63,58.43 235.94,58.11 v4(235.94,55.48) ; v2(241.7,63.46) 241.7,63.57 242.51,64.39 243.52,64.39 244.47,65.34 244.47,66.32 246.03,67.88 246.38,67.88 249.33,70.82 v2(251.46,70.82) ; v2(21.79,79.12) 21.6,79.32 20.88,79.32 18.78,77.22 18.78,75.52 16.74,73.49 v2(16.74,73.3)
  IN3 w0.508: 13.76,57.31 13.76,60.12 15.03,61.39 15.03,63.98 15.71,64.67 15.71,70.14 15.18,70.67 15.18,72.96 15.78,73.56 16.43,73.56 16.44,73.55 16.49,73.55 v2(16.74,73.3) ; v2(157.16,82.46) 159.66,79.96 159.66,77.79 159.12,77.25 158.87,77.25 157.29,75.67 v2(157.29,74.99) ; v4(258.64,42.93) 258.64,41.92 257.5,40.78 257.5,39.31 256.27,38.08 256.27,34.6 253.53,31.86 v2(253.53,31.47) ; v2(93.9,48.85) 92.63,47.58 92.63,43.72 91.53,42.63 91.53,36.43 v4(92.14,35.82) ; v4(34.1,89.52) 34.42,89.84 34.42,90.65 35.7,91.93 45.84,91.93 46.8,90.97 46.8,90.56 47.11,90.26 47.39,89.98 47.39,88.81 48.66,87.54 48.86,87.33 51.77,87.33 53.12,85.99 53.65,85.99 55.54,85.99 56.18,86.62 v2(56.48,86.62) ; v4(193.06,36.56) 193.06,36.81 192.63,37.25 189.2,37.25 v2(188.05,38.39) 186.92,38.39 186.11,39.2 186.11,39.59 185.46,40.25 184.11,40.25 183.65,40.71 v4(182.54,40.71) 181.9,40.71 181.39,41.22 179.02,41.22 v2(178.4,40.6)
  IN4 w0.381: v4(230.52,51.73) 228.43,49.64 227.94,49.64 227.45,49.15 v2(227.45,47.61)
  IN4 w0.508: v2(56.48,86.62) 56.53,86.57 60.95,86.57 v2(61.64,87.26) 62.25,86.64 63.79,86.64 63.97,86.83 71.34,86.83 72.31,87.79 78.12,87.79 79.57,86.35 79.57,85.83 79.81,85.58 v2(79.81,85.56) ; v2(21.79,79.12) 24.93,82.26 24.93,85.07 25.65,85.78 29.68,85.78 30.78,86.88 v2(30.83,86.88) 30.83,86.98 33.34,89.49 34.08,89.49 v4(34.1,89.52) ; v2(296.03,19.57) 296.03,20.38 293.51,22.89 290.19,22.89 288.26,24.82 285.01,24.82 283.38,26.45 266.06,26.45 263.11,29.4 263.11,36.89 v4(262.15,37.85) ; v2(259.86,51.19) 259.86,50.91 258.13,49.18 258.13,47.43 258.61,46.95 258.61,45.63 259.15,45.09 259.15,43.44 v4(258.64,42.93)
  GND5 w0.254: v5(162.59,43.04) v4(161.9,43.04)
  GND5 w0.381: v5(19.79,51.63) 18.8,51.63 v4(18.79,51.65) 18.76,51.62 17.9,51.62 v5(17.89,51.63) 17.52,51.27 v5(16.96,51.27) ; v4(169.23,47.94) 169.21,47.91 v5(168.7,47.91)
  GND5 w0.508: v5(193.39,37.3) 193.39,36.98 193.06,36.65 v4(193.06,36.56) ; v4(34.1,89.52) 33.97,89.66 v5(33.97,90.07) ; v4(182.54,40.71) 183.1,40.15 v5(183.1,40.12) ; v5(171.24,78.9) 170.96,78.9 170.45,78.39 v4(170.45,78.07)
  BOTTOM w0.254: v5(193.39,37.3) 193.39,36.08 192.75,35.44 JUSH1.19 ; v2(226.56,37.42) 226.25,37.73 JEDP1.5 ; v2(56.48,86.62) 56.48,87.26 57.01,87.79 57.8,87.79 58.39,87.2 58.39,86.15 59.24,85.29 59.24,84.88 61.49,82.63 61.9,82.63 62.4,82.13 62.4,81.72 61.99,81.31 61.99,79.87 60.57,78.44 v2(60.55,78.44)
  BOTTOM w0.381: UC12.5 172.84,78.25 172.76,78.17 RC291.2 ; RZ365.2 168.06,47.51 168.47,47.91 v5(168.7,47.91)
  BOTTOM w0.508: v5(171.24,78.9) 171.54,78.9 171.92,78.53 RC291.2 ; JSEN2.1 233.28,55.8 233.27,55.81 v2(233.14,55.81) ; v2(178.4,40.6) 178.33,40.52 RC513.1 ; RC361.2 164.76,72.35 164.25,72.86 RC360.2 RC359.2 RC358.2 164.12,74.63 v2(164.4,74.91) ; RC292.2 164.63,64.6 165.27,65.24 RC403.2 165.27,66.19 165.99,66.91 v2(166.16,66.91) ; RV18.1 16.48,34.73 17.54,33.66 v2(18.14,33.66) ; v2(169.66,76.02) 169.92,75.75 174.31,75.75 v2(174.36,75.8) 174.41,75.75 176.88,75.75 177.44,76.32 RC225.2 ; RZ362.1 173.66,39.67 174.17,39.16 v2(174.25,39.16) ; QZ1.3 228.27,33.2 227.88,32.81 v2(227.88,32.4)
  vias: v2(17.89,35.42) v2(18.08,34.29) v2(18.2,34.88) v2(18.42,39) v2(18.55,38.36) v2(18.64,34.02) v2(18.92,33.5) v2(32.76,23.17) v2(32.78,22.56) v2(33.29,23.48) v2(33.34,22.89) v2(33.93,23.35) v2(33.93,22.72) v2(34.59,23.83) v2(156.53,82.46) v2(167.09,89.44) v2(167.73,89.44) v2(174.22,38.55) v2(252.71,30.79) v2(275.43,86.45) v2(283.61,65.79) v2(283.63,65.16) v2(283.63,64.52) v4(15.02,26.33) v4(15.03,25.71) v4(15.64,25.68) v4(15.65,26.35) v4(16.29,26.35) v4(16.28,25.68) v4(16.92,26.35) v4(16.91,25.68) v4(160.57,31.66) v4(160.77,32.22) v4(161.21,31.66) v4(161.41,32.22) v4(262.17,38.49) v6(34.51,22.65)
+3.3V_RUN_AUDIO: length 4.8
  TOP w0.508: RA18.2 259,41.52 259.5,42.03 v3(259.8,42.03) ; CA68.1 CA67.1
  GND1 w0.508: v3(261.07,37.94) 261.06,37.94 v4(260.65,37.52) ; v3(260.9,42.12) 260.88,42.12 v4(260.46,41.7) 260.45,41.7 260.13,42.03 v3(259.8,42.03) ; v4(262.26,42.49) 262.26,42.26 v3(262.54,41.98)
  vias: v2(258.77,29.3) v2(259.25,29.8) v6(258.58,29.93)
+3.3V_RUN_AUDIO_DVDD: length 4.3
  TOP w0.203: CA10.1 262.38,37.22 v1(262.96,36.63) 263.68,35.92 UA1.4
  TOP w0.356: CA61.1 261.54,37.22 CA10.1 262.07,37.6 261.92,37.75 LA14.2
+3.3V_RUN_AUDIO_IO: length 5.2
  TOP w0.203: UA1.12 263.64,32.72 263.44,32.51 263.44,32.09 v1(263,31.64) 262.29,30.94 CA55.1
  TOP w0.356: CA56.1 261.55,31.23 261.85,30.94 CA55.1
  TOP w0.457: CA56.1 261.27,30.68 LA12.2
+3.3V_RUN_AUDIO_UZ5: length 2.1
  TOP w0.102: 256.9,31.33 257.38,31.33 258.01,31.95 258.2,31.95 v1(258.58,31.57)
+3.3V_RUN_CARD: length 3
  TOP w0.102: 283.81,48.46 283.81,47.94 v6(283.42,47.54)
  TOP w0.203: UR1.12 278.98,55.03
  TOP w0.254: 278.9,53.65 278.9,54.58 278.98,54.66 278.98,55.03
  vias: v2(278.33,52.13) v2(278.91,52.13) v2(283.51,49.49) v2(283.51,48.85)
+3.3V_RUN_UZ3: length 1.5
  TOP w0.508: 21.25,36.03 v1(22.71,36.03)
+3.3V_SPI: length 59
  TOP w0.254: v3(175.56,55.05) 173.96,55.05 172.66,53.76 172.66,53.45 v1(172.53,53.32) 172.06,52.85 v3(171.9,52.85) ; v3(176.39,55.05) 176.57,55.24 176.57,55.51 RC31.2 176.7,55.58 177.18,55.1 178.02,55.1 178.48,55.56 RC30.2 ; v3(171.82,51.76) 172.17,51.42 RC41.2 172.78,51.07 JSPI1.6
  GND1 w0.254: v3(171.82,51.76) 171.82,52.78 v3(171.9,52.85) ; v3(176.39,55.05) v3(175.56,55.05) 175.56,55.56 v4(176.12,56.13)
  IN3 w0.254: v4(147.56,65.44) 148.43,66.3 148.43,66.32 149.06,66.95 150.7,66.95 151.02,66.63 151.02,66.28 151.76,65.54 154.7,65.54 156.63,63.61 164.04,63.61 164.9,62.75 166.78,62.75 167.81,63.77 167.81,64.97 168.07,65.24 168.62,65.24 v4(169.86,63.99) 170.22,63.64 170.22,62.01 v4(169.95,61.74)
  GND5 w0.254: v5(169.57,62.04) 169.58,62.04 169.61,62.01 169.69,62.01 v4(169.95,61.74) ; v4(176.12,56.13) 176.03,56.22 v5(175.38,56.22) ; v4(147.56,65.44) 147.56,66.46 v5(147.36,66.67) ; v5(170.42,63.99) v4(169.86,63.99)
  BOTTOM w0.254: v5(169.57,62.04) 169.44,61.91 169.44,60.81 169.75,60.5 CC10.1 170.08,60.31 170.08,59.28 170.22,59.14 170.22,59.06 170.22,59.06 170.22,58.2 170.84,57.59 UC6.8 172.11,57.59 172.61,57.08 174.19,57.08 175.05,56.22 v5(175.38,56.22) ; UC5.8 170.5,63.3 170.24,63.56 169.97,63.56 169.9,63.63 CC9.1 169.9,63.68 170.21,63.99 v5(170.42,63.99)
+3.3V_TBT: length 69.7
  TOP w0.254: RT337.2 37,68.13 36.21,68.13 35.81,67.73 35.81,67.37 35.02,66.58 RT15.2 ; v2(41.84,69.29) 41.77,69.29 40.39,67.91 v6(40.39,65.2) 40.39,62.71 40,62.32 ; RT14.2 38.78,62.06 39.07,62.35 39.96,62.35 40,62.32 ; RT336.2 40.3,60.16 40.3,62.01 40,62.32
  TOP w0.356: v2(30.75,60.23) 30.28,60.23 CT43.1
  TOP w0.508: v3(38.78,69.2) 38.24,68.67 RT337.2
  GND1 w0.508: v3(29.48,65.49) 29.2,65.21 29.2,64.91 v4(29.13,64.83) ; v4(39.36,69.2) v3(38.78,69.2)
  IN3 w0.508: v4(29.13,64.83) 29.2,64.91 29.2,65.82 28.56,66.46 28.56,67.18 29.86,68.49 30.7,68.49 32.13,69.91 35.73,69.91 36.11,70.29 37.33,70.29 38.42,69.2 v4(39.36,69.2)
  IN4 w0.508: v2(21.73,81.37) 21.73,81.21 20.44,79.92 20.44,71.13 25.82,65.74 27.78,65.74 v4(27.83,65.69) ; v2(30.75,60.23) 30.75,62.41 30,63.16 30,63.52 29.13,64.4 v4(29.13,64.83)
  GND5 w0.254: v5(40.34,69.05) 40.19,69.2 v4(39.36,69.2)
  GND5 w0.508: v4(27.83,65.69) 27.83,65.29 v5(26.87,64.32)
  GND5 w0.762: v4(22.21,56.42) 21.59,56.42 v5(21.38,56.22)
  BOTTOM w0.203: UT1.H9 30.75,60.23 v2(30.75,60.23)
  BOTTOM w0.254: RT13.2 40.91,67.27 41.34,67.7 41.34,68.62 41.18,68.78 40.6,68.78 v5(40.34,69.05) 40.59,69.3 41.83,69.3 v2(41.84,69.29)
  BOTTOM w0.762: LT2.2 21.11,55.95 v5(21.38,56.22)
+3.3V_TBT_FLASH_R: length 18.5
  BOTTOM w0.102: RT1.2 41.06,82.3 v1(40.96,82.4)
  BOTTOM w0.254: RT4.2 RT3.2 RT2.2 41.89,69.96 42.75,70.82 RT9.2 43.34,71.21 43.34,72.92 40.67,75.58 40.67,76.78 42.59,78.7 UT2.8 42.59,80.98 42.61,81.01 CT1.1 RT10.2 41.93,81.47 RT1.2
