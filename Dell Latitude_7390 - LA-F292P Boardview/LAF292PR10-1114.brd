# Allegro board LAF292PR10-1114.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_RUN on BOTTOM (solid shape): 167.98,89.49 167.98,88.99 167.35,88.35 166.49,88.35 161.61,83.47 159.17,83.47 157.98,82.28 156.41,82.28 156.37,82.32 156.37,82.65 156.67,82.95 156.67,84.53 157.19,85.05 157.21,85.06 157.24,85.1 157.26,85.12 158.64,86.5 161.66,86.5 161.81,86.65 163.36,86.65 163.36,86.6 163.37,86.54 163.39,86.49 163.41,86.44 163.44,86.4 163.48,86.36 163.52,86.33 163.57,86.3 163.62,86.28 163.67,86.27 163.72,86.27 163.77,86.27 163.83,86.28 163.88,86.3 163.92,86.33 163.96,86.36 164,86.4 164.03,86.44 164.05,86.49 164.07,86.54 164.08,86.6 164.08,86.65 164.07,86.7 164.05,86.75 164.03,86.8 164,86.85 163.96,86.88 163.92,86.92 163.88,86.94 163.83,86.96 163.77,86.98 163.72,86.98 163.67,86.98 163.62,86.96 163.57,86.94 163.52,86.92 163.48,86.88 163.44,86.85 163.41,86.8 163.39,86.75 163.37,86.7 163.36,86.65 161.81,86.65 165.17,90 167.48,90
+3.3V_RUN on IN1 (solid shape): outline of 1621 points within 31.96,21.55 162.6,33.49
+3.3V_RUN on IN2 (solid shape): outline of 319 points within 270.72,63.46 284.78,86.95
+3.3V_RUN on IN3 (solid shape): outline of 873 points within 11.4,23.96 20.67,57.68
+3.3V_RUN on IN3 (solid shape): outline of 2655 points within 261.87,36.15 285.16,66.38
+3.3V_RUN on VCC: 13.89,13.04 13.89,35.54 14.12,35.77 17.84,35.77 19.22,34.4 19.22,33.34 16.43,30.54 16.43,27.03 17.19,26.27 17.19,25.89 18.35,24.72 31.77,24.72 32.41,25.36 37.48,25.36 37.48,21.31 36.94,20.76 34.84,17.84 37.24,15.17 37.28,15.13 37.48,15.13 37.48,13.04
+3.3V_RUN on VCC: outline of 91 points within 153.59,28.79 262.55,82.76 ; 1 cut-out
+3.3V_RUN_AUDIO on TOP (solid shape): 260.27,30.44 260.27,29.8 260.39,29.68 260.9,29.68 261.03,29.55 261.03,29.04 260.9,28.91 259.28,28.91 258.69,28.33 253.5,28.33 253.08,28.75 253.08,29.22 253.1,29.24 257.18,29.24 258.07,30.13 259.33,30.13 259.76,30.57 260.14,30.57
+3.3V_RUN_AUDIO on IN4 (solid shape): 262.51,42.81 262.51,42.27 261.54,41.3 261.54,39.98 260.9,39.34 260.9,37.09 261.28,36.71 261.28,34.94 260.79,34.62 261.28,34.29 261.28,30.82 259.12,28.66 258.49,28.66 258.11,29.04 258.11,30.31 259.53,31.74 259.53,34.4 259,34.94 259,40.17 259.05,40.26 259.15,40.25 259.71,40.55 259.15,40.84 259.05,40.84 259,40.93 259,41.49 260.57,43.07 262.25,43.07
+3.3V_RUN_AUDIO_UZ5 on TOP (solid shape): 256.49,32.56 256.49,32.54 256.51,32.54 256.58,32.47 256.96,32.47 257.05,32.38 257.05,31.88 257.09,31.88 257.09,30.01 257.03,29.95 256.02,29.95 255.82,30.15 255.82,31.58 255.25,32.15 254.99,32.15 254.93,32.21 254.93,32.7 254.99,32.76 256.3,32.76
+3.3V_RUN_CARD on TOP (solid shape): 279.19,54.31 279.19,52 279.09,51.9 278.17,51.9 278.07,52 278.07,53.83 278.81,54.57 278.93,54.57
+3.3V_RUN_CARD on TOP (solid shape): 283.76,49.62 283.76,49.36 283.89,49.23 285.67,49.23 285.79,49.11 286.94,49.11 287.06,48.98 287.06,48.6 286.94,48.47 285.79,48.47 285.67,48.35 283.63,48.35 283.25,48.73 283.25,49.62 283.38,49.74 283.63,49.74
+3.3V_RUN_CARD on IN2 (solid shape): outline of 196 points within 277.79,48.47 284.27,52.54
+3.3V_RUN_UZ3 on TOP (solid shape): 21.63,36.92 21.63,33.41 21,32.78 21,32.22 20.93,32.15 20.13,32.15 19.69,32.6 19.35,32.6 19.29,32.65 19.29,33.13 20.34,34.17 20.34,34.95 20.29,34.95 20.29,34.95 19.79,34.95 19.78,34.96 19.78,35.4 20.29,35.4 20.29,35.42 20.31,35.42 20.31,36.12 20.29,36.12 20.29,36.15 19.78,36.15 19.78,36.6 20.29,36.6 20.29,36.62 20.31,36.62 20.31,37.28 21.25,37.3
+3.3V_TBT on TOP (solid shape): 22.9,82.07 22.9,81.9 22.78,81.62 22.9,81.33 22.9,81.19 22.9,80.98 23.41,80.48 23.41,80.35 23.18,80.12 22.76,80.12 22.76,80.1 22.53,80.1 22.53,80.12 22.02,80.12 22.02,80.1 21.63,80.1 21.38,80.35 21.38,82 21.51,82.13 22.85,82.13
+3.3V_TBT on BOTTOM (solid shape): 27.64,64.23 27.64,63.55 27.86,63.33 28.06,63.33 28.14,63.25 28.14,63.13 28.36,62.9 28.47,62.9 28.57,62.8 28.57,62.67 28.52,62.62 27.42,62.62 26.28,63.76 24.66,63.76 24.58,63.77 24.49,63.76 21.46,63.76 21.38,63.84 21.38,64.35 21.51,64.47 27.4,64.47
+3.3V_TBT on IN2 (solid shape): 28.01,65.85 28.01,65.66 27.35,65.01 25.47,65.01 23.41,62.95 23.41,57.38 22.95,56.92 22.95,54.82 21.38,54.82 21.25,54.95 21.25,57.49 22.52,58.76 22.52,58.85 22.56,58.89 22.56,64.64 23.92,66 27.86,66
+3.3V_TBT on IN3 (solid shape): 29.51,65.87 29.51,64.73 29.25,64.47 27.73,64.47 27.47,64.73 27.47,65.49 28.36,66.38 29,66.38
+3.3V_TBT_S0 on IN4 (solid shape): outline of 300 points within 30.14,53.43 33.95,58.25
+3.3V_TBT_SX on TOP (solid shape): 25.32,82 25.32,80.98 25.19,80.86 23.41,80.86 23.03,81.24 23.03,82.13 22.52,82.64 22.52,83.02 22.65,83.14 24.17,83.14
+3.3V_TBTA_FLASH on VCC: 28.77,73.24 29.78,72.22 32.45,72.22 36.49,68.18 36.49,65.38 38.02,63.86 38.02,61.83 38.93,60.92 39.9,60.92 40.92,61.93 41.72,61.93 42.61,61.05 43.88,61.05 44.75,60.18 44.75,58 44.75,54.82 44.75,53.78 44.51,53.55 33.55,53.55 33.32,53.78 33.32,59.88 32.91,60.28 31.64,60.28 30.96,60.97 30.25,61.68 28.6,61.68 27.6,62.67 27.6,69.15 26.95,69.81 25.42,69.81 25.2,70.03 25.2,71.59 26.84,73.24
+3.3V_TBTB_FLASH on IN1 (solid shape): outline of 1085 points within 23.67,37.3 28.49,47.2
+3.3V_TP on TOP (solid shape): 173.88,36.38 174.5,36.38 174.71,36.17 174.71,34.85 174.54,34.68 173.04,34.68 172.92,34.81 172.92,36.05 173.25,36.38 173.68,36.38 173.68,36.94 173.88,36.94
+3.3V_TSP on BOTTOM (solid shape): 192.32,37.82 192.32,37.5 192.32,36.58 192.07,36.33 191.31,36.33 191.28,36.36 191.28,36.95 191.47,37.14 191.52,37.14 191.52,37.19 191.66,37.33 191.66,37.72 191.81,37.87 192.27,37.87
+3.3V_TSP_UZ41 on TOP (solid shape): 187.03,37.77 187.7,37.77 187.75,37.72 187.75,36.91 187.62,36.79 185.46,36.79 185.21,37.04 185.21,37.8 185.27,37.87 186.93,37.87
+3.3V_VDD_PIC on TOP (solid shape): 24.05,84.92 24.05,84.03 23.92,83.91 22.52,83.91 22.27,84.16 22.27,84.89 22.78,84.89 22.93,85.05 23.92,85.05
+3.3V_VDD_PIC on TOP (solid shape): 36.26,25.8 36.26,24.42 36.06,24.22 35.41,24.22 34.94,24.69 34.9,24.69 34.89,24.7 34.16,24.7 34.01,24.84 34.01,25.11 34.14,25.24 35.02,25.24 35.69,25.92 36.15,25.92
+3.3V_VDD_PIC on TOP (solid shape): 40.29,90.7 40.29,89.38 39.54,88.63 38.89,88.63 38.84,88.68 38.79,88.71 38.66,88.83 38.66,89.96 38.57,90.05 38.3,90.05 38.22,90.07 38.17,90.08 37.99,90.08 37.93,90.07 37.86,90.05 36.4,90.05 36.32,90.07 36.27,90.08 36.09,90.08 36.03,90.07 35.96,90.05 35.86,90.05 35.78,90.13 35.78,90.53 35.91,90.66 38.98,90.66 39.12,90.8 40.19,90.8
+3.3V_VDD_PIC on BOTTOM (solid shape): 21.84,38.82 21.84,37.89 21.63,37.68 21.19,37.68 20.73,38.14 20.73,38.82 20.82,38.92 21.74,38.92
+3.3V_VDD_PIC on IN2 (solid shape): outline of 230 points within 38.02,87.72 48.81,92.16
+3.3V_VDD_PIC on IN2 (solid shape): outline of 288 points within 21,36.03 28.11,39.2
+3.3V_VDD_PIC_PDA on TOP (solid shape): 42.59,90.98 42.59,90 42.42,89.83 40.9,89.83 40.59,90.14 40.59,91.6 40.73,91.74 41.83,91.74
+3.3V_VDD_PIC_PDA on BOTTOM (solid shape): 33.81,71.15 33.81,70.87 34.28,70.4 35.07,69.6 35.07,68.97 34.99,68.89 34.49,68.89 34.28,69.1 34.28,69.73 33.59,70.42 33.59,70.52 33.65,70.62 33.64,70.73 33.63,70.74 33.63,71.15 33.64,71.16 33.79,71.16
+3.3V_VDD_PIC_PDA on IN2 (solid shape): 42.26,91.12 42.26,89.95 42.08,89.77 41.32,89.77 41.14,89.95 41.14,91.14 41.22,91.22 42.16,91.22
+3.3V_VDD_PIC_PDB on BOTTOM (solid shape): 26.38,42.15 26.38,42.1 26.19,41.91 25.94,41.91 25.71,41.68 25.69,41.67 25.58,41.64 25.5,41.57 25.43,41.44 25.42,41.3 25.41,41.22 25.34,41.17 24.87,40.7 23.59,40.7 23.31,40.42 23.31,39.25 23.26,39.2 22.72,39.2 22.72,39.2 21.46,39.2 21.4,39.26 20.81,39.26 20.75,39.2 19.98,39.2 19.77,39.42 19.77,39.98 19.92,40.13 21.49,40.13 22.42,41.06 22.83,41.06 23.27,41.5 24.8,41.5 25.49,42.19 25.77,42.19 25.81,42.19 25.85,42.21 26.32,42.21
+3.3V_WLAN on TOP (solid shape): 230.24,36.08 230.24,35.54 229.71,35.54 229.71,35.03 230.24,35.03 230.24,34.74 229.71,34.74 229.71,34.23 230.24,34.23 230.24,33.79 230.17,33.71 228.52,33.71 227.12,35.11 227.12,35.9 227.68,36.46 229.86,36.46
+3.3V_WLAN on TOP (solid shape): 241.66,57.7 242.23,57.13 243.01,57.33 243.08,57.36 243.15,57.33 243.28,57.2 243.27,57.11 243.27,57.03 243.4,56.51 243.77,56.13 243.77,55.6 243.54,55.37 243.51,55.38 242.97,55.26 242.85,54.72 242.86,54.69 242.61,54.44 240.12,54.44 240.02,54.54 240.02,55 239.69,55.33 239.69,57.62 239.82,57.74 241.65,57.74
+3.3V_WLAN on TOP (solid shape): 242.87,38.89 242.87,38.87 243.07,38.52 243.46,38.46 243.47,38.46 243.53,38.46 243.76,38.24 243.76,37.66 243.5,37.44 243.33,37.15 243.3,37.05 243.28,36.96 243.28,36.92 242.73,36.92 242.72,36.92 242.44,36.95 242.16,36.92 242.11,36.92 242.08,36.89 241.7,36.65 241.45,36.27 241.45,36.26 241.22,36.03 240.66,36.03 239.69,36.03 239.62,36.1 237.99,36.1 237.81,35.92 236.8,35.92 236.7,36.02 236.72,36.05 236.72,37.09 236.76,37.1 237.01,37.33 236.96,37.66 237.2,37.91 238.42,37.91 238.45,37.93 240.99,37.93 241.98,38.92 242.84,38.92
+3.3V_WLAN on IN2 (solid shape): 242.89,38.78 243.1,38.5 243.45,38.46 243.48,38.47 243.76,38.19 243.76,37.66 243.49,37.43 243.32,37.12 243.12,36.92 242.73,36.92 242.72,36.92 242.44,36.95 242.16,36.92 242.15,36.92 241.72,36.92 241.22,36.41 236.9,36.41 236.52,36.79 236.52,36.99 236.55,37.07 236.63,37.09 236.99,37.29 236.93,37.69 236.9,37.76 236.93,37.84 237.03,37.93 238.93,37.93 239.31,37.55 240.07,37.55 241.34,38.82 242.88,38.82
+3.3V_WLAN on IN3 (solid shape): outline of 749 points within 237.91,36.94 243.77,57.11
+3.3V_WLAN on IN4 (solid shape): outline of 321 points within 226.99,33.74 239.69,41.27
+3.3V_WLAN on VCC: 236.11,36.15 235.25,37.02 235.25,39.1 237.91,41.76 237.91,53.95 238.4,54.44 239.04,54.44 241.7,57.11 243.28,57.11 243.38,56.55 243.77,56.13 243.77,37.67 243.47,37.4 243.3,37.04 241.62,37.04 240.73,36.15
+3.3V_WLAN_UZ2 on TOP (solid shape): 232.96,38.06 232.96,37.04 233.53,36.47 233.53,35.71 233.47,35.65 232.58,35.65 232.45,35.52 232.45,33.99 232.12,33.66 230.55,33.66 230.37,33.85 230.37,34.34 230.37,34.36 229.84,34.36 229.84,34.61 230.37,34.61 230.37,34.63 230.37,35.14 230.37,35.16 229.84,35.16 229.84,35.41 229.92,35.41 230.39,35.41 230.39,37.9 230.61,38.12 232.9,38.12
+3.3V_WWAN on TOP (solid shape): 215.82,45.3 215.82,43.73 212.18,40.09 210.48,40.09 210.15,40.42 210.15,41.42 210.68,41.42 210.68,42.13 210.15,42.13 210.15,42.62 210.68,42.62 210.68,43.33 210.15,43.33 210.15,43.93 210.3,44.08 211.47,44.08 213.07,45.68 215.44,45.68
+3.3V_WWAN on TOP (solid shape): 233.09,88.6 233.09,88.1 232.96,87.97 232.58,87.97 232.07,87.46 231.69,87.46 230.93,86.7 229.66,86.7 229.41,86.95 229.41,87.46 228.77,88.1 228.51,88.1 228.26,88.2 228.01,88.1 226.1,88.1 225.98,88.22 225.98,88.86 226.1,88.99 230.29,88.99 230.75,89.44 230.78,89.42 230.99,89.4 231.18,89.49 232.2,89.49
+3.3V_WWAN on TOP (solid shape): 231.48,71.8 231.93,71.44 232.38,71.8 232.39,71.84 232.96,71.84 233.17,71.63 233.17,70.17 232.8,69.8 232.67,69.3 232.61,69.2 232.51,69.22 232.21,69.39 231.88,69.45 230.88,68.84 231.06,67.69 231.16,67.59 231.27,67.51 231.27,65.87 231.14,65.74 228.52,65.74 228.4,65.86 228.4,66.5 228.43,66.51 228.66,66.75 228.59,67.07 228.57,67.14 228.6,67.2 228.64,67.67 228.19,67.77 228.13,67.8 228.05,67.81 228.01,67.86 228.01,68.55 228.18,68.72 228.18,69.55 228.23,69.64 228.33,69.64 228.84,70 228.26,70.23 228.21,70.23 228.18,70.27 228.18,70.36 228.46,70.64 228.55,70.67 228.62,70.61 229.2,70.5 229.09,71.07 229.03,71.15 229.06,71.24 229.15,71.33 229.15,71.59 229.4,71.84 231.47,71.84
+3.3V_WWAN on BOTTOM (solid shape): 240.27,65.93 240.3,65.85 240.26,65.77 240.23,65.24 240.76,65.27 240.84,65.31 240.91,65.28 240.96,65.24 240.96,60.28 240.58,59.9 238.42,59.9 238.33,60 238.33,62.55 238.37,62.63 238.45,62.65 238.73,62.76 238.7,63.06 238.67,63.1 238.8,63.23 238.8,63.81 238.04,64.58 238.04,65.36 237.66,65.74 237.66,66.51 237.79,66.63 239.57,66.63
+3.3V_WWAN on IN2 (solid shape): outline of 375 points within 158.28,26.76 172.61,30.7
+3.3V_WWAN on VCC: 213.13,44.15 211.88,45.4 211.88,49.81 213.93,51.06 215.84,52.51 215.99,52.59 216.15,52.62 216.31,52.59 216.45,52.52 217.89,51.75 219.5,51.48 224.25,54.88 222.57,60.46 222.43,60.58 222.25,60.84 222.28,61.15 223.73,65.73 224.22,70.5 224.22,75.8 224.22,75.83 224.22,92.28 226.64,92.28 228.92,90 230.95,90 231.33,89.62 232.68,89.62 232.78,89.05 233.17,88.63 233.17,70.17 232.71,69.04 233.68,68.29 239.95,68.29 239.95,65.47 239.46,64.98 235.4,64.98 230.67,60.26 230.67,50.48 228.08,47.89 227.65,47.46 222.06,47.46 219.9,45.3 217.11,45.3 215.96,44.15
+3.3V_WWAN_UZ4 on TOP (solid shape): 210.02,43.96 210.02,43.2 210.55,43.2 210.55,42.75 210.02,42.75 210.02,42 210.55,42 210.55,41.55 210.02,41.55 210.02,40.39 209.59,39.96 205.71,39.96 205.3,40.37 204.23,40.37 204.18,40.42 204.18,42.07 204.13,42.12 204.13,42.45 204.23,42.55 204.67,42.55 204.87,42.76 207.05,42.76 208.32,44.03 209.96,44.03
+5V_ALW on TOP (solid shape): 48.81,68.82 48.81,67.01 49.7,66.13 49.7,64.47 49.57,64.35 45.64,64.35 45.36,64.63 45.36,68.82 45.56,69.02 48.61,69.02
+5V_ALW on TOP (solid shape): 28.39,80.15 28.39,78.52 27.86,78.52 27.86,77.78 28.41,77.78 28.41,77.33 27.86,77.33 27.86,76.59 28.41,76.59 28.41,75.29 28.29,75.17 28.24,75.17 27.96,74.89 26.59,74.89 26.33,75.14 26.33,80.1 26.47,80.23 27.08,80.23 27.09,80.25 28.29,80.25
+5V_ALW on TOP (solid shape): 202.79,39.04 202.79,38.31 203,38.1 203,37.23 204.13,36.09 204.13,30.82 203.37,30.06 203.37,28.1 202.66,27.39 201.08,27.39 200.96,27.52 200.96,27.77 200.96,30.31 202.61,31.96 202.61,36.23 201.47,37.37 201.44,37.4 201.44,38.59 201.95,39.1 202.73,39.1
+5V_ALW on TOP (solid shape): 268.4,77.71 268.4,76.54 268.52,76.41 268.52,75.04 268.67,74.89 269.04,74.89 269.13,74.79 269.13,74.53 269.06,74.46 268.11,74.46 267.68,74.89 267,74.89 266.74,74.63 266.74,74.19 266.74,74.19 266.74,73.49 266.62,73.36 266.06,73.36 265.94,73.48 265.94,74.15 266.11,74.32 266.11,75.14 266.62,75.65 266.62,77.5 266.92,77.81 268.3,77.81
+5V_ALW on TOP (solid shape): 34.15,42.06 34.15,40.56 34.06,40.47 33.3,40.47 33.11,40.66 33.11,40.68 33.11,40.78 33.08,40.87 33.08,40.88 33.08,41.52 33.04,41.56 32.38,41.56 32.38,42.12 31.64,42.12 31.64,41.56 31.18,41.56 31.18,42.12 30.45,42.12 30.45,41.56 29.91,41.56 29.91,42.78 30.29,43.16 33.05,43.16
+5V_ALW on TOP (solid shape): 23.17,29.47 23.17,28.11 22.85,27.8 20.97,27.8 20.74,27.57 20.74,25.73 20.67,25.65 20.16,25.65 19.7,26 19.53,25.44 19.56,25.4 19.23,25.08 17.19,25.08 16.88,25.38 16.88,26.76 18.36,28.23 18.45,28.26 18.53,28.2 19.11,28.07 18.98,28.65 18.92,28.73 18.95,28.82 19.74,29.61 23.03,29.61
+5V_ALW on BOTTOM (solid shape): 86.06,50.1 87.13,50.1 87.21,50.02 87.21,49.89 87.1,49.77 85.26,49.77 85.23,49.8 85.23,50.36 85.25,50.38 85.77,50.38
+5V_ALW on BOTTOM (solid shape): 89.9,66.38 89.9,64.66 89.84,64.61 89.31,64.61 89.27,64.65 89.27,65.59 88.99,65.87 88.05,65.87 87.99,65.93 87.99,66.09 88.1,66.19 89.02,66.19 89.25,66.42 89.86,66.42
+5V_ALW on BOTTOM (solid shape): 19.18,27.07 19.18,26.12 18.84,25.78 18.59,25.78 18.57,25.78 18.18,25.76 17.99,25.42 17.99,25.19 17.99,25.15 17.99,25.11 17.68,24.8 16.39,24.8 16.11,25.08 16.11,26.32 16.96,27.17 17.89,27.17 17.89,27.18 18.59,27.18 18.7,27.29 18.97,27.29
+5V_ALW on IN2 (solid shape): outline of 2944 points within 33.06,35.52 55.94,69.43
+5V_ALW on GND1: 26.13,78.57 25.7,79 25.7,79.15 26.13,79.59 26.66,79.59 26.84,79.41 26.84,78.75 26.66,78.57
+5V_ALW on VCC: outline of 169 points within 16.93,22.52 299.98,84.25 ; 2 cut-outs
+5V_ALW on VCC: 44.6,61.05 44.09,61.55 42.82,61.55 41.93,62.44 40.7,62.44 39.69,61.43 39.14,61.43 38.52,62.04 38.52,64.07 37,65.6 37,68.39 32.66,72.73 29.99,72.73 28.98,73.75 25.95,73.75 25.63,74.07 25.63,80.56 26.18,81.11 45.02,81.11 45.26,80.88 45.25,78.08 46.29,77.05 47.18,77.05 47.41,76.81 47.41,69.58 48.18,68.81 48.18,64.33 44.9,61.05
+5V_ALW2 on BOTTOM (solid shape): 55.67,70.06 55.67,69.17 54.91,69.17 54.53,69.55 53.88,69.55 53.35,70.09 53.35,70.24 53.41,70.3 55.43,70.3
+5V_ALW_PDA on TOP (solid shape): outline of 108 points within 27.98,75.4 35.48,79.08
+5V_ALW_PDA on BOTTOM (solid shape): 35.22,76.67 35.22,76.41 34.97,76.16 34.59,76.16 34.33,75.9 32.68,75.9 32.61,75.98 32.61,76.39 32.76,76.54 33.44,76.54 33.7,76.79 35.09,76.79
+5V_ALW_PDA on IN1 (solid shape): 35.35,77.3 35.35,76.29 35.22,76.16 32.68,76.16 32.3,75.78 30.73,75.78 30.55,75.95 30.55,76.79 30.68,76.92 30.82,76.92 31.09,76.8 31.36,76.92 31.54,76.92 32.17,77.56 35.1,77.56
+5V_ALW_PDA on GND1: 33.75,76.29 33.57,76.46 33.57,77.63 34,78.06 34.92,78.06 35.35,77.63 35.35,76.46 35.17,76.29
+5V_ALW_PDA on GND5: 32.67,75.89 32.61,75.96 32.61,76.41 32.78,76.58 33.35,76.58 33.57,76.8 33.57,77.26 33.71,77.4 35.12,77.4 35.28,77.25 35.28,76.41 35.02,76.16 34.56,76.16 34.29,75.89
+5V_ALW_PDB on TOP (solid shape): 31.06,41.44 31.77,41.44 31.77,42 32.25,42 32.25,41.44 32.91,41.44 32.91,41.41 32.94,41.39 32.94,40.93 32.95,40.91 32.95,40.64 33.24,40.34 33.52,40.34 33.65,40.22 33.65,39.84 33.57,39.76 30.69,39.76 29.89,40.56 29.89,41.44 30.57,41.44 30.57,42 31.06,42
+5V_ALW_PDB on BOTTOM (solid shape): 31.82,42.86 31.84,42.81 31.87,42.78 31.92,42.72 31.92,42.2 33.09,41.03 33.06,40.99 33.09,40.52 33.57,40.5 33.63,40.53 33.7,40.5 33.96,40.42 34.2,40.55 34.28,40.55 34.62,40.22 37.18,40.22 37.31,40.08 37.31,38.85 37.16,38.69 35.68,38.69 35.68,38.69 30.78,38.69 30.52,38.95 30.52,40.22 31.03,40.73 31.03,43.14 31.11,43.22 31.46,43.22
+5V_ALW_PDB on IN3 (solid shape): outline of 474 points within 29.76,39.71 35.09,45.81
+5V_ALWP on TOP (solid shape): 46.3,63.94 46.3,63.79 46.5,63.59 50.13,63.59 50.33,63.38 50.33,62.16 49.98,61.81 49.45,61.81 49.45,61.3 49.34,61.19 48.96,61.19 48.81,61.04 48.81,60.6 48.74,60.54 48.18,60.54 48.05,60.66 48.05,61.55 47.92,61.68 47.49,61.68 47.11,62.06 46.65,62.06 46.43,61.84 46.43,60.64 46.32,60.54 44.75,60.54 44.49,60.79 44.49,63.97 44.62,64.09 46.14,64.09
+5V_ALWP on BOTTOM (solid shape): 48.81,64.09 49.86,63.04 49.86,62.23 49.45,61.81 49.45,61.3 49.34,61.2 48.96,61.2 48.81,61.05 48.81,60.62 48.76,60.57 48.14,60.57 48.05,60.66 48.05,61.68 47.92,61.81 47.59,61.81 47.37,62.03 46.64,62.03 46.4,61.78 46.4,60.56 46.37,60.54 44.75,60.54 44.62,60.66 44.62,63.85 44.93,64.17 46.02,64.17 46.25,64.4 46.25,66.86 46.4,67.01 48.81,67.01
+5V_PD_VDD on TOP (solid shape): 31.79,33.74 31.79,30.76 31.36,30.32 31.35,30.32 31.35,30.31 31.09,30.06 31.09,27.87 30.8,27.58 30.8,25.5 31.07,25.23 31.83,25.23 31.94,25.13 31.94,24.84 31.83,24.74 28.21,24.74 28.15,24.8 28.15,25.77 28.23,25.85 29.55,25.85 29.99,26.3 29.99,28.69 29.84,28.84 28.75,28.84 28.64,28.94 28.64,29.26 28.81,29.42 29.3,29.42 29.38,29.5 29.41,29.5 29.41,29.52 29.62,29.74 29.62,30.27 30.28,30.93 30.27,30.95 30.27,33.74 30.52,33.99 31.54,33.99
+5V_RUN on TOP (solid shape): 253,36.61 253.54,36.61 253.54,37.17 253.79,37.17 253.79,36.61 254.27,36.61 254.27,35.75 253.64,35.13 253.64,34.22 253.58,34.15 251.46,34.15 250.96,34.65 250.96,35.1 251.48,35.61 252.07,36.2 252.07,36.49 252.19,36.61 252.72,36.61 252.72,37.17 253,37.17
+5V_RUN on TOP (solid shape): 200.09,42.99 200.09,42.63 199.53,42.63 199.53,42.12 199.54,42.11 200.09,42.11 200.09,41.82 199.54,41.82 199.53,41.82 199.53,41.31 200.07,41.31 200.07,40.85 200.19,40.73 201.72,40.73 201.97,40.47 201.97,39.58 201.29,38.9 201.29,37.37 202.48,36.18 202.48,32.09 202.23,31.84 200.7,31.84 200.45,32.09 200.45,35.39 199.37,36.47 199.37,39.47 197.78,41.06 197.78,41.11 196.77,42.12 196.77,43.65 196.89,43.77 199.31,43.77
+5V_RUN on IN3 (solid shape): outline of 393 points within 162.86,31.99 176.32,34.38
+5V_RUN on IN3 (solid shape): outline of 576 points within 200.7,30.96 239.31,37.08
+5V_RUN on IN4 (solid shape): outline of 141 points within 192.45,37.93 200.32,39.91
+5V_RUN on IN4 (solid shape): outline of 766 points within 236.01,31.07 253.15,36.27
+5V_RUN_AUDIO on TOP (solid shape): 272.2,46.06 272.2,44.66 272.08,44.54 271.06,44.54 270.93,44.41 270.93,43.65 270.67,43.39 269.28,43.39 269.03,43.65 269.03,44.79 270.05,45.81 270.05,46.03 270.31,46.29 270.86,46.29 270.86,46.31 271.02,46.31 271.95,46.31
+5V_RUN_AUDIO on TOP (solid shape): 254.04,39.71 254.14,39.71 254.14,39.66 254.6,39.66 254.87,39.39 254.97,39.31 255.09,39.28 255.11,39.28 255.82,38.57 256.46,38.57 256.71,38.31 256.71,38.06 256.84,37.93 258.08,37.93 258.23,37.78 258.23,36.33 258.13,36.23 256.74,36.23 256.74,36.79 256.28,36.79 256.28,36.23 256,36.23 256,36.66 255.92,36.74 253.94,36.74 253.94,37.3 253.41,37.3 253.41,36.74 253.13,36.74 253.13,37.3 252.6,37.3 252.6,36.74 252.24,36.74 252.11,36.86 252.11,38.62 252.14,38.64 252.14,38.69 252.2,38.76 252.65,38.76 252.65,38.95 252.8,38.95 253.15,39.17 253.09,39.58 253.08,39.61 253.09,39.65 253.23,39.78 253.34,39.78 253.39,39.84 253.92,39.84
+5V_RUN_AUDIO on BOTTOM (solid shape): outline of 109 points within 256.2,36.33 272.15,46.69
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): 256.61,36.1 257.07,36.1 257.09,36.08 257.09,34.97 257.05,34.97 257.05,34.45 256.96,34.36 256.45,34.36 256.24,34.15 254.99,34.15 254.93,34.22 254.93,34.88 256,35.95 256,36.1 256.41,36.1 256.41,36.66 256.61,36.66
+5V_RUN_PVDD_L on TOP (solid shape): 268.65,44.74 268.65,43.52 268.39,43.27 267.02,43.27 266.87,43.11 266.87,42.05 267.07,41.84 269.08,41.84 269.21,41.72 269.21,40.93 269.11,40.83 268.83,40.83 268.7,40.7 268.7,40.24 269.03,39.91 269.03,39.46 267.89,38.31 267.89,37.56 267.83,37.51 267.7,37.51 267.65,37.56 267.65,38.43 268.36,39.14 268.36,39.16 268.36,40.06 268.36,40.06 268.36,40.17 268.18,40.34 267.79,40.34 267.67,40.23 267.67,40.17 267.55,40.17 267.54,40.18 267.21,40.18 267.2,40.17 266.18,40.17 265.6,39.58 265.6,38.69 265.9,38.39 265.9,37.55 265.85,37.5 265.68,37.5 265.65,37.52 265.65,38.39 264.46,39.58 264.46,39.91 264.48,39.91 264.48,40.37 264.97,40.85 265.45,41.33 265.45,44.2 266.06,44.81 268.57,44.81
+5V_RUN_UZ4 on TOP (solid shape): 201.64,42.5 202.1,42.5 202.2,42.4 202.2,42.12 202.25,42.07 202.25,42.02 202.31,42.02 202.4,41.92 202.63,41.92 202.79,41.77 202.79,40.45 202.73,40.39 202.24,40.39 202.18,40.45 202.18,40.64 201.87,40.95 200.2,40.95 200.2,41.44 199.66,41.44 199.66,41.69 200.22,41.69 200.22,42.25 199.66,42.25 199.66,42.5 200.22,42.5 200.22,42.99 201.16,42.99
+5V_TBT_VBUS on TOP (solid shape): 28.62,35.01 28.62,34.12 28.74,33.99 29.38,33.99 29.51,33.87 29.51,33.11 29.38,32.98 27.47,32.98 27.22,32.72 24.68,32.72 24.3,33.11 24.3,33.93 24.62,34.25 27.09,34.25 27.8,34.96 27.8,35.01 27.93,35.14 28.49,35.14
+5V_USB_CHG_PWR on TOP (solid shape): 273.32,75.02 273.32,74.23 273.22,74.13 272.93,74.13 272.79,74.27 272.7,74.27 272.51,74.46 271.42,74.46 271.32,74.56 271.32,75.78 271.57,76.03 272.31,76.03
+5V_USB_CHG_PWR on TOP (solid shape): 289.03,59.45 289.03,59.08 289.68,59.08 289.68,58.93 290.29,58.93 290.65,58.93 291.47,58.93 291.47,59.63 291.62,59.78 294.17,59.78 294.68,59.27 294.68,55.58 294.43,55.33 291.76,55.33 291.51,55.58 291.51,56.22 291.25,56.47 287.44,56.47 287.06,56.85 287.06,59.52 287.32,59.78 288.7,59.78
+5V_USB_CHG_PWR on IN1 (solid shape): outline of 500 points within 271.32,56.6 289.73,76.16
+5V_USB_CHG_PWR on IN2 (solid shape): 287.89,66.97 288.11,66.51 288.59,66.34 288.59,65.82 288.53,65.74 288.48,65.66 287.99,65.35 287.93,64.77 288.06,64.56 288.26,64.4 288.39,64.01 288.61,63.65 289.08,63.24 289.66,63.01 289.7,63.01 289.7,62.55 289.83,61.87 290.22,61.3 290.79,60.91 291.47,60.78 292.54,60.78 295.06,58.25 295.06,56.08 294.75,55.75 294.73,55.29 294.74,55.26 294.43,54.95 291.64,54.95 289.73,56.85 289.73,57.62 285.92,61.43 285.92,66.89 286.05,67.01 287.89,67.01
+5V_USB_CHG_PWR on IN4 (solid shape): outline of 158 points within 285.92,54.95 295.06,67.01
+VCC_1P8 on TOP (solid shape): 150.84,72.22 151.98,72.22 152.11,72.09 152.11,71.59 151.98,71.46 150.84,71.46 150.61,71.23 150.61,71 150.56,70.95 150.03,70.95 149.98,71.01 149.98,71.38 149.59,71.77 149.59,71.97 149.73,72.11 150.34,72.11 150.57,72.34 150.72,72.34
+VCC_CORE on TOP (solid shape): 134.71,65.06 135.94,65.06 136.14,64.86 136.14,64.54 136.02,64.42 134.64,64.42 134.38,64.17 134.03,64.17 134,64.19 134,64.55 134.13,64.68 134.13,65.11 134.18,65.16 134.61,65.16
+VCC_CORE on TOP (solid shape): outline of 120 points within 95.42,67.86 104.97,80.9
+VCC_CORE on TOP (solid shape): outline of 1340 points within 129.84,66.07 140.17,82.25
+VCC_CORE on BOTTOM (solid shape): outline of 86 points within 96.71,64.45 104.97,85.37
+VCC_CORE on BOTTOM (solid shape): outline of 312 points within 133.16,64.5 138.12,67.45
+VCC_CORE on BOTTOM (solid shape): outline of 858 points within 131.39,74.96 138.9,77.86
+VCC_CORE on IN1 (solid shape): outline of 1116 points within 131.36,67.52 139.74,76.21
+VCC_CORE on IN2 (solid shape): outline of 7032 points within 98.39,63.71 138.7,80.97
+VCC_CORE on IN3 (solid shape): outline of 8498 points within 98.34,61.05 138.98,80.71
+VCC_CORE on GND3: 102.76,61.05 101.11,62.7 98.25,62.7 96.7,64.25 96.7,77.75 98.53,79.59 100.48,79.59 103.27,82.38 108.52,82.38 113.35,77.56 121.22,77.56 121.86,76.92 131.97,76.92 132.63,77.58 132.63,78.72 132.99,79.08 138.88,79.08 139.23,78.72 139.23,77.41 138.6,76.77 138.6,75.8 139.11,75.29 139.11,69.15 138.6,68.64 138.6,65.98 138.24,65.62 124.27,65.62 124.02,65.36 115.13,65.36 112.97,63.2 111.57,63.2 111.04,62.67 111.04,61.91 110.17,61.05
+VCC_CORE on VCC: 98.53,79.59 100.48,79.59 102,81.11 104.63,81.11 107.84,76.83 110.37,81.55 111.19,80.73 116.9,80.73 118.43,79.21 137.36,79.21 138.09,78.58 138.09,77.32 138.6,76.81 138.6,75.8 139.11,75.29 139.11,69.15 138.6,68.64 138.6,65.96 138.25,65.62 124.27,65.62 124.02,65.36 115.13,65.36 112.97,63.2 111.57,63.2 111.04,62.67 111.04,61.91 110.17,61.05 98.35,61.05 96.71,62.69 96.71,77.76
+VCC_GT on TOP (solid shape): outline of 1652 points within 99.73,53.04 127.35,82.62
+VCC_GT on BOTTOM (solid shape): outline of 1899 points within 99.73,53.04 126.1,77.05
+VCC_GT on IN1 (solid shape): outline of 2467 points within 99.18,54.49 125.77,76.41
+VCC_GT_+VCC_CORE on TOP (solid shape): outline of 99 points within 124.91,65.64 131.36,76.49
+VCC_GT_+VCC_CORE on BOTTOM (solid shape): outline of 346 points within 126.26,74.94 131.31,76.94
+VCC_GT_+VCC_CORE on BOTTOM (solid shape): outline of 636 points within 124.91,64.97 132.63,67.42
+VCC_GT_+VCC_CORE on IN1 (solid shape): outline of 252 points within 124.81,66.1 131.49,76.21
+VCC_GT_+VCC_CORE on IN4 (solid shape): 127.62,76.67 127.67,76.63 127.65,76.58 127.55,76.48 127.52,76.49 127.12,75.93 127.75,76.21 127.75,76.24 128.17,76.67 131.23,76.67 131.36,76.54 131.36,76.03 131.18,75.72 131.36,75.4 131.36,75.02 130.6,74.25 126.66,74.25 125.94,74.97 125.92,75.06 125.97,75.13 126.15,75.45 125.94,75.76 125.89,75.83 125.91,75.92 125.95,76.26 125.68,76.48 125.6,76.55 125.63,76.65 125.65,76.67
+VCC_GTUS on BOTTOM (solid shape): outline of 478 points within 121.88,64.86 126.66,66.76
+VCC_SA on TOP (solid shape): 97.28,52.49 99.34,52.49 99.46,52.37 99.46,51.52 99.56,51.42 101.24,51.42 101.31,51.35 101.31,50.24 101.12,50.06 99.57,50.06 99.57,50.28 99.57,50.44 99.37,50.64 99.07,50.64 98.87,50.44 98.86,50.28 98.87,50.21 98.87,50.06 96.9,50.06 96.77,50.19 96.77,52.23 97.02,52.49
+VCC_SA on TOP (solid shape): outline of 152 points within 139.68,66.68 142.75,77.86
+VCC_SA on BOTTOM (solid shape): 97.21,53.09 97.21,52.6 97.32,52.49 98.68,52.49 98.69,52.49 99.34,52.49 99.46,52.37 99.46,51.52 99.56,51.42 101.24,51.42 101.31,51.35 101.31,50.24 101.12,50.06 99.57,50.06 99.57,50.43 99.49,50.52 99.37,50.63 99.22,50.64 99.06,50.63 98.85,50.42 98.85,50.06 97.36,50.06 97.16,50.27 95.04,50.27 94.94,50.36 94.94,51.33 95.85,51.33 95.85,52.15 94.94,52.15 94.94,53.17 94.97,53.2 97.1,53.2
+VCC_SA on BOTTOM (solid shape): 142.33,67.27 142.33,66.72 142.61,66.44 142.61,66.33 142.53,66.25 142.31,66.17 142.26,65.93 142.24,65.84 142.16,65.8 141.93,65.8 141.85,65.84 141.83,65.93 141.61,66.25 141.33,65.98 141.34,65.95 141.27,65.92 141.16,66.03 141.16,67.32 141.28,67.45 142.15,67.45
+VCC_SA on BOTTOM (solid shape): outline of 497 points within 138.64,74.94 143.04,77.82
+VCC_SA on IN4 (solid shape): outline of 11675 points within 95.32,49.98 146.52,79.71
+VCC_SFR_OC on IN2 (solid shape): outline of 1137 points within 116.25,63.97 142.92,67.52
+VDDA_AVDD1 on TOP (solid shape): 270.6,40.62 270.6,39.38 270.3,39.07 269.05,39.07 268.37,38.39 268.37,37.6 268.27,37.5 268.14,37.5 268.06,37.58 268.06,38.34 269.21,39.48 270.02,39.48 270.17,39.63 270.17,40.6 270.25,40.67 270.55,40.67
GND on TOP (solid shape): 8.3,74.05 0.25,74.05 0.25,76.85 8.3,76.85
GND on TOP (solid shape): 10.3,8.04 2.3,8.04 2.3,15.04 10.3,15.04
GND on TOP (solid shape): 77.01,56.75 71.51,56.75 71.51,62.25 77.01,62.25
GND on TOP (solid shape): 58.08,74 58.08,72.48 57.83,72.22 56.81,72.22 56.56,72.48 56.56,74 56.68,74.13 57.95,74.13
GND on TOP (solid shape): 187.12,26.92 187.12,26.16 186.96,26 185.95,26 185.84,26.1 185.84,27.06 185.91,27.12 186.93,27.12
GND on TOP (solid shape): 219.12,30.18 219.12,29.17 218.99,29.04 216.7,29.04 216.58,29.17 216.58,30.18 216.96,30.57 218.74,30.57
GND on TOP (solid shape): 292.5,76.48 286.02,76.48 286.02,61.53 292.5,61.53 292.5,60.33 284.82,60.33 284.82,77.67 292.5,77.67
GND on TOP (solid shape): 33.06,15.54 33.06,14.37 32.94,14.25 32.43,14.25 32.31,14.36 32.31,14.78 32.3,14.78 32.3,15.59 32.35,15.64 32.96,15.64
GND on TOP (solid shape): 44.11,63.97 44.11,60.75 43.99,60.62 42.84,60.62 42.71,60.75 42.71,63.97 42.84,64.09 43.98,64.09
GND on TOP (solid shape): 77.31,63.46 77.31,56.83 76.99,56.51 71.56,56.51 69.09,58.97 69.09,61.55 66.49,64.16 66.49,66.46 69.42,69.39 71.38,69.39
GND on TOP (solid shape): 79.8,39.15 79.8,34.38 79.67,34.25 78.78,34.25 78.55,34.48 78.55,38.92 78.83,39.2 79.75,39.2
GND on TOP (solid shape): 186.88,30.16 186.88,29.33 186.75,29.19 183.56,29.19 183.46,29.29 183.46,30.12 183.86,30.51 186.53,30.51
GND on TOP (solid shape): 16.17,15.93 11.84,15.93 11.84,15.93 8.54,15.93 8.54,17.13 14.97,17.13 14.97,32.08 8.5,32.08 8.5,33.28 16.17,33.28
GND on TOP (solid shape): 101.96,52.74 101.96,51.65 101.9,51.58 99.79,51.58 99.71,51.66 99.71,52.75 99.85,52.89 101.81,52.89
GND on TOP (solid shape): 51.49,54.73 51.49,50.91 50.98,50.4 49.76,50.4 48.6,51.56 46.09,51.56 45.21,52.44 45.21,54.2 45.9,54.9 51.33,54.9
GND on TOP (solid shape): 56,60.78 57.12,60.78 57.26,60.64 57.26,60.28 55.35,58.38 53.76,58.38 53.64,58.51 53.64,59.83 54.92,61.11 55.67,61.11
GND on TOP (solid shape): 80.08,49.46 80.52,49.46 80.57,49.42 80.57,48.89 78.77,48.89 78.62,49.04 78.62,50.03 78.65,50.05 79.5,50.05
GND on TOP (solid shape): 130.34,72.98 130.34,72.22 130.5,72.07 131.49,72.07 131.59,71.97 131.59,70.82 131.54,70.77 129.48,70.77 129.05,71.21 129.05,72.68 129.43,73.06 130.27,73.06
GND on TOP (solid shape): 10.16,73.63 10.16,72.9 8.55,71.29 8.55,71.29 7.94,70.68 7.22,70.68 7.13,70.77 7.6,71.25 7.6,71.64 8.42,72.47 8.42,73.74 8.62,73.93 9.86,73.93
GND on TOP (solid shape): 53.54,76.92 53.54,76.42 52.94,75.83 52.94,71.01 52.75,70.82 51.22,70.82 50.97,71.08 50.97,76.41 51.66,77.1 53.36,77.1
GND on TOP (solid shape): 57.7,54.95 57.7,52.79 57.88,52.62 57.88,51.86 57.82,51.8 57.29,51.8 57.13,51.65 56.69,51.65 56.56,51.77 56.56,54.95 56.69,55.08 57.57,55.08
GND on TOP (solid shape): 131.34,65.34 131.34,64.52 131.18,64.37 128.85,64.37 128.69,64.54 128.69,64.82 128.55,64.96 128.55,65.42 128.59,65.46 131.21,65.46
GND on TOP (solid shape): 8.73,79.21 9.22,79.21 10.4,78.02 10.4,77.5 9.75,76.84 9.38,76.84 8.35,77.87 8.35,78.52 7.11,79.76 7.11,79.92 7.17,79.98 7.96,79.98
GND on TOP (solid shape): 80.81,53.68 80.81,52.28 80.69,52.16 78.47,52.16 77.66,51.35 76.79,51.35 76.69,51.45 76.69,52.01 76.71,52.03 77.45,52.03 78.43,53.01 78.43,53.72 78.52,53.81 80.69,53.81
GND on TOP (solid shape): 87.62,48.89 87.62,47.99 87.55,47.91 87.55,46.72 87.38,46.55 85.28,46.55 85.13,46.69 85.13,48.95 87.56,48.95
GND on TOP (solid shape): 263.31,29.68 263.31,27.77 262.93,27.39 260.2,27.39 259.25,28.34 259.25,28.53 259.5,28.79 260.95,28.79 260.95,28.79 262.04,28.79 262.43,29.17 262.43,29.68 262.68,29.93 263.06,29.93
GND on TOP (solid shape): 9.85,88.17 9.85,87.09 7.93,85.17 7.18,85.17 7.08,85.27 7.08,85.42 7.7,86.04 7.7,86.04 8.26,86.6 8.26,87.85 8.82,88.42 9.6,88.42
GND on TOP (solid shape): 50.96,60.53 50.96,59.14 50.71,58.88 47.69,58.88 47.3,58.49 46.06,58.49 45.95,58.6 45.95,60 46.36,60.41 50.27,60.41 50.55,60.69 50.8,60.69
GND on TOP (solid shape): 92.6,61.4 92.6,58.6 92.35,58.35 90.99,58.35 90.82,58.51 90.82,59.52 90.56,59.78 87.91,59.78 86.94,58.81 84.73,58.81 83.6,59.95 83.6,60.96 87.22,60.96 88.12,61.87 92.14,61.87
GND on TOP (solid shape): 74.85,78.95 74.85,74.51 74.72,74.38 70.91,74.38 70.53,74 69.89,74 69.77,74.13 69.77,75.78 69.38,76.16 69.38,78.44 69.51,78.57 69.51,78.95 69.64,79.08 74.72,79.08
GND on TOP (solid shape): 186.86,38.82 186.86,38.11 186.79,38.03 184.73,38.03 184.57,37.88 184.57,35.95 184.47,35.85 183.8,35.85 183.68,35.96 183.68,38.06 183.94,38.31 183.94,38.82 184.13,39.01 186.67,39.01
GND on TOP (solid shape): 177.67,39.78 177.67,39.5 177.61,39.44 175.18,39.44 175.13,39.39 175.13,38.05 175.23,37.94 177.26,37.94 177.34,37.87 177.34,37.6 177.27,37.53 174.98,37.53 174.72,37.79 174.72,39.34 174.72,39.35 174.72,39.68 174.94,39.9 177.55,39.9
GND on TOP (solid shape): 241.39,35.86 241.39,35.84 241.41,35.66 241.47,35.49 241.47,34.76 240.96,34.25 239.69,34.25 239.31,33.87 236.9,33.87 236.64,34.12 236.64,35.52 236.9,35.77 240.58,35.77 240.71,35.9 241.34,35.9
GND on TOP (solid shape): 8.31,65.1 8.82,65.1 10.76,63.15 10.76,62.76 10.35,62.36 10.04,62.36 10.03,62.37 9.74,62.37 8.45,63.66 8.45,63.71 8.45,63.94 7.33,65.07 7.16,65.23 7.16,65.44 7.2,65.48 7.93,65.48
GND on TOP (solid shape): 98.25,78.41 92.58,72.73 92.58,72.25 92.44,72.11 90.01,72.11 89.63,72.49 89.63,73.21 90.68,74.27 90.68,76.41 91.01,76.74 92.59,76.74 92.82,76.97 92.82,80.31 92.99,80.49 94.52,80.49 95.15,81.12 98.25,81.12
GND on TOP (solid shape): 102.83,50.57 102.83,49.61 102.46,49.23 96.36,49.23 96.18,49.41 96.18,49.81 96.28,49.91 98.93,49.91 98.99,49.97 98.99,50.39 99.11,50.51 99.33,50.51 99.44,50.39 99.44,49.94 99.48,49.91 101.32,49.91 101.45,50.04 101.45,50.55 101.67,50.76 102.63,50.76
GND on TOP (solid shape): 86.94,56.12 86.94,55.85 86.91,55.81 86.81,55.81 86.81,55.74 86.66,55.6 86.66,54.95 86.64,54.93 81.98,54.93 81.64,55.27 81.64,55.43 81.81,55.6 81.87,55.6 82.46,56.19 86.87,56.19
GND on TOP (solid shape): 71.37,51.25 71.37,46.4 71.2,46.24 70.64,46.24 70.38,46.5 70.38,48.75 70.24,48.89 67.12,48.89 66.88,49.13 66.88,49.75 66.82,49.82 65.97,49.82 65.63,50.16 65.05,50.16 64.83,50.39 64.83,51.35 65.13,51.66 70.96,51.66
GND on TOP (solid shape): 127.32,71.84 127.32,70.82 126.74,70.24 126.74,68.87 126.13,68.26 125.95,68.26 125.82,68.13 125.82,67.57 125.8,67.55 124.86,67.55 124.66,67.34 124.66,67.06 124.53,66.94 124.2,66.94 123.64,67.5 123.41,67.5 123.28,67.62 123.28,68.11 123.36,68.18 124.88,68.18 125.8,69.1 125.8,71.74 125.95,71.89 127.27,71.89
GND on TOP (solid shape): 122.95,71.1 122.95,70.85 123.16,70.65 123.56,70.65 123.72,70.8 123.72,71.1 123.84,71.23 124.05,71.23 124.2,71.08 124.2,70.82 124.38,70.65 124.58,70.65 124.6,70.67 124.68,70.67 124.73,70.62 124.73,69.96 124.63,69.86 123.39,69.86 122.95,69.43 121.35,69.43 121.23,69.55 121.23,70.57 121.2,70.6 121.28,70.67 122.39,70.67 122.5,70.77 122.5,71.1 122.62,71.23 122.83,71.23
GND on TOP (solid shape): 63.13,76.19 63.13,75.11 62.78,74.76 62.78,71.57 62.67,71.46 60.84,71.46 60.75,71.55 60.75,73.24 61,73.49 61.89,73.49 62.02,73.62 62.02,74.51 61.76,74.76 60.81,74.76 60.62,74.81 60.43,74.76 58.97,74.76 58.84,74.89 58.84,76.29 58.97,76.41 62.91,76.41
GND on TOP (solid shape): 65.64,66.1 65.64,66.08 65.71,64.95 66.08,63.89 66.16,63.73 66.22,63.63 66.22,63.03 66.15,62.95 64.69,62.95 64.56,63.08 64.56,66.13 64.69,66.25 65.49,66.25
GND on TOP (solid shape): 131.92,68.41 131.92,68.06 132.07,67.9 132.07,67.88 132.07,67.34 132.3,67.12 132.62,67.12 132.66,67.08 132.66,66.73 132.81,66.58 133.32,66.58 133.49,66.41 133.49,66.21 133.72,65.99 134.26,65.99 134.33,65.92 134.33,65.42 134.28,65.36 133.77,65.36 133.29,65.85 131.84,65.85 131.59,66.1 131.59,67.29 131.41,67.47 130.83,67.47 130.7,67.6 130.7,68.31 130.85,68.46 131.87,68.46
GND on TOP (solid shape): 122.47,73.49 122.47,73.06 122.52,73.01 123.16,73.01 123.23,73.08 123.23,73.49 123.33,73.59 123.54,73.59 123.69,73.44 123.69,73.21 123.92,72.98 124.43,72.98 124.53,73.08 124.53,73.49 124.6,73.57 124.88,73.57 124.99,73.47 124.99,73.08 125.09,72.98 125.49,72.98 125.52,72.96 125.52,72.35 125.44,72.27 121.3,72.27 121.15,72.12 121.15,71.76 121.1,71.71 120.29,71.71 120.13,71.87 120.13,72.16 120.78,72.8 120.78,72.9 120.89,73.01 121.76,73.01 121.89,73.14 121.89,73.52 121.96,73.59 122.37,73.59
GND on TOP (solid shape): 282.61,44.17 282.61,42.9 282.61,42.9 282.61,42.83 282.08,42.83 281.68,42.83 281.68,42.28 281.48,42.28 281.48,42.83 280.94,42.83 280.36,42.25 279.37,42.25 279.14,42.48 279.14,43.06 279.17,43.07 279.38,43.33 279.3,43.64 279.27,43.72 279.3,43.79 279.81,44.29 282.5,44.29
GND on TOP (solid shape): 67.86,61.93 67.86,60 67.76,59.9 64.81,59.9 64.67,59.76 64.07,59.76 63.97,59.85 62.58,59.85 62.27,60.16 62.27,61.81 62.4,61.93 62.78,61.93 64.13,60.59 64.8,60.59 64.81,60.58 64.94,60.56 65.07,60.58 65.08,60.59 65.49,60.59 65.5,60.58 65.63,60.56 65.76,60.58 65.76,60.59 66.38,60.59 66.39,60.58 66.51,60.56 66.64,60.58 66.65,60.59 66.84,60.59 67,60.74 67,61.91 67.11,62.02 67.78,62.02
GND on TOP (solid shape): 114.62,70.52 114.62,70.19 114.83,69.99 115.1,69.99 115.44,69.66 118.38,69.66 118.66,69.38 118.66,69 118.18,68.51 115.33,68.51 114.57,69.27 109.42,69.27 109.31,69.38 109.31,70.44 109.44,70.57 109.69,70.57 109.8,70.47 109.8,70.14 109.95,69.99 110.43,69.99 110.56,70.11 110.56,70.47 110.66,70.57 110.89,70.57 110.99,70.47 110.99,70.11 111.09,70.01 111.65,70.01 111.78,70.14 111.78,70.47 111.85,70.54 112.13,70.54 112.23,70.44 112.23,70.04 112.29,69.99 112.84,69.99 112.95,70.09 112.95,70.44 113.05,70.54 113.33,70.54 113.4,70.47 113.4,70.06 113.48,69.99 114.06,69.99 114.17,70.09 114.17,70.54 114.22,70.6 114.55,70.6
GND on TOP (solid shape): 10.71,63.2 11.85,63.2 12.36,62.7 12.75,62.7 13,62.59 13.25,62.7 15.28,62.7 15.71,62.26 15.71,62.21 15.9,62.21 15.91,62.21 16.08,62.17 16.25,62.21 16.26,62.21 16.33,62.21 22.88,55.66 22.88,54.67 24.43,53.12 27.68,53.12 28.49,53.93 28.87,53.93 29,53.81 29,53.3 28.87,53.17 28.24,53.17 27.73,52.66 24.3,52.66 22.42,54.54 22.42,55.18 16.17,61.43 15.54,61.43 15.16,61.81 10.3,61.81 8.45,63.66 8.45,63.99 8.93,64.47 9.44,64.47
GND on TOP (solid shape): 178.16,29.38 178.16,27.58 178.19,27.56 178.19,26.68 178.96,25.9 178.96,25.54 178.86,25.43 175.99,25.43 175.46,25.97 175.38,26.04 175.38,26.06 175.19,26.36 174.84,26.35 174.82,26.35 174.29,26.88 173.27,26.88 173.02,26.63 173.02,26.12 172.92,26.03 171.21,26.03 171.11,26.12 171.11,26.78 171.14,26.78 171.14,27.67 171.18,27.71 172.03,27.71 172.03,27.77 174.51,27.77 174.51,27.77 174.63,27.77 175.2,27.2 175.54,27.2 176.5,26.25 177.21,26.25 177.43,26.47 177.43,27.42 177.21,27.64 176.48,27.64 176.46,27.67 176.46,29.37 176.49,29.41 178.13,29.41
GND on TOP (solid shape): 110.18,72.86 110.16,72.72 110.18,72.63 110.18,72.48 110.28,72.37 110.46,72.37 110.52,72.37 110.71,72.37 110.91,72.58 110.91,72.83 111.02,72.93 111.27,72.93 111.37,72.83 111.37,72.53 111.52,72.37 112.01,72.37 112.13,72.5 112.13,72.86 112.23,72.96 112.44,72.96 112.56,72.83 112.56,72.53 112.72,72.37 113.12,72.37 113.33,72.58 113.33,72.86 113.43,72.96 113.68,72.96 113.78,72.86 113.78,72.5 113.94,72.35 114.44,72.35 114.52,72.42 114.52,72.86 114.62,72.96 115.08,72.96 115.54,72.5 115.54,71.97 115.69,71.81 116.1,71.81 116.1,71.82 116.14,71.82 116.24,71.92 116.24,72.07 116.54,72.37 117.31,72.37 117.39,72.3 117.39,71.66 117.14,71.41 115.79,71.41 115.61,71.59 109.87,71.59 109.69,71.76 109.69,72.88 109.8,72.98 110.05,72.98
GND on TOP (solid shape): 148.3,73.29 148.3,72.68 147.93,72.32 147.93,72 147.98,71.95 148.04,71.87 148.12,71.81 148.31,71.62 148.31,71.41 148.41,71.31 148.95,71.31 148.95,72.11 149.04,72.21 149.04,72.28 149.05,72.29 149.09,72.38 149.1,72.48 149.1,72.69 149.23,72.82 150.82,72.82 150.88,72.76 150.88,72.53 150.81,72.47 150.52,72.47 150.29,72.24 149.68,72.24 149.66,72.22 149.61,72.22 149.48,72.09 149.48,72.04 149.47,72.03 149.47,71.71 149.48,71.7 149.48,71.69 149.69,71.48 149.69,70.84 149.65,70.79 149.62,70.73 149.59,70.64 149.58,70.55 149.58,70.53 149.36,70.31 148.4,70.31 148.26,70.37 148.12,70.34 148.09,70.32 147.72,70.69 147.72,71.42 147.45,71.69 147.45,72.65 147.59,72.79 147.59,73.21 147.6,73.29 147.7,73.39 148.19,73.39
GND on TOP (solid shape): 144.01,68.68 144.01,67.5 143.72,67.21 143.7,67.21 143.35,67.01 143.42,66.61 143.42,65.73 143.67,65.48 143.67,64.99 143.81,64.86 144.44,64.86 144.7,65.11 144.7,65.36 144.82,65.49 145.46,65.49 145.58,65.62 146.98,65.62 147.62,66.25 148.89,66.25 149.39,65.74 149.39,65.11 149.27,64.98 146.77,64.98 146.76,64.99 146.62,65.02 146.48,64.99 146.47,64.98 145.86,64.98 145.85,64.99 145.71,65.02 145.57,64.99 145.55,64.98 145.46,64.98 145.17,64.7 145.17,64.43 145.01,64.27 145.01,63.94 144.88,63.81 144.5,63.81 144.15,64.16 144.11,64.21 144.07,64.24 144.03,64.27 143.94,64.36 143.6,64.36 143.28,64.68 143.28,64.91 143.16,65.03 143.12,65.03 142.41,65.75 142.41,65.74 141.77,65.74 141.57,65.95 141.57,66.39 141.69,66.51 142.8,66.51 143.02,66.72 143.02,68.6 143.13,68.72 143.98,68.72
GND on TOP (solid shape): 179.45,88.15 179.46,87.93 179.52,87.72 179.65,87 179.52,86.27 179.46,86.07 179.45,85.85 179.45,84 177.48,84 174.5,87 177.48,90 179.45,90
GND on TOP (solid shape): outline of 81 points within 137.48,66.84 141.08,75.8
GND on TOP (solid shape): 136.95,71.5 137.16,71.72 137.38,71.5 137.38,71.18 137.4,71.16 137.84,71.16 137.9,71.1 137.9,70.52 137.81,70.43 132.09,70.43 132.04,70.48 132.04,71.53 132.12,71.61 132.36,71.66 132.5,71.46 132.5,71.23 132.61,71.12 133.15,71.12 133.27,71.24 133.27,71.46 133.49,71.68 133.7,71.46 133.7,71.23 133.88,71.06 134.29,71.06 134.48,71.24 134.48,71.46 134.69,71.68 134.91,71.46 134.91,71.21 134.99,71.12 135.56,71.12 135.68,71.25 135.68,71.46 135.9,71.68 136.12,71.46 136.12,71.2 136.17,71.14 136.18,71.14 136.87,71.14 136.95,71.22
GND on TOP (solid shape): 137.87,70.23 137.87,69.12 137.65,68.9 137.44,69.12 137.44,69.33 137.31,69.46 137.11,69.46 137.05,69.47 136.99,69.46 136.73,69.46 136.65,69.38 136.65,69.12 136.44,68.9 136.22,69.12 136.22,69.38 136.08,69.53 135.58,69.53 135.45,69.39 135.45,69.12 135.23,68.9 135.01,69.12 135.01,69.39 134.87,69.53 134.36,69.53 134.24,69.4 134.24,69.12 134.02,68.9 133.81,69.12 133.81,69.37 133.72,69.46 133.17,69.46 133.02,69.31 133.02,69.12 132.82,68.91 132.59,69.08 132.59,69.13 132.59,69.18 132.59,69.37 132.52,69.44 132.15,69.44 132.1,69.49 132.1,70.24 132.16,70.29 137.81,70.29
GND on TOP (solid shape): outline of 114 points within 73.07,42.38 76.75,48.73
GND on TOP (solid shape): 6.52,79.21 7.47,79.21 8.2,78.48 8.2,72.47 7.53,71.79 6.6,71.79 6.39,71.58 5.46,71.58 5.43,71.61 5.44,71.64 5.08,72.36 4.32,72.1 3.13,72.1 2.84,71.82 2.45,71.72 1.15,71.72 0.76,71.82 0.47,72.1 0.25,72.1 0.25,78.8 0.47,78.8 0.76,79.08 1.15,79.18 2.45,79.18 2.84,79.08 3.13,78.8 4.35,78.8 4.56,78.54 4.86,78.43 4.91,78.43 4.96,78.43 5.36,78.62 5.52,79.04 5.52,79.16 5.51,79.31 5.45,79.45 5.49,79.51 5.56,79.54 6.19,79.54
GND on TOP (solid shape): 102.06,73.05 102.11,73.03 102.15,73 102.19,72.97 102.21,72.94 102.23,72.9 102.24,72.85 102.24,72.58 102.29,72.53 103.36,72.53 103.4,72.49 103.4,71.88 103.38,71.87 102.42,71.87 102.18,71.63 102.18,70.39 101.98,70.19 101.7,70.19 101.62,70.23 101.6,70.32 101.26,70.77 100.92,70.32 100.9,70.23 100.82,70.19 100.53,70.19 100.45,70.23 100.44,70.32 100.34,70.67 99.99,70.76 99.9,70.77 99.86,70.86 99.86,72.4 99.93,72.47 100.16,72.47 100.46,72.47 100.52,72.53 100.52,72.89 100.54,72.93 100.63,73.03 100.68,73.05 100.8,73.05 100.86,73.02 100.94,72.94 100.96,72.88 100.96,72.54 101.05,72.45 101.71,72.45 101.78,72.53 101.78,72.86 101.8,72.92 101.83,72.97 101.87,73 101.91,73.03 101.96,73.05
GND on TOP (solid shape): 135.68,73.92 135.88,74.13 136.11,73.94 136.1,73.88 136.11,73.76 136.11,73.7 136.23,73.58 136.29,73.58 136.3,73.58 136.42,73.56 136.53,73.58 136.54,73.58 136.77,73.58 136.89,73.71 136.89,73.92 137.1,74.13 137.33,73.93 137.32,73.89 137.33,73.85 137.33,73.64 137.42,73.56 137.5,73.56 137.51,73.56 137.8,73.56 137.83,73.53 137.83,72.89 137.64,72.7 131.9,72.7 131.82,72.78 131.82,73.49 131.99,73.67 131.99,73.92 132,73.95 132.01,73.99 132.14,74.12 132.33,74.09 132.42,73.92 132.42,73.7 132.54,73.58 133.1,73.58 133.22,73.7 133.22,73.92 133.44,74.13 133.66,73.92 133.66,73.77 133.66,73.69 133.79,73.57 134.34,73.57 134.46,73.68 134.46,73.75 134.46,73.92 134.67,74.13 134.89,73.92 134.89,73.81 134.93,73.77 134.93,73.76 135.12,73.59 135.38,73.62 135.39,73.63 135.48,73.63 135.68,73.82
GND on TOP (solid shape): outline of 175 points within 78.83,63.58 89.4,70.2
GND on TOP (solid shape): outline of 164 points within 92.14,63.03 103.39,67.8
GND on TOP (solid shape): outline of 81 points within 286.81,42.95 300.74,64
GND on TOP (solid shape): outline of 113 points within 0.25,31.29 14.27,65.06
GND on TOP (solid shape): outline of 1492 points within 104.91,49.47 123.15,66.76
GND on TOP (solid shape): outline of 298 points within 0.5,0.26 300.49,28.76
GND on TOP (solid shape): outline of 362 points within 0.25,47.45 300.49,97.75
GND on BOTTOM (solid shape): 12.5,35.9 3.5,35.9 3.5,37.1 12.5,37.1
GND on BOTTOM (solid shape): 291,78.9 285,78.9 285,80.1 291,80.1
GND on BOTTOM (solid shape): 300.4,24.45 299.2,24.45 299.2,26.75 300.4,26.75
GND on BOTTOM (solid shape): 44.11,63.97 44.11,60.79 43.97,60.65 43.11,60.65 42.69,61.07 42.69,63.99 42.75,64.05 44.03,64.05
GND on BOTTOM (solid shape): 101.14,92.92 101.14,89.49 100.88,89.24 94.28,89.24 93.9,89.62 93.9,90.51 94.79,91.4 94.79,92.92 95.04,93.18 100.88,93.18
GND on BOTTOM (solid shape): 263.53,30.09 263.53,30.08 265.6,28.01 265.6,27.01 265.22,26.63 260.27,26.63 260.14,26.76 260.14,27.9 262.55,30.31 263.31,30.31
GND on BOTTOM (solid shape): 89.1,31.99 91.58,31.99 91.69,31.88 91.69,31.25 91.41,30.98 87.23,30.98 87.02,31.19 87.02,31.9 87.27,32.14 88.94,32.14
GND on BOTTOM (solid shape): 101.96,52.75 101.96,51.65 101.9,51.58 99.79,51.58 99.7,51.67 99.7,52.74 99.85,52.89 101.82,52.89
GND on BOTTOM (solid shape): 109.96,80.88 109.96,74.42 109.75,74.2 106.58,74.2 105.9,74.89 105.9,78.37 105.4,78.86 105.4,80.81 106.81,82.22 108.63,82.22
GND on BOTTOM (solid shape): 79.93,39.07 79.93,34.5 79.67,34.25 78.78,34.25 78.56,34.47 78.56,38.98 78.66,39.07 78.78,39.2 79.8,39.2
GND on BOTTOM (solid shape): 103.63,67.54 103.63,63.19 103.57,63.13 101.77,63.13 101.63,63.27 101.63,64.42 101.38,64.67 100.21,64.67 99.98,64.9 99.98,67.59 100.08,67.7 103.48,67.7
GND on BOTTOM (solid shape): 214.42,41.26 214.14,40.98 214.15,40.98 214.15,40.54 214.01,40.39 208.64,40.39 208.54,40.49 208.54,40.98 208.3,41.22 208.3,41.23 208.35,41.28 214.42,41.28
GND on BOTTOM (solid shape): 35.2,79.48 21.03,79.48 21.03,79.47 20.42,79.47 20.42,57.47 16.02,57.47 14.83,57.47 14.83,58.68 19.22,58.68 19.22,80.67 35.2,80.67 35.2,80.68
GND on BOTTOM (solid shape): 47.01,60.06 47.01,57.75 46.92,57.66 45.96,57.66 45.76,57.46 44.54,57.46 44.54,57.46 44.46,57.46 44.43,57.5 44.43,60.23 44.47,60.27 46.8,60.27
GND on BOTTOM (solid shape): 68.62,36.92 68.62,31.2 69,30.82 69,30.44 68.75,30.18 67.35,30.18 67.1,30.44 67.1,36.41 66.84,36.66 66.84,36.92 67.61,37.68 67.86,37.68
GND on BOTTOM (solid shape): 227,81.43 226.99,81.37 227,81.3 227,66.63 226.77,66.4 224.43,66.4 224.32,66.51 224.32,92.29 224.44,92.4 227,92.4
GND on BOTTOM (solid shape): 80.94,42.38 80.94,41.87 80.81,41.74 80.81,40.6 80.69,40.47 80.09,40.47 80.03,40.53 80.03,41.68 79.84,41.87 79.42,41.87 79.29,42 79.29,42.38 79.42,42.5 80.81,42.5
GND on BOTTOM (solid shape): 88.36,50.96 88.36,49.7 88.36,49.69 88.45,49.59 89.64,49.59 89.74,49.7 90,49.7 90.13,49.57 90.13,49.21 90.02,49.1 87.71,49.1 87.47,49.34 87.47,50.98 87.47,50.99 88.33,50.99
GND on BOTTOM (solid shape): 87.6,48.89 87.6,47.97 87.6,47.97 87.6,46.32 87.22,45.93 85.89,45.93 85.2,45.24 85.2,43.45 85.17,43.42 84.29,43.42 84.25,43.46 84.25,45.67 85.13,46.55 85.13,48.91 85.15,48.93 87.57,48.93
GND on BOTTOM (solid shape): 215.71,34.65 215.71,33.82 214.52,32.63 214.52,31.71 214.51,31.7 214.42,31.7 214.42,31.68 213.91,31.68 213.91,31.7 213.48,31.7 213.48,32.19 212.69,32.98 212.53,32.98 212.22,33.29 212.22,34.64 212.36,34.78 215.59,34.78
GND on BOTTOM (solid shape): 298.15,58.8 298.28,58.38 298.62,58.1 289.4,58.1 289.4,59.3 298.15,59.3
GND on BOTTOM (solid shape): 21.35,19.93 16.17,19.93 16.17,15.93 8.5,15.93 8.5,17.13 14.97,17.13 14.97,21.13 21.35,21.13
GND on BOTTOM (solid shape): 18.46,30.69 18.46,28.53 17.97,28.05 17.97,27.44 17.84,27.3 17.36,27.3 17.35,27.3 17.25,27.33 17.15,27.32 17.12,27.31 16.93,27.5 16.93,27.98 16.05,28.87 16.05,31.45 16.43,31.84 17.32,31.84
GND on BOTTOM (solid shape): 108.22,48.48 161.17,48.48 161.17,29.03 71.83,29.03 71.83,30.23 159.97,30.23 159.97,47.28 95.42,47.28 95.42,30.23 94.22,30.23 94.22,47.28 88,47.28 88,48.48 102.03,48.48 103.22,48.47 103.22,48.48 107.03,48.48 107.03,55.45 108.22,55.45
GND on BOTTOM (solid shape): 87.36,55.96 87.36,54.97 87.21,54.82 85.83,54.82 85.82,54.83 85.48,54.83 85.38,54.93 83.29,54.93 83.29,54.93 82.05,54.93 82.05,54.93 81.97,54.93 81.65,55.25 81.65,55.42 81.82,55.58 81.88,55.58 82.49,56.19 87.13,56.19
GND on BOTTOM (solid shape): 16.02,42.13 21.81,31.52 35.17,31.52 35.65,32.51 38.36,31.22 37.93,30.33 21.1,30.33 14.82,41.83 14.82,57.48 16.02,57.48
GND on BOTTOM (solid shape): 71.37,51.25 71.37,46.43 71.18,46.24 70.64,46.24 70.44,46.44 70.44,48.61 70.17,48.88 66.88,48.88 66.88,49.75 66.82,49.81 65.95,49.81 65.6,50.16 65.02,50.16 64.81,50.36 64.81,51.37 64.92,51.48 71.14,51.48
GND on BOTTOM (solid shape): 102.82,50.57 102.82,49.68 102.37,49.23 96.28,49.23 96.18,49.34 96.18,49.74 96.35,49.91 98.95,49.91 99,49.95 99,50.39 99.12,50.5 99.32,50.5 99.45,50.38 99.45,49.95 99.49,49.91 101.32,49.91 101.45,50.04 101.45,50.57 101.64,50.76 102.62,50.76
GND on BOTTOM (solid shape): 51.88,54.8 51.88,52.98 51.73,52.84 50.65,52.84 50.46,52.64 50.46,52.04 50.28,51.86 46.32,51.86 46.28,51.9 46.28,52.83 46.2,52.91 42.72,52.91 42.61,53.03 42.61,54.33 42.75,54.48 49.89,54.48 50.32,54.91 51.77,54.91
GND on BOTTOM (solid shape): 88.94,43.65 88.94,40.16 88.62,39.84 88.05,39.84 87.93,39.96 87.93,41.96 88.19,42.22 88.19,43.35 88.02,43.52 87.37,43.52 87.17,43.52 87.09,43.45 85.46,43.45 85.39,43.52 85.39,43.66 85.43,43.7 86.59,43.7 87.17,44.28 88.31,44.28
