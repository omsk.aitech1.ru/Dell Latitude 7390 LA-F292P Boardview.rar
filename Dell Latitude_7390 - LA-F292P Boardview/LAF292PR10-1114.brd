# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N46816449: length 1.9
  TOP w0.086: PC647.2 77.55,77.79 v1(76.69,77.79)
  TOP w0.254: PC647.2 77.64,76.89 PR650.2
N46816463: length 0.9
  BOTTOM w0.254: PC629.2 77.77,78.03 PR639.1
N46816511: length 29.7
  IN1 w0.203: v2(88.13,62.87) 88.34,63.08 88.34,69.12 87.01,70.44 87.01,71.56 86.12,72.45 80.15,72.45 78.77,73.84 78.77,79.16 v2(78.58,79.35)
  BOTTOM w0.203: v2(78.58,79.35) 78.58,80.15 78.31,80.41 76.99,80.41 76.79,80.21 PR647.2 76.79,79.03 PR635.1
  BOTTOM w0.254: v2(88.13,62.87) 87.22,61.96 PH603.2
N46816791: length 2.5
  BOTTOM w0.203: 75.81,74.13 75.21,74.73 PU602.20
  BOTTOM w0.254: 75.81,74.13 PC630.1 PR640.1
N46816817: length 0.9
  BOTTOM w0.203: PC630.2 76.98,73.21 PR644.1
N46816821: length 2.1
  TOP w0.086: v2(101.1,63.33) v1(101.1,64.08)
  TOP w0.254: PR657.2 v2(101.1,63.33)
  BOTTOM w0.254: PH605.1 101.1,62.66 v2(101.1,63.33)
N46816907: length 1.9
  TOP w0.086: PC639.2 v1(79.46,75.63)
  TOP w0.254: PR645.1 77.87,75.77 78.39,75.77 PC639.2
N46924944: length 1.8
  TOP w0.117: PR920.2 55.74,33.19 PU901.21
N46924987: length 2.1
  TOP w0.117: PU901.22 56.14,33.68 PR922.2
N46941563: length 2.9
  TOP w0.102: CT86.1 22.65,76.26 v1(22.46,76.07)
  TOP w0.254: RT395.2 CT86.1 RT104.1
N47324022: length 1.4
  BOTTOM w0.086: 63.87,69.44 63.87,69.03 v1(64.61,68.3)
N47394352: length 1
  BOTTOM w0.254: PR308.1 66.34,72.3 PC307.2
N48142326: length 3.1
  BOTTOM w0.086: RV18.2 QV4.2 14.98,36.4 15.14,36.56 15.93,36.56 v1(16.25,36.24)
N48223124: length 3.2
  TOP w0.086: v1(118,77.96) 118.25,77.96 v3(118.48,78.19) 118.49,78.2 118.49,78.71 RC436.2
  GND1 w0.086: v3(118.48,78.19) v4(118.97,78.19)
  GND5 w0.086: v4(118.97,78.19) 119.14,78.01 v5(119.49,78.01)
  BOTTOM w0.086: UC1.G65 v5(119.49,78.01)
N48247115: length 16.7
  TOP w0.086: v1(126.93,87.35) 127.17,87.59 RC437.2 127.9,86.73 126.79,85.62 v3(126.79,83.78)
  GND1 w0.086: v3(126.79,83.78) v4(126.79,84.26)
  IN4 w0.051: v2(127.4,76.16) 127.45,76.16 128.77,77.48 128.77,79.49 127.18,81.08 127.18,82.77 127.68,83.26 127.68,84.01 127.42,84.26 v4(126.79,84.26)
  BOTTOM w0.086: v2(127.4,76.16) 127.35,76.16 127.13,76.37 UC1.K52
N48250113: length 5.8
  TOP w0.086: v1(121.77,67.14) RC438.1 123.28,67.14 123.31,67.17 v2(123.33,67.17)
  BOTTOM w0.086: UC1.AK52 126.74,66.22 126.74,66.35 126.38,66.72 124.99,66.72 124.89,66.81 123.69,66.81 v2(123.33,67.17)
N48302079: length 9.4
  TOP w0.086: QE12.1 263.57,75.59 v2(263.96,75.19) v1(264.53,75.19) ; RE94.1 v3(259,71.87)
  GND1 w0.086: v3(259,71.87) v4(259,72.6)
  IN1 w0.051: v4(259,72.6) 259.71,72.6 260.77,73.67 263.52,73.67 263.96,74.11 v2(263.96,75.19)
N48610495: length 0.9
  BOTTOM w0.086: CZ56.1 RZ63.1
N48610537: length 2
  BOTTOM w0.086: UZ12.27 172.14,42.75 172.25,42.63 RZ62.1
N48704005: length 6.9
  TOP w0.254: v2(93.55,52.19) 93.55,52.45 94.48,53.37 v1(95.57,53.37) 96.07,53.37 PR624.1
  BOTTOM w0.254: PL614.3 93.1,51.74 v2(93.55,52.19)
N48708800: length 7.5
  TOP w0.086: v2(21.51,85.94) 21.76,86.19 v1(22.31,86.19) 24.38,86.19 25.19,85.38 25.19,83.96 RC433.2
  BOTTOM w0.086: QC6.1 20.24,85.68 20.49,85.94 v2(21.51,85.94)
N48708802: length 5.9
  TOP w0.086: RC432.2 RC433.1 26.84,83.22 QC7.2 28.21,84.18 v1(28.74,84.72) 28.74,85.38 CC340.1
N49117945: length 1.5
  TOP w0.117: PU901.27 58.43,35.94 PR932.1
N49118067: length 1.8
  TOP w0.254: PQ1207.6 58.76,85.79 58.68,85.87 57.73,85.87 PR1209.1
N49204882: length 6.4
  TOP w0.086: PR661.1 v1(97.79,61.47)
  TOP w0.254: v2(99.5,60.8) 99.5,60.98 PR661.1
  BOTTOM w0.254: v2(99.5,60.8) 99.5,58.77 99.11,58.39 PL612.3
N49222948: length 2.4
  BOTTOM w0.254: PR687.2 87.52,70.67 88.22,71.37 88.22,72.11 88.35,72.24 PU610.1
N49223679: length 2
  BOTTOM w0.254: PR659.2 87.51,71.55 87.79,71.83 87.79,72.25 88.28,72.74 PU610.2
N49225697: length 3.1
  TOP w0.203: v2(88.13,70.6) 88.08,70.65 PR686.2
  BOTTOM w0.203: PU610.17 89.26,71.25 89.11,71.1 88.64,71.1 v2(88.13,70.6)
N49226542: length 3.8
  TOP w0.086: v2(87.86,63.58) 88.1,63.58 v1(88.68,63)
  TOP w0.203: v2(87.86,63.58) 87.68,63.39 87.68,62.51 PR692.2
  BOTTOM w0.203: PU613.1 87.65,63.94 87.86,63.73 v2(87.86,63.58)
N49226544: length 1.6
  TOP w0.203: v2(87.25,63.57) 87.25,62.96 PR671.2
  BOTTOM w0.203: PU613.2 87.15,63.67 v2(87.25,63.57)
N49228457: length 2
  BOTTOM w0.203: PR689.2 89.13,63.99 88.92,64.21 88.92,64.86 88.74,65.03 PU613.17
N49230528: length 3
  BOTTOM w0.086: PR1298.2 v1(94.26,56.05)
  BOTTOM w0.254: PU612.17 93.42,58.28 93.64,58.06 93.64,57.63 PR1298.2
N49231205: length 32.2
  IN1 w0.203: v2(76.18,70) 76.43,69.74 76.43,68.18 75.84,67.59 75.84,58.32 77.1,57.06 91.44,57.06 92.22,56.28 92.55,56.28 92.98,56.71 v2(92.98,56.82)
  BOTTOM w0.203: v2(92.98,56.82) 92.98,57.06 92.77,57.27 92.38,57.27 92.31,57.35 PU612.1 ; v2(76.18,70) PR664.2
N49231242: length 30.6
  IN1 w0.203: v2(77.06,70) 76.74,69.68 76.74,68.06 76.14,67.46 76.14,58.44 77.22,57.36 91.83,57.36 v2(92.4,56.79)
  BOTTOM w0.203: v2(92.4,56.79) 92.28,56.79 91.81,57.26 PU612.2 ; v2(77.06,70) PR1299.2
N49466989: length 4
  TOP w0.086: 265.47,81.37 265.47,79.76 v1(264.86,79.16) 264.28,78.57 QE17.1
N49466993: length 12.5
  TOP w0.086: CE64.1 262.93,83.97 263.96,85 QE15.2 265.94,83.84 265.94,82.65 RE565.1 RE543.2 263.62,81.4 DE2.1 261.85,82.09 v1(261.65,82.29) 261.38,82.29 260.9,81.81 RE541.2
N50595384: length 2.8
  TOP w0.117: v1(62.69,35.61) 62.95,35.35 62.95,34.96 63.16,34.74
  TOP w0.254: PR946.1 63.16,34.74 64.06,35.64 PU903.4
N51741838: length 2
  BOTTOM w0.086: RT446.2 24.93,24.09 25.43,24.09 25.61,23.91 UT33.3
N51741841: length 4.1
  BOTTOM w0.086: UT33.1 26.91,22.71 26.34,22.14 26,22.14 25.72,21.87 24.78,21.87 24.48,22.17 RT444.2
N51744116: length 2.5
  BOTTOM w0.086: RT456.2 RT445.2 7.96,10.9 UT32.1
N51744150: length 2.2
  BOTTOM w0.086: UT32.3 7.85,9.6 8.11,9.85 8.11,10.26 RT448.2
N52410921: length 3.8
  TOP w0.086: RE527.2 RE528.1 257.94,82.44 257.94,82.22 v1(257.23,81.5) 256.37,80.64 UE2.3
N52410927: length 4.5
  TOP w0.086: RE500.2 260.29,80.2 RE501.1 259.62,80.87 257.55,80.87 257.37,80.69 UE2.1
N52410929: length 5
  TOP w0.086: UE2.2 256.87,80.7 257.28,81.11 257.34,81.11 257.63,81.4 v1(258.61,81.4) 258.68,81.4 RE503.1 RE502.2
N119328643: length 5.8
  TOP w0.086: PC938.1 60.28,32.15 v1(60.79,31.64)
  TOP w0.203: PC938.1 59.83,32.13 PR930.1 58.93,32.14 PR931.2 58.93,33.5 58.13,34.3 58.13,34.93 57.93,35.14 PU901.25
N132000604: length 1.2
  TOP w0.508: PR921.2 PC934.1
N132005053: length 22.5
  TOP w0.254: PR938.2 55.61,47.47 v1(55.61,47.91) 55.61,49.69 56.29,50.37 56.29,55.06 56.51,55.28 56.51,58.09 58.02,59.6 59.11,59.6 59.73,58.98 59.73,56.88 59.48,56.63 PR917.3

## Copper pours and planes (outline as drawn)
1.8V_OUT on TOP (solid shape): 78.88,51.85 78.88,50.98 77.87,49.97 77.87,49.22 77.87,49.01 78.17,48.7 78.17,48.24 78.22,48.19 78.22,47.83 77.66,47.83 77.66,47.34 78.22,47.34 78.22,47.02 77.77,46.57 77.13,46.57 76.81,46.88 76.81,50.24 78.53,51.95 78.78,51.95
3V_SN on TOP (solid shape): 76.88,41.74 76.88,40.09 75.61,38.82 74.59,38.82 74.34,39.07 74.34,40.6 74.46,40.73 75.35,40.73 75.48,40.85 75.48,41.74 75.61,41.87 76.75,41.87
3V_VIN on TOP (solid shape): 73.83,47.96 73.83,46.31 74.21,45.93 74.21,45.42 74.08,45.3 73.07,45.3 72.81,45.04 72.81,43.65 72.69,43.52 71.8,43.52 71.54,43.77 71.54,47.96 71.67,48.09 73.7,48.09
3V_VIN on BOTTOM (solid shape): 72.03,49.75 72.03,49.23 72.54,49.23 72.54,49.75 72.83,49.75 72.83,49.23 73.34,49.23 73.34,49.75 73.73,49.75 73.83,49.64 73.83,48.64 73.33,48.14 73.33,46.7 72.81,46.19 72.81,45.3 73.01,45.1 73.01,43.66 72.93,43.58 71.53,43.58 71.42,43.69 71.42,46.19 71.54,46.31 71.54,49.75 71.99,49.75
5V_SN on TOP (solid shape): 55.48,65.74 55.48,62.95 55.35,62.82 54.46,62.82 54.34,62.95 54.34,65.74 54.46,65.87 55.35,65.87
5V_VIN on TOP (solid shape): 50.72,74.38 50.72,70.82 50.59,70.7 49.57,70.7 49.45,70.82 49.45,74.51 49.57,74.63 50.46,74.63
5V_VIN on BOTTOM (solid shape): 51.22,76.11 51.22,75.93 50.54,75.24 50.54,73.41 50.97,72.98 50.97,72.2 51.13,72.03 51.13,70.57 51.07,70.5 49.77,70.5 49.45,70.82 49.45,72.22 48.56,73.11 48.56,75.52 49.19,76.16 51.17,76.16
+0.6V_DDR_VTT on TOP (solid shape): 90.92,40.34 90.92,40.09 91.46,39.56 91.46,37.41 91.46,37.41 91.46,34.78 93.08,33.16 112.29,33.16 113.73,31.71 140.38,31.71 140.76,31.33 140.76,30.31 140.51,30.06 111.09,30.06 109.69,31.45 93.01,31.45 92.5,31.96 90.39,34.07 90.39,37.98 90.16,38.21 90.16,39.08 90.16,39.59 90.16,39.61 89.6,39.61 89.6,39.82 90.16,39.82 90.16,40.24 90.37,40.45 90.82,40.45
+0.6V_DDR_VTT on BOTTOM (solid shape): outline of 130 points within 95.98,30.65 159.55,36.27
+0.6VSP on TOP (solid shape): 88.38,43.39 88.44,43.39 88.69,43.14 88.69,42.63 90.03,41.29 90.03,39.95 89.48,39.95 89.48,39.48 90.03,39.48 90.03,39.17 89.87,39.01 89.39,39.01 88.69,39.71 88.69,39.71 88.69,40.47 88.69,40.47 88.69,41.11 87.29,42.5 87.29,43.39 87.42,43.52 88.25,43.52
+0.6VSP on BOTTOM (solid shape): 88.02,43.26 88.02,42.37 87.91,42.25 87.47,42.25 87.47,42.25 86.66,42.25 86.38,42.53 85.46,42.53 85.39,42.61 85.39,43.18 85.47,43.27 87.29,43.27 87.42,43.39 87.89,43.39
+0.9V_TBT_CIO on BOTTOM (solid shape): 34.44,60.64 34.57,60.57 34.71,60.55 34.75,60.54 34.77,60.51 34.8,60.43 34.87,60.37 34.87,60.09 34.76,59.9 34.87,59.72 34.87,59.55 34.73,59.41 34.73,58.7 34.7,58.63 34.63,58.6 34.48,58.55 34.37,58.43 33.98,58.43 33.88,58.53 33.89,58.55 33.89,58.62 33.88,58.69 33.88,59.17 33.88,59.18 33.89,59.25 33.88,59.33 33.88,59.34 33.88,59.82 33.88,59.83 33.89,59.9 33.88,59.98 33.88,59.99 33.88,60.38 34.06,60.57 34.07,60.57 34.15,60.6 34.21,60.64
+0.9V_TBT_DP on TOP (solid shape): 32.99,60.99 32.99,60.03 32.89,59.93 31.98,59.93 31.82,60.09 31.82,61.1 31.84,61.12 32.86,61.12
+0.9V_TBT_DP on TOP (solid shape): 36.02,60.35 36.02,59.45 35.63,59.05 35.63,58.55 35.53,58.26 35.65,57.98 36.14,57.49 36.14,57.39 36.05,57.3 36.02,57.31 35.93,57.32 35.85,57.3 35.84,57.29 35.63,57.29 35.59,57.33 35.59,57.33 35.52,57.4 35.08,57.4 35.02,57.46 35.02,60.36 35.2,60.54 35.83,60.54
+0.9V_TBT_DP on BOTTOM (solid shape): 32.55,61.38 32.7,61.31 32.85,61.38 33.11,61.38 33.24,61.25 33.24,60.42 33.2,60.38 33.17,60.34 33.14,60.29 33,60.14 32.95,60.14 32.8,59.99 32.62,59.99 32.47,60.14 32.42,60.14 32.4,60.16 32.28,60.16 32.05,60.38 32.05,61.12 32.15,61.22 32.16,61.23 32.26,61.29 32.33,61.38
+0.9V_TBT_DP on BOTTOM (solid shape): 35.76,59.44 35.76,59.18 35.65,58.94 35.76,58.7 35.76,58.53 35.64,58.28 35.76,58.03 35.76,57.9 35.68,57.82 35.33,57.82 35.2,57.95 35.19,57.97 35.17,58.06 35.1,58.13 35.07,58.15 35.04,58.16 34.99,58.2 34.97,58.26 34.96,58.36 34.92,58.46 34.87,58.51 34.82,58.55 34.82,59.31 34.91,59.39 34.96,59.5 34.97,59.52 35.25,59.8 35.4,59.8
+0.9V_TBT_DP on IN4 (solid shape): outline of 302 points within 31.08,57.87 35.6,61.3
+0.9V_TBT_LVR_OUT on TOP (solid shape): 31.02,59.65 31.02,58.04 30.99,58.01 30.56,58.01 30.49,58.07 30.49,59.04 30.26,59.26 30.26,59.85 30.31,59.9 30.77,59.9
+0.9V_TBT_LVR_OUT on TOP (solid shape): 31.77,56.61 31.77,56.12 31.69,56.04 31.11,56.04 30.96,55.9 30.96,55.62 30.87,55.53 30.55,55.53 30.47,55.57 30.44,55.65 30.43,55.8 30.35,55.94 30.35,56.42 30.52,56.6 30.93,56.6 30.98,56.65 31.72,56.65
+0.9V_TBT_LVR_OUT on BOTTOM (solid shape): 31.84,59.32 31.84,59.17 31.77,59.08 31.74,58.97 31.73,58.95 31.64,58.86 31.16,58.86 31.12,58.82 31.09,58.82 30.88,58.69 30.93,58.45 30.93,58.11 30.86,57.95 30.93,57.8 30.93,57.46 30.86,57.3 30.93,57.15 30.93,56.81 30.86,56.65 30.93,56.5 30.93,56.4 31.1,56.23 31.11,56.22 31.15,56.14 31.21,56.08 31.21,55.93 31.17,55.9 31.14,55.85 30.38,55.85 30.3,55.93 30.3,56.33 30.41,56.44 30.43,56.44 30.61,56.53 30.63,56.73 30.63,56.74 30.63,57.22 30.63,57.22 30.64,57.3 30.63,57.38 30.63,57.39 30.63,57.87 30.63,57.87 30.64,57.95 30.63,58.03 30.63,58.04 30.63,58.51 30.63,58.52 30.64,58.6 30.63,58.68 30.63,58.69 30.63,58.73 30.52,58.84 30.52,59.04 30.85,59.37 31.79,59.37
+0.9V_TBT_PCIE on TOP (solid shape): 32.94,57.82 32.94,57.31 33.06,57.18 33.44,57.18 33.47,57.16 33.47,56.8 33.42,56.75 33.06,56.75 32.94,56.63 32.94,56.02 33.04,55.91 33.49,55.91 33.57,55.84 33.57,55.08 33.42,54.92 32.38,54.92 32.3,55 32.3,55.33 32.43,55.46 32.43,56.09 32.33,56.19 31.97,56.19 31.92,56.24 31.92,56.57 31.95,56.6 32.28,56.6 32.48,56.8 32.48,57.84 32.53,57.9 32.86,57.9
+0.9V_TBT_PCIE on BOTTOM (solid shape): 33.11,58.07 33.14,58.05 33.17,58.02 33.17,57.7 33.15,57.63 33.17,57.56 33.17,57.46 33.42,57.21 33.42,56.71 33.4,56.67 33.37,56.66 33.08,56.2 33.61,56.14 33.69,56.18 33.76,56.15 33.98,55.94 33.98,55.36 33.83,55.2 33.48,55.2 33.47,55.21 33.42,55.23 33.37,55.25 33.35,55.25 33.25,55.35 33.24,55.37 33.17,55.52 33.02,55.57 32.94,55.57 32.55,55.18 32.35,55.18 32.25,55.28 32.25,56.32 32.37,56.44 32.39,56.44 32.54,56.51 32.59,56.68 32.57,56.75 32.53,56.81 32.48,56.86 32.48,57.11 32.5,57.13 32.59,57.3 32.5,57.48 32.48,57.5 32.48,57.76 32.5,57.78 32.56,57.84 32.59,57.92 32.59,57.93 32.73,58.07
+0.9V_TBT_SVR on TOP (solid shape): 30.01,59.8 30.01,59.32 30.4,58.94 30.4,57.51 30.29,57.41 30.29,56.73 30.17,56.6 29.25,56.6 29.13,56.73 29.13,59.01 29.51,59.39 29.51,59.78 29.63,59.9 29.91,59.9
+0.9V_TBT_SVR on BOTTOM (solid shape): 26.93,69.22 26.93,65.93 26.62,65.62 23.54,65.62 23.54,65.62 22.9,65.62 22.78,65.74 22.78,69.24 22.78,69.35 22.93,69.5 26.65,69.5
+0.9V_TBT_SVR on BOTTOM (solid shape): 32.58,59.9 32.84,59.9 32.99,60.05 33.17,60.05 33.24,59.98 33.24,59.7 33.01,59.47 33,59.47 32.9,59.43 32.83,59.35 32.82,59.32 32.59,59.32 32.57,59.35 32.36,59.47 32.17,59.32 32.17,59.32 32,59.32 31.9,59.42 31.87,59.42 31.83,59.46 31.73,59.47 31.66,59.46 31.15,59.46 31.08,59.47 31.01,59.46 30.82,59.46 30.43,59.08 30.43,58.8 30.54,58.7 30.54,57.22 30.45,57.13 30.22,57.13 29.99,57.37 29.98,57.38 29.93,57.46 29.85,57.51 29.84,57.51 29.66,57.7 29.63,57.74 29.61,57.78 29.61,58.13 29.67,58.28 29.61,58.43 29.61,58.78 29.64,58.82 29.66,58.87 29.84,59.05 29.85,59.05 29.95,59.12 29.99,59.23 30,59.25 30.14,59.39 30.2,59.41 30.24,59.44 30.58,59.75 30.93,59.75 31.08,59.69 31.23,59.75 31.29,59.75 31.59,60.05 32.43,60.05
+0.9V_TBT_SVR on VCC: 22.65,64.96 20.17,67.44 20.17,72.62 20.4,72.85 23.54,72.85 24.3,73.62 24.45,73.62 24.93,73.13 24.93,72.05 24.68,71.8 24.68,69.84 25.22,69.3 26.74,69.3 27.09,68.94 27.09,62.46 28.39,61.17 30.04,61.17 30.6,60.61 31.43,59.78 32.7,59.78 32.81,59.67 32.81,53.78 32.58,53.55 26.71,53.55 26.6,53.66 26.6,56.1 22.65,60.06
+0.9V_TBT_SVR on GND5: 26,67.6 25.57,68.03 25.57,68.94 26,69.38 26.79,69.38 27.09,69.07 27.09,67.9 26.79,67.6
+1.0V_MPHYGT on TOP (solid shape): 148.53,73.94 148.53,73.74 148.3,73.51 147.57,73.51 147.44,73.38 147.44,72.87 147.31,72.74 146.81,72.74 146.74,72.8 146.74,73.97 146.85,74.07 147.23,74.07 147.23,74.08 148.4,74.08
+1.0V_MPHYGT on TOP (solid shape): 161.08,91.02 161.08,90.06 161.04,90.02 161.04,89.94 160.88,89.66 161.04,89.37 161.04,88.94 160.82,88.73 159.02,88.73 159.02,88.76 158.41,88.76 158.41,88.73 156.25,88.73 156.2,88.68 153.71,88.68 153.59,88.81 153.59,89.24 154.22,89.87 154.73,89.87 156,91.14 160.95,91.14
+1.0V_MPHYGT on BOTTOM (solid shape): 156.94,90.94 157.68,90.94 157.68,91.47 158.13,91.47 158.13,90.94 158.87,90.94 158.87,91.47 159.55,91.47 159.66,91.37 159.66,89.77 159.45,89.57 155.44,89.57 155.21,89.8 155.21,91.25 155.44,91.47 156.94,91.47
+1.0V_MPHYGT on IN2 (solid shape): outline of 1376 points within 146.39,73.24 158.41,90.76
+1.0V_MPHYGT on VCC: 139.8,72.22 139.62,72.4 139.62,75.5 139.23,75.88 139.23,76.56 140,77.32 140,78.97 140.38,79.35 140.38,80.04 140.56,80.22 141.57,80.22 141.95,80.6 154.8,80.6 154.98,80.42 154.98,77.1 153.28,75.4 150.23,75.4 148.45,73.62 145.28,73.62 144.7,73.04 144.7,72.78 144.52,72.6 142.61,72.6 142.23,72.22 ; 1 cut-out
+1.0V_PRIM on TOP (solid shape): 173.04,81.57 173.04,79.56 172.91,79.43 172.63,79.43 172.56,79.51 172.56,81.59 172.68,81.72 172.89,81.72
+1.0V_PRIM on TOP (solid shape): 59.72,67.11 59.72,66.1 59.18,66.1 59.18,65.35 59.72,65.35 59.72,64.9 59.16,64.9 59.16,64.14 59.72,64.14 59.72,62.78 59.28,62.35 57.69,62.35 57.5,62.54 57.5,67.52 57.61,67.62 59.21,67.62
+1.0V_PRIM on TOP (solid shape): 160.57,94.32 160.57,93.18 160.7,93.05 162.48,93.05 162.6,92.92 162.6,92.29 161.97,91.65 159.05,91.65 158.79,91.91 158.79,91.98 158.79,93.48 158.79,93.48 158.79,94.32 158.92,94.45 160.44,94.45
+1.0V_PRIM on BOTTOM (solid shape): 173.7,82.1 173.7,79.46 173.57,79.33 171.2,79.33 171,79.53 171,80.44 171.17,80.6 171.79,80.6 171.92,80.73 171.92,81.87 172.28,82.23 173.57,82.23
+1.0V_PRIM on BOTTOM (solid shape): 160.57,94.03 160.57,91.88 160.32,91.63 158.72,91.63 158.72,91.07 158.28,91.07 158.28,91.63 157.52,91.63 157.52,91.07 157.09,91.07 157.09,91.6 156.25,91.6 156.25,93.18 156.51,93.43 157.78,93.43 158.65,94.31 160.29,94.31
+1.0V_PRIM on IN1 (solid shape): 160.19,94.05 160.19,92.01 159.95,91.77 158.77,91.77 158.5,92.03 158.5,94.1 158.74,94.34 159.9,94.34
+1.0V_PRIM on IN2 (solid shape): 165.21,92.22 164.76,91.78 163.31,91.78 162.6,92.49 162.6,92.67 162.73,92.8 164.63,92.8
+1.0V_PRIM on IN2 (solid shape): 173.27,81.87 173.27,79.59 173.14,79.46 172.64,79.46 172,80.1 172,81.87 172.25,82.13 173.02,82.13
+1.0V_PRIM on IN2 (solid shape): outline of 187 points within 156.89,74.51 163.79,94.19
+1.0V_PRIM on VCC: 57.43,62.44 56.94,62.93 56.94,72.96 55.9,74 54.89,74 54.65,74.23 54.65,74.87 54.14,75.37 54.14,76.9 53.49,77.56 46.5,77.56 45.76,78.3 45.76,88.24 45.76,89.64 47.01,90.89 48.01,90.89 48.01,90.89 48.26,90.89 48.36,90.78 48.36,90.54 49.79,89.11 51.08,89.11 51.84,89.87 52.23,89.87 55.43,89.42 56.43,92.49 56.43,93.38 56.51,93.38 57.88,93.92 58.52,95.24 58.67,95.55 59,95.68 165.78,95.68 165.78,92.01 165.16,91.4 155.13,91.4 153.35,89.62 147.98,89.62 145.82,91.78 140.15,91.78 137.48,89.11 131.59,89.11 130.2,90.51 125.12,90.51 123.85,91.78 97.6,91.78 94.55,88.73 85.37,88.73 83.71,90.38 66.61,90.38 66.36,90.13 61.41,90.13 60.88,89.6 60.88,88.75 61.76,87.86 61.76,86.97 63.54,85.2 63.54,76.69 64.05,76.18 64.05,64.58 61.91,62.44 ; 3 cut-outs
+1.0V_PRIM on VCC: 144.37,66 144.19,66.18 144.19,66.58 145,67.4 145.26,67.4 146.22,68.36 146.22,68.97 145.89,69.3 145,69.3 144.82,69.48 144.82,71.66 144.95,71.79 144.95,72.93 145.38,73.36 148.56,73.36 150.34,75.14 153.38,75.14 155.24,76.99 155.24,78.14 155.42,78.32 156.71,78.32 158.41,76.61 158.41,76.23 159.17,75.47 159.17,74.94 158.74,74.51 158.34,74.51 158.03,74.81 158.03,74.94 157.45,75.52 157.09,75.52 156.25,74.69 156.25,72.27 153.41,69.43 149.85,69.43 148.07,67.65 147.69,67.65 146.47,66.43 146.47,66.05 146.42,66
+1.0V_PRIM on GND4: 79.65,85.3 78,86.95 66.74,86.95 65.6,85.81 50.95,85.81 48.18,88.58 48.18,94.15 56.51,94.15 57.36,94.48 57.76,95.3 58.16,96.11 59,96.44 164.76,96.44 164.76,86.68 163.77,85.68 141.69,85.68 141.18,85.3 130.58,85.3 128.93,86.95 104.84,86.95 103.19,85.3 ; 2 cut-outs
+1.0V_PRIM_CORE on BOTTOM (solid shape): 145.21,69.05 145.41,68.94 145.61,69.05 145.83,69.05 146.04,68.84 146.04,68.67 146.24,68.46 146.24,68.21 146.14,68.11 145.33,68.11 144.97,68.46 144.97,68.52 144.84,68.65 144.84,68.94 144.86,68.96 144.92,69 144.96,69.05
+1.0V_PRIM_CORE on BOTTOM (solid shape): 172.25,39.33 172.25,39.18 172.25,39.17 172.23,39 172.25,38.83 172.25,38.82 172.25,38.65 172.98,37.93 172.98,36.17 172.43,35.62 172.43,34.38 173.06,33.74 173.06,32.47 173.4,32.14 173.4,28.56 171.47,26.63 168.24,26.63 168.11,26.76 168.11,27.09 168.67,27.09 168.67,27.64 168.11,27.64 168.11,27.9 168.67,27.9 168.67,28.43 168.11,28.43 168.11,28.84 169.28,30.01 171.57,30.01 171.85,30.29 171.85,32.32 170.76,33.41 170.76,35.29 171.77,36.31 171.91,36.31 171.91,37.45 171.87,37.45 171.87,37.55 171.75,37.68 171.24,37.68 170.81,38.11 170.81,38.13 170.78,38.13 170.61,38.31 170.61,39.7 170.81,39.9 171.68,39.9
+1.0V_PRIM_CORE on IN3 (solid shape): outline of 4403 points within 140.67,38.31 177.38,72.73
+1.0V_PRIM_CORE on VCC: 163.13,40.98 170.5,40.98 171.44,40.04 172.38,39.1 172.38,38.29 172.02,37.93 157.12,37.93 156.89,38.16 156.89,38.93 156.36,39.46 153.18,39.46 152.95,39.69 152.95,40.45 152.44,40.96 152.44,43.75 148.38,47.82 148.38,52.16 148.38,54.42 142.52,60.28 139.85,60.28 139.11,61.02 139.11,68.43 139.62,68.94 139.62,71.79 139.8,71.97 142.34,71.97 142.72,72.35 144.52,72.35 144.7,72.17 144.7,71.89 144.57,71.77 144.57,69.37 144.9,69.05 145.79,69.05 145.97,68.87 145.97,68.46 145.15,67.65 144.9,67.65 143.93,66.69 143.93,66.07 144.26,65.74 146.68,65.74 147.44,64.98 153.15,64.98 153.33,64.8 153.33,60.13 153.2,60.01 153.2,55.61 156,52.81 156,52.05 156.38,51.67 156.38,48.49 159.55,45.32 159.56,44.56 ; 1 cut-out
+1.0V_PRIM_COREP on TOP (solid shape): 168.63,30.58 168.63,28.61 168.48,28.46 167.76,28.46 167.47,28.75 167.47,30.57 167.54,30.63 168.58,30.63
+1.0V_PRIM_COREP on BOTTOM (solid shape): 166.92,30.82 167.1,30.64 168.55,30.64 168.65,30.54 168.65,29.57 167.96,28.89 167.96,28.3 168.52,28.3 168.52,28.05 167.96,28.05 167.96,27.49 168.52,27.49 168.52,27.24 167.96,27.24 167.96,26.78 167.94,26.76 165.4,26.76 165.24,26.91 165.24,29.98 165.42,30.16 165.42,31.47 165.5,31.55 166.19,31.55
+1.0V_SRAM on IN4 (solid shape): outline of 1187 points within 143.6,68.52 156.3,77.73
+1.0V_VCCST on TOP (solid shape): 156.18,93.84 156.18,93.41 156.13,93.36 156.13,92.92 155.62,92.92 155.62,92.9 155.59,92.9 155.59,92.44 155.62,92.44 155.62,92.41 156.13,92.41 156.13,92.13 155.36,92.13 155.26,92.24 155.26,92.74 154.98,93.02 154.98,93.89 155.06,93.96 156.05,93.96
+1.0V_VCCST on IN3 (solid shape): outline of 1017 points within 143.22,73.11 149.14,82.17
+1.0V_VCCST on IN4 (solid shape): outline of 316 points within 154.73,91.35 165.02,94.83
+1.0V_VCCST_C on TOP (solid shape): 157.56,93.61 157.67,93.59 157.77,93.61 157.78,93.61 158.49,93.61 158.67,93.43 158.67,92.03 158.54,91.91 158.03,91.91 157.78,92.16 157.7,92.16 156.58,92.16 156.58,92.16 156.28,92.16 156.28,92.55 155.74,92.55 155.74,92.78 156.28,92.78 156.28,93.33 156.56,93.61 157.55,93.61
+1.0V_VCCSTG on TOP (solid shape): 90.85,88.99 90.85,87.32 90.72,87.19 89.08,87.19 88.84,87.42 88.84,88.89 89.07,89.11 90.72,89.11
+1.0V_VCCSTG on BOTTOM (solid shape): 176.38,82.57 176.38,82.01 176.99,81.4 177,81.39 177.05,81.26 177.13,81.15 177.13,80.1 176.92,80.1 176.92,80.97 176.37,80.97 176.37,81.16 176.27,81.25 176.27,81.28 175.97,81.58 175,81.58 174.74,81.84 174.74,82.57 174.84,82.67 176.29,82.67
+1.0V_VCCSTG on IN4 (solid shape): 175.48,82.35 175.48,81.75 175.22,81.49 174.59,81.49 173.95,82.13 173.95,82.77 174.29,83.11 174.67,83.11
+1.0V_VCCSTG_C on BOTTOM (solid shape): 176.06,81.03 176.06,80.66 176.62,80.66 176.62,80.48 176.06,80.48 176.06,80.02 175.88,79.84 175.55,79.84 175.33,79.62 175.33,78.98 175.3,78.95 174.44,78.95 173.83,79.56 173.83,81.11 173.93,81.21 175.88,81.21
+1.0VS_VCCIO on TOP (solid shape): 133.32,65.52 133.32,64.99 133.31,64.98 133.31,64.6 133.06,64.35 131.84,64.35 131.61,64.58 131.61,65.36 131.82,65.57 133.27,65.57
+1.0VS_VCCIO on TOP (solid shape): 191.11,30.68 191.11,27.07 191.05,27.01 188.7,27.01 188.61,27.1 188.61,27.49 189.15,27.49 189.15,28.03 188.61,28.03 188.61,28.03 188.61,28.28 189.15,28.28 189.15,28.81 188.61,28.81 188.61,28.83 188.61,29.45 188,30.06 188,30.69 188.21,30.9 190.89,30.9
+1.0VS_VCCIO on TOP (solid shape): outline of 83 points within 138.14,64.35 140.81,67.27
+1.0VS_VCCIO on IN1 (solid shape): outline of 346 points within 131.71,64.35 139.6,66.43
+1.0VS_VCCIO on IN2 (solid shape): outline of 1426 points within 125.31,66 141.57,79.68
+1.0VS_VCCIO on IN3 (solid shape): outline of 6606 points within 131.74,30.29 196.14,66.51
+1.2V_DDR_B+ on TOP (solid shape): 84.86,48.67 84.86,47.08 84.77,47 83.67,47 83,47.67 83,48.81 83.12,48.94 84.59,48.94
+1.2V_DDR_B+ on BOTTOM (solid shape): 82.83,48.78 83.3,48.78 83.43,48.92 84.59,48.92 84.83,48.68 84.83,46.48 84,45.65 84,43.44 83.99,43.43 83.6,43.43 83.57,43.46 83.57,45.23 83.51,45.3 82.47,45.3 81.91,45.86 81.91,46.08 81.62,46.37 81.62,47.43 82.15,47.43 82.15,47.44 82.16,47.44 82.16,47.94 82.15,47.94 82.15,47.97 81.63,47.97 81.63,48.22 82.15,48.22 82.15,48.24 82.16,48.24 82.16,48.74 81.62,48.74 81.62,49.25 81.64,49.28 82.34,49.28
+1.2V_DDRP on TOP (solid shape): 88.69,34.25 88.69,32.85 88.56,32.72 87.04,32.72 86.91,32.85 86.91,34.38 87.04,34.5 88.43,34.5
+1.2V_DDRP on BOTTOM (solid shape): 86.53,42.12 87.42,42.12 87.67,41.87 87.67,40.47 87.17,39.96 86.66,39.96 86.53,40.09 86.53,40.98 85.86,41.65 85.43,41.65 85.35,41.72 85.35,42.24 85.49,42.38 86.28,42.38
+1.2V_DDRP on BOTTOM (solid shape): outline of 98 points within 81.32,30.96 91.74,37.55
+1.2V_MEM on TOP (solid shape): outline of 16916 points within 91.66,33.61 156.13,64.54
+1.2V_MEM on BOTTOM (solid shape): 93.75,38.92 93.75,34.35 93.64,34.25 92.63,34.25 92.5,34.12 91.8,34.12 91.74,34.18 91.74,34.38 92.24,34.38 92.24,36.41 92.19,36.41 92.19,36.72 91.74,36.72 91.74,38.46 92.4,39.12 93.54,39.12
+1.2V_MEM on BOTTOM (solid shape): 92.77,44.66 92.77,43.23 92.91,43.1 92.91,42.76 92.78,42.63 92.55,42.63 92.4,42.78 92.4,42.94 91.58,42.94 91.57,42.93 91.36,43.14 91.36,43.77 91.48,43.9 91.53,43.9 91.55,43.89 91.86,43.82 92.11,44.02 92.12,44.02 92.16,44.07 92.16,44.67 92.22,44.74 92.69,44.74
+1.2V_MEM on BOTTOM (solid shape): outline of 554 points within 114.47,37.3 124.5,43.39
+1.2V_MEM on BOTTOM (solid shape): outline of 3901 points within 96.82,36.92 159.43,46.82
+1.2V_MEM on IN3 (solid shape): outline of 13801 points within 98.98,34.76 155.87,63.71
+1.2V_MEM on VCC: 125.75,34.25 124.99,35.01 92.1,35.01 91.61,35.5 91.61,42.27 93.64,44.3 93.64,48.11 95.04,49.51 95.04,60.81 95.27,61.05 97.6,61.05 98.11,60.54 104.18,60.54 104.44,60.28 104.44,58.14 108.23,54.75 110.41,59.35 110.41,60.56 111.55,61.7 111.55,62.46 111.78,62.7 113.18,62.7 115.34,64.86 124.23,64.86 124.48,65.11 138.4,65.11 138.6,64.91 138.6,60.81 139.64,59.78 142.31,59.78 147.87,54.21 147.87,52.16 147.87,49.51 147.87,47.6 151.93,43.54 151.93,40.75 152.44,40.24 152.44,39.48 152.97,38.95 156.15,38.95 156.38,38.71 156.38,37.78 154.86,36.26 154.86,35.12 153.99,34.25
+1.8V_3.3V_ALW_VTR3 on TOP (solid shape): 263.54,50.73 263.54,50.12 263.14,50.12 263.14,49.56 262.96,49.56 262.96,50.12 260.85,50.12 260.85,49.56 260.67,49.56 260.67,50.12 260.27,50.12 260.22,50.17 260.22,50.55 260.55,50.89 260.79,50.88 260.83,50.89 261.15,51.01 261.22,51.34 261.21,51.37 261.79,51.95 262.32,51.95
+1.8V_MEM on TOP (solid shape): 79.34,48.63 79.34,48.19 79.47,48.05 79.47,47.25 79.29,47.08 78.53,47.08 78.4,47.2 78.4,48.08 78.4,48.65 78.48,48.73 79.24,48.73
+1.8V_MEM on BOTTOM (solid shape): 97.83,42.38 97.83,42 97.71,41.87 96.94,41.87 96.69,41.61 96.69,40.34 97.95,39.08 97.96,39.03 97.96,36.53 97.83,36.41 97.45,36.41 96.82,37.04 96.82,37.42 95.93,38.31 95.93,42 96.56,42.63 97.58,42.63
+1.8V_MEM on BOTTOM (solid shape): 159.59,42.72 159.59,38.89 159.51,38.8 158.74,38.8 158.74,38.74 158.37,38.74 158.34,38.76 158.29,38.77 158.24,38.78 158.19,38.78 158.14,38.77 158.09,38.76 158.05,38.74 157.98,38.74 157.34,38.09 157,38.09 156.81,38.29 156.81,39.59 156.92,39.69 158.18,39.69 158.19,39.64 158.2,39.59 158.22,39.54 158.25,39.5 158.29,39.46 158.33,39.42 158.37,39.39 158.42,39.37 158.47,39.36 158.52,39.35 158.58,39.35 158.63,39.36 158.68,39.38 158.72,39.4 158.77,39.44 158.8,39.47 158.84,39.51 158.86,39.56 158.88,39.61 158.89,39.66 158.9,39.71 159,39.81 159.48,39.81 159.48,40.45 158.87,40.45 158.87,40.4 158.54,40.07 158.49,40.06 158.44,40.05 158.39,40.03 158.34,40.01 158.3,39.98 158.26,39.94 158.23,39.89 158.21,39.85 158.19,39.8 158.18,39.75 158.18,39.69 156.92,39.69 157.65,40.42 157.65,41.75 157.36,42.04 157.06,42.04 156.92,42.18 156.92,42.37 157.03,42.48 157.07,42.52 157.25,42.7 157.48,42.7 157.66,42.88 159.43,42.88
+1.8V_MEM on BOTTOM (solid shape): 113.45,39.07 113.45,36.23 113.4,36.14 113.3,36.14 112.91,35.96 113.21,35.66 113.23,35.66 113.29,35.61 113.2,35.52 112.69,35.52 112.58,35.63 112.58,38.31 111.95,38.94 111.39,38.94 111.39,38.39 111.79,37.98 111.79,37.9 111.73,37.91 111.54,37.9 111.37,37.8 111.33,37.79 111.3,37.8 110.66,38.44 110.56,38.44 110.56,38.49 109.75,38.49 109.75,38.44 109.01,38.44 108.63,38.06 107.87,38.06 107.74,38.19 107.74,39.33 107.87,39.46 109.01,39.46 109.52,39.96 112.56,39.96
+1.8V_MEM on BOTTOM (solid shape): outline of 161 points within 141.27,36.53 146.98,43.14
+1.8V_MEM on BOTTOM (solid shape): outline of 189 points within 123.36,36.62 131.87,42.63
+1.8V_MEM on IN2 (solid shape): outline of 910 points within 122.34,32.34 158.79,42.88
+1.8V_MEM on IN3 (solid shape): outline of 832 points within 77.69,37.93 98.21,52.49
+1.8V_MEM on IN4 (solid shape): outline of 1254 points within 141.77,34.38 159.17,40.98
+1.8V_MEM on IN4 (solid shape): outline of 2743 points within 96.44,34.63 124.38,40.56
+1.8V_PRIM on TOP (solid shape): 156.91,70.52 156.91,69.99 157,69.9 157.23,69.9 157.57,69.55 157.57,69.05 157.44,68.92 157.01,68.92 156.43,69.51 156.43,69.68 156.3,69.81 155.61,69.81 155.52,69.9 154.84,69.9 154.78,69.96 154.78,70.57 154.9,70.7 156.73,70.7
+1.8V_PRIM on TOP (solid shape): 262.81,49.44 262.83,49.44 263.26,49.44 263.29,49.44 263.29,50 263.57,50 263.57,48.56 263.53,48.56 263.53,48.1 263.49,48.07 263.47,48.07 263.42,48.06 263.35,48.04 263.01,48.04 262.5,48.55 262.5,49.97 262.53,50 262.81,50
+1.8V_PRIM on TOP (solid shape): outline of 85 points within 218.61,26.93 223.69,37.93
+1.8V_PRIM on IN3 (solid shape): 220.9,37.8 220.9,36.92 220.64,36.66 218.36,36.66 218.23,36.79 218.23,37.8 218.5,38.08 219.18,38.08 219.29,38.19 220.52,38.19
+1.8V_RUN on TOP (solid shape): 264.4,29.35 264.4,28.91 264.47,28.84 265.42,28.84 265.47,28.79 265.47,28.28 265.58,28.17 265.33,27.91 265.33,27.37 265.87,27.37 266.12,27.63 266.6,27.16 266.6,25.99 263.7,25.99 263.44,26.25 263.44,27.72 263.44,29.68 263.57,29.8 263.95,29.8
+1.8V_RUN on TOP (solid shape): 226.26,48.98 226.26,48.62 226.28,48.6 226.28,45.35 225.87,45.35 225.87,44.79 225.67,44.79 225.67,45.35 225.16,45.35 224.91,45.6 224.91,46.87 225.06,46.87 225.06,46.82 225.08,46.77 225.1,46.72 225.12,46.67 225.16,46.63 225.19,46.59 225.24,46.56 225.29,46.54 225.34,46.52 225.39,46.52 225.44,46.52 225.5,46.52 225.55,46.54 225.6,46.56 225.64,46.59 225.68,46.63 225.71,46.67 225.74,46.72 225.76,46.77 225.77,46.82 225.77,46.87 225.77,46.93 225.76,46.98 225.74,47.03 225.71,47.07 225.68,47.11 225.64,47.15 225.6,47.18 225.55,47.2 225.5,47.22 225.44,47.23 225.39,47.23 225.34,47.22 225.29,47.2 225.24,47.18 225.19,47.15 225.16,47.11 225.12,47.07 225.1,47.03 225.08,46.98 225.06,46.93 225.06,46.87 224.91,46.87 224.91,48.98 225.06,49.13 226.1,49.13
+1.8V_RUN on IN3 (solid shape): outline of 1266 points within 272.2,40.73 291.76,86.45
+1.8V_RUN_AUDIO on TOP (solid shape): 266.11,30.22 266.11,29.86 266.39,29.59 266.39,29.02 266.34,28.97 265.68,28.97 265.58,29.07 265.58,29.32 265.34,29.56 264.45,29.56 264.38,29.63 264.38,30.21 264.45,30.28 266.06,30.28
+1.8V_RUN_CARD on TOP (solid shape): 297.48,51.52 298.58,51.52 298.58,51.51 299.65,51.51 299.73,51.43 299.73,50.5 298.62,50.5 298.49,50.38 296.46,50.38 295.57,51.27 289.73,51.27 289.6,51.39 289.6,52.79 289.73,52.92 296.08,52.92
+1.8V_RUN_CARD on TOP (solid shape): 279.48,55.93 279.48,54.85 279.55,54.77 279.58,54.74 279.6,54.72 280.43,53.88 280.43,51.96 280.37,51.9 279.44,51.9 279.34,52 279.34,53.15 279.49,53.3 279.82,53.3 279.89,53.36 279.96,53.36 279.96,53.97 279.81,53.97 279.25,54.53 279.25,55.93 279.3,55.98 279.42,55.98
+1.8V_RUN_CARD on IN2 (solid shape): outline of 297 points within 279.32,51.01 290.87,54.95
+1.8V_RUN_UZ8 on TOP (solid shape): 225.54,44.64 225.57,44.61 225.99,44.61 226,44.62 226,45.16 226.31,45.16 226.31,44.28 226.03,44 225.39,44 225.19,43.8 225.19,43.74 225.17,43.74 225.17,43.33 225.11,43.27 224.71,43.27 224.55,43.1 222.98,43.1 222.92,43.17 222.92,43.78 223,43.86 223.55,43.86 224.85,45.16 225.54,45.16
+1.8V_VIN on TOP (solid shape): 78.91,55.18 78.91,54.19 78.78,54.06 78.52,54.06 78.01,53.55 78.01,53.01 77.71,52.71 76.8,52.71 76.7,52.82 76.7,53.65 77.09,54.05 77.09,55.17 77.25,55.32 78.77,55.32
+1.8VALWP on TOP (solid shape): 216.32,29.68 216.32,29.04 216.58,28.79 219.24,28.79 219.65,29.19 220.83,29.19 220.83,28.89 220.26,28.89 220.26,28.46 220.27,28.45 220.83,28.45 220.83,26.76 220.69,26.63 215.43,26.63 215.05,27.01 215.05,29.68 215.18,29.8 216.2,29.8
+1VALWP on TOP (solid shape): 62.78,66.38 64.12,66.38 64.26,66.24 64.26,62.06 64.13,61.93 63.29,61.93 62.91,62.32 60.03,62.32 59.87,62.47 59.87,63.62 59.87,64.3 59.33,64.3 59.33,64.75 59.87,64.75 59.87,65.51 59.33,65.51 59.33,65.95 59.88,65.95 59.88,66.67 60.09,66.89 62.27,66.89
+1VALWP on BOTTOM (solid shape): 64.3,66.25 64.3,62.06 64.18,61.93 63.14,61.93 62.63,62.44 59.22,62.44 58.97,62.7 58.97,65.87 59.22,66.13 62.65,66.13 62.91,66.38 64.18,66.38
+1VALWP_B+ on TOP (solid shape): 60.49,73.87 60.49,71.62 60.39,71.52 58.5,71.52 58.34,71.69 58.34,74 58.46,74.13 60.24,74.13
+1VALWP_B+ on BOTTOM (solid shape): 58.34,77.17 58.34,74.51 58.59,74.25 60.11,74.25 60.77,73.59 61.36,73.59 61.42,73.54 61.42,71.98 61.34,71.91 60.68,71.91 60.67,71.92 59.99,71.92 59.81,72.09 58.44,72.09 58.21,72.32 58.21,72.73 57.95,72.98 57.07,72.98 56.94,73.11 56.94,75.24 57.47,75.24 57.47,75.75 56.94,75.75 56.94,76.04 57.47,76.04 57.47,76.55 56.94,76.55 56.94,77.3 57.07,77.43 58.08,77.43
+1VS_VCCIOP on TOP (solid shape): 188.48,28.7 188.49,28.69 189.02,28.69 189.02,28.41 188.49,28.41 188.48,28.4 188.48,27.9 188.49,27.9 189.02,27.9 189.02,27.62 188.46,27.62 188.46,27.14 188.35,27.02 187.27,27.02 187.05,27.24 185.7,27.24 185.46,27.01 185.46,26.25 185.34,26.12 182.54,26.12 182.29,26.37 182.29,28.53 182.67,28.91 187.75,28.91 188,29.17 188.48,29.17
+3.3V_1.8V_PGPPA on TOP (solid shape): 175.08,62.47 175.08,61.91 175.3,61.68 175.3,60.28 175.18,60.16 174.41,60.16 174.39,60.18 174.39,60.42 174.95,60.42 174.95,60.91 174.39,60.91 174.39,61.33 174.29,61.43 173.4,61.43 173.02,61.81 172.38,61.81 172.25,61.93 172.25,62.19 172.64,62.57 174.98,62.57
+3.3V_ALW on TOP (solid shape): 193.72,43.52 193.72,43.27 193.34,42.88 192.19,42.88 191.94,43.14 191.94,43.77 192.07,43.9 193.34,43.9
+3.3V_ALW on TOP (solid shape): 207.31,38.95 207.31,38.31 206.93,37.93 204.39,37.93 204.18,38.14 204.18,39.04 204.24,39.1 204.85,39.1 204.94,39.19 207.06,39.19
+3.3V_ALW on TOP (solid shape): 23.79,35.26 23.79,33.61 23.54,33.36 23.54,32.47 23.22,32.15 22.34,32.15 22.27,32.22 22.27,32.85 21.94,33.18 21.94,35.26 22.19,35.52 23.54,35.52
+3.3V_ALW on TOP (solid shape): 76.94,55.22 76.94,54.9 76.41,54.9 76.41,54.46 76.94,54.46 76.94,54.16 76.2,53.43 74.09,53.43 73.84,53.67 73.84,55.18 73.99,55.33 76.83,55.33
+3.3V_ALW on TOP (solid shape): 175.73,32.71 175.73,32.2 175.63,32.1 175.13,32.1 174.78,31.76 174.78,30.4 174.72,30.34 174.13,30.34 174.06,30.41 174.06,32.62 174.2,32.76 175.69,32.76
+3.3V_ALW on TOP (solid shape): 180.04,35.45 180.04,34.92 179.95,34.83 179.47,34.83 179.37,34.73 179.37,34.03 179.28,33.94 178.68,33.94 178.63,33.99 178.63,35.42 178.74,35.53 179.96,35.53
+3.3V_ALW on TOP (solid shape): 170.15,49.64 170.15,48.93 170.02,48.8 169.18,48.8 169.13,48.85 169.13,49.51 168.57,49.51 168.57,49.72 169.13,49.72 169.13,50.12 169.16,50.15 169.64,50.15
+3.3V_ALW on TOP (solid shape): 73.75,37.63 73.75,36.76 73.73,36.74 73.19,36.74 73.19,36 73.73,36 73.73,35.54 73.19,35.54 73.19,34.81 73.73,34.81 73.73,33.64 73.45,33.36 70.53,33.36 70.27,33.61 70.27,37.8 70.4,37.93 73.45,37.93
+3.3V_ALW on TOP (solid shape): 236.8,33.74 236.85,33.74 239.36,33.74 241.6,33.74 242.23,34.38 246.42,34.38 246.65,34.15 246.65,33.33 246.3,32.98 235.66,32.98 235.27,33.37 235.19,33.37 234.92,33.63 234.92,34.31 235,34.39 236.15,34.39
+3.3V_ALW on TOP (solid shape): 207.31,29.14 206.77,29.14 206.77,28.69 206.84,28.69 206.84,28.65 207.33,28.65 207.33,28.28 207.31,28.25 206.7,28.25 206.29,27.85 206.29,26.12 206.16,25.99 204.89,25.99 204.77,26.12 204.77,28.91 205.33,29.47 207.31,29.47
+3.3V_ALW on TOP (solid shape): 195.67,38.26 195.67,37.57 195.57,37.47 195.57,36.76 195.48,36.68 195.46,36.68 195.45,36.67 195.18,36.67 195.04,36.8 195.04,37.24 194.86,37.42 194.49,37.42 193.98,37.93 193.98,38.36 194.04,38.42 194.54,38.42 194.74,38.62 195.31,38.62
+3.3V_ALW on TOP (solid shape): 264.35,70.19 264.35,69.93 263.8,69.93 263.8,69.43 264.35,69.43 264.35,69.2 264.33,69.17 263.01,69.17 262.81,68.98 262.81,68.92 262.72,68.83 262.72,68.37 262.63,68.28 261.92,68.28 260.9,69.3 260.9,69.78 260.97,69.85 261.62,69.85 261.79,69.68 262.96,69.68 263.51,70.23 264.32,70.23
+3.3V_ALW on TOP (solid shape): 233.55,34.31 233.55,33.66 233.57,33.64 233.57,32.44 232.66,31.54 232.66,31.53 232.56,31.47 232.5,31.37 232.49,31.37 232.33,31.2 232.33,30.31 231.31,30.31 230.67,29.68 230.67,28.03 231.18,27.52 233.21,27.52 233.34,27.39 233.34,26.78 233.24,26.68 230.24,26.68 229.58,27.35 229.58,31.2 230.16,31.79 230.16,31.83 231.44,33.11 231.95,33.11 232.78,33.94 232.78,34.18 232.97,34.37 233.49,34.37
+3.3V_ALW on TOP (solid shape): 264.63,49.76 265.32,49.76 265.43,49.87 266.49,49.87 266.62,49.74 266.62,48.98 266.11,48.47 265.74,48.47 265.74,48.58 265.74,48.59 265.62,48.96 265.23,48.92 265.11,48.8 265.11,48.47 264.2,48.47 264.16,48.51 264.16,48.56 264.12,48.56 263.95,48.73 263.95,49.74 264.08,49.87 264.52,49.87
+3.3V_ALW on TOP (solid shape): 170.76,32.89 170.76,32.27 170.31,31.82 170.31,30.48 170.41,30.22 170.73,30.06 170.76,29.99 170.76,28.88 171.01,28.62 171.01,27.77 170.98,27.75 170.45,27.75 170.38,27.82 170.38,28.33 170.25,28.46 170.25,28.46 170.05,28.66 169.93,28.66 169.4,29.19 169.4,32.35 169.55,32.49 169.55,32.5 169.63,32.55 169.69,32.63 169.69,32.64 170.21,33.16 170.49,33.16
+3.3V_ALW on TOP (solid shape): 259.46,52.02 259.46,51.48 259.48,51.48 259.48,51.11 259.49,51.09 259.59,50.92 259.76,50.83 259.77,50.82 260.09,50.5 260.09,50.12 260.13,50.08 260.13,50 260.2,50 260.21,50 260.52,50 260.52,49.44 260.54,49.44 260.98,49.44 261,49.44 261,50 261.36,50 261.41,49.95 261.41,48.51 261.24,48.35 259.76,48.35 259.61,48.5 259.61,49.87 259.35,50.12 257.88,50.12 257.73,50.28 257.73,50.68 257.76,50.72 257.76,52.18 259.3,52.18
+3.3V_ALW on TOP (solid shape): 265.07,45.39 265.07,45.1 264.35,44.38 264.34,44.38 264.2,44.31 264.13,44.17 264.13,44.15 264,44.03 263.64,44.03 263.43,43.82 263.26,43.65 258.5,43.65 258.49,43.65 258.39,43.67 258.28,43.65 258.27,43.65 257.37,43.65 256.9,44.12 256.9,44.6 257.09,44.79 260.23,44.79 260.24,44.75 260.46,44.51 260.77,44.59 260.96,44.79 263.29,44.79 263.36,44.86 263.47,44.86 263.47,44.97 263.99,45.49 264.98,45.49
+3.3V_ALW on BOTTOM (solid shape): 64.74,71.52 64.74,70.48 65.19,70.03 65.19,69.42 65.19,69.17 65.07,69.05 64.69,69.05 64.56,69.17 64.56,69.94 64.06,70.43 64.05,70.43 64.03,70.46 64.03,71.04 63.67,71.4 63.67,71.68 63.72,71.73 64.53,71.73
+3.3V_ALW on BOTTOM (solid shape): 196.1,38.19 196.1,36.12 195.41,35.43 195.41,33.7 195.16,33.45 194.41,33.45 194.1,33.76 194.1,35.42 194.14,35.47 194.23,35.47 194.38,35.62 194.38,35.92 194.86,36.41 194.86,38.07 195.08,38.28 196,38.28
+3.3V_ALW on BOTTOM (solid shape): 72.59,88.58 75.18,88.58 75.59,88.16 75.59,87.47 75.33,87.21 74.87,87.21 74.74,87.33 74.74,87.82 74.49,88.07 73.78,88.07 73.5,87.79 73.5,87.36 73.32,87.18 72.99,87.18 72.79,87.38 72.79,87.92 72.51,88.2 70.02,88.2 69.72,87.89 69.72,87.59 69.51,87.38 67.89,87.38 67.68,87.59 67.68,88.07 67.58,88.17 66.74,88.17 66.64,88.07 66.64,87.44 66.39,87.18 65.98,87.18 65.8,87.36 65.8,88.5 65.91,88.6 68.83,88.6 69.03,88.81 72.36,88.81
+3.3V_ALW on BOTTOM (solid shape): 246.67,33.74 246.67,33.71 246.65,33.6 246.67,33.49 246.68,33.48 246.68,33.36 246.96,33.08 249.98,33.08 250,33.08 250.61,32.47 250.61,30.06 249.73,29.17 248.33,29.17 248.11,29.39 248.11,30.06 248.23,30.18 248.58,30.18 249.6,31.2 249.6,31.84 249.47,31.96 248.96,31.96 248.71,32.22 247.06,32.22 246.42,31.58 245.66,31.58 245.59,31.66 245.61,31.69 245.68,32.02 245.53,32.33 245.53,33.74 245.66,33.87 246.55,33.87
+3.3V_ALW on BOTTOM (solid shape): 207.07,38.68 207.07,38.41 205.6,36.94 205.4,36.94 205.38,36.94 205.38,35.15 206.17,34.36 206.17,34.32 206.18,34.27 206.2,34.22 206.22,34.18 206.25,34.15 206.29,34.11 206.33,34.09 206.38,34.07 206.42,34.06 206.47,34.06 207.61,32.92 207.62,32.92 207.69,32.85 212.64,32.85 213.35,32.14 213.35,31.57 213.78,31.57 213.78,28.28 212.77,27.26 205.15,27.26 205.02,27.39 205.02,28.15 205.15,28.28 210.66,28.28 210.66,28.28 211.24,28.28 212.26,29.3 212.26,30.95 211.63,31.58 208.2,31.58 207.05,30.44 205.4,30.44 205.14,30.71 205.14,31.57 206.5,31.57 206.5,32.71 205.2,32.71 205.2,31.57 205.14,31.57 205.14,33.37 204.28,34.23 204.28,34.47 204.67,34.85 204.67,36.06 204.67,36.18 204.13,36.72 204.13,38.19 204.7,38.76 207,38.76
+3.3V_ALW on GND1 (solid shape): 180,36.83 180,35.23 179.89,35.11 179.02,35.11 178.82,35.31 178.82,36.8 178.95,36.93 179.9,36.93
+3.3V_ALW on IN1 (solid shape): 266,46.27 266.35,45.99 266.7,46.27 266.71,46.31 267.83,46.31 267.84,46.27 268.02,45.97 268.37,45.98 268.4,46 268.57,45.83 268.57,45.07 268.01,44.51 265.15,44.51 265.14,44.56 264.79,44.89 264.43,44.56 264.43,44.51 264.36,44.51 264.13,44.74 264.13,45.06 264.14,45.07 264.14,45.54 264.53,45.93 265.49,45.93 265.87,46.31 265.99,46.31
+3.3V_ALW on IN2 (solid shape): 82.67,42.83 82.67,41.16 82.36,40.85 80.54,40.85 79.93,41.46 79.93,43.14 80.23,43.44 82.06,43.44
+3.3V_ALW on IN3 (solid shape): 236.39,34.38 236.39,32.47 235.76,31.84 232.45,31.84 232.07,32.22 232.07,33.23 232.45,33.61 234.12,33.61 234.22,33.55 234.18,33.43 234.41,32.8 234.63,33.43 234.6,33.55 234.7,33.61 234.74,33.61 234.93,33.8 234.94,33.81 235.03,33.88 235.11,33.98 235.11,33.98 235.76,34.63 236.14,34.63
+3.3V_ALW on GND3: 169.95,28.53 169.33,29.15 169.33,32.36 174.14,37.17 180.15,37.17 180.76,36.56 180.76,35.62 173.67,28.53
+3.3V_ALW on GND3: 161.18,35.52 160.44,36.26 160.44,43.03 161.18,43.77 163.72,43.77 164.63,44.68 164.63,45.53 163.49,46.67 163.49,48.49 164.23,49.23 168.04,49.23 168.7,49.89 168.7,50.12 169.74,50.12 173.14,46.72 173.14,45.66 171.77,44.28 169.23,44.28 167.3,42.35 167.3,40.83 161.99,35.52
+3.3V_ALW on VCC: outline of 238 points within 13.89,32.09 279.19,95.68 ; 6 cut-outs
+3.3V_ALW_DSW on TOP (solid shape): 147.31,68.97 147.31,68.85 147.62,68.54 147.62,67.52 147.63,67.51 147.63,67.45 147.69,67.45 147.74,67.4 148,67.4 148,67.4 148.13,67.4 148.25,67.27 148.25,66.63 148.12,66.51 147.24,66.51 146.98,66.76 146.98,67.27 146.85,67.4 146.35,67.4 146.22,67.52 146.22,68.56 146.15,68.63 146.15,68.94 146.41,69.2 147.08,69.2
+3.3V_ALW_DSW on IN2 (solid shape): outline of 1249 points within 143.17,49.23 156.76,69.05
+3.3V_ALW_PCH on TOP (solid shape): 166.46,88.99 166.46,88.25 166.46,88.22 166.33,88.1 165.44,88.1 165.06,88.48 162.65,88.48 162.4,88.22 161.51,88.22 161.38,88.35 161.38,89.24 161.76,89.62 165.82,89.62
+3.3V_ALW_PCH on TOP (solid shape): 238.41,39.32 238.41,38.22 238.23,38.03 237.25,38.03 237.25,38.46 236.7,38.46 236.7,38.67 237.25,38.67 237.25,39.15 237.52,39.42 237.52,39.7 237.63,39.81 237.93,39.81
+3.3V_ALW_PCH on VCC: 157.19,63.71 156.76,64.15 156.76,64.78 156.25,65.29 156.25,65.54 155.8,66 155.31,66 154.55,65.24 147.54,65.24 146.73,66.05 146.73,66.33 147.8,67.4 148.18,67.4 149.96,69.17 153.51,69.17 156.18,71.84 160.88,71.84 161.89,72.86 162.3,72.86 162.98,72.17 162.98,64.78 161.92,63.71
+3.3V_ALW_PCH_UZ3 on TOP (solid shape): 237.13,39.1 237.13,38.79 236.57,38.79 236.57,38.35 236.57,38.34 237.13,38.34 237.13,38.03 236.87,38.03 236.64,37.8 236.63,37.8 236.32,37.48 236.56,37.11 236.59,37.1 236.59,36.1 236.42,35.92 235.96,35.92 235.78,35.92 235.5,35.65 234.99,35.65 234.87,35.77 234.87,36.79 235.32,37.25 235.32,38.39 236.06,39.12 237.1,39.12
+3.3V_ALW_UE1 on TOP (solid shape): 268.27,71.31 268.27,70.57 266.62,68.92 264.88,68.92 264.64,69.16 264.52,69.16 264.48,69.2 264.48,69.57 264.48,69.57 264.48,69.8 264.48,69.8 264.48,70.2 264.5,70.21 265.52,70.21 266.57,71.26 266.57,71.79 266.64,71.87 267.71,71.87
+3.3V_ALW_UE1 on VCC: 260.75,51.65 257.98,54.42 257.98,64.11 259.36,65.49 264.82,65.49 266.36,67.04 266.36,71.1 266.59,71.33 268.16,71.33 272.08,67.42 272.08,60.39 270.55,58.86 270.55,57.59 269.98,57.02 269.98,55.37 269.43,54.82 267.27,54.82 264.1,51.65
+3.3V_ALW_UZ12 on TOP (solid shape): 168.98,50.12 168.98,49.87 168.42,49.87 168.42,49.39 168.98,49.39 168.98,48.83 168.9,48.75 167.56,48.75 167.45,48.85 167.45,50.07 167.53,50.15 168.95,50.15
+3.3V_ALWP on TOP (solid shape): 78.4,39.15 78.4,34.5 78.32,34.42 75.78,34.42 75.48,34.12 73.96,34.12 73.88,34.2 73.88,34.96 73.35,34.96 73.35,35.39 73.88,35.39 73.88,36.15 73.35,36.15 73.35,36.58 73.88,36.58 73.88,36.71 73.88,37.68 73.88,37.73 74.21,38.06 77.28,38.06 77.67,38.44 77.67,39.07 77.79,39.2 78.35,39.2
+3.3V_ALWP on BOTTOM (solid shape): 78.4,39.07 78.4,31.2 78.27,31.07 72.05,31.07 71.8,31.33 71.8,34.63 74.08,36.92 75.35,36.92 77.64,39.2 78.27,39.2
+3.3V_CAM on BOTTOM (solid shape): 227.75,37.42 227.75,37.1 227.53,36.88 227.53,35.54 227.53,35.53 227.39,35.12 227.77,34.88 227.89,34.88 228.17,34.61 228.17,34.34 228.17,34 227.85,33.68 226.63,33.68 226.28,34.02 226.28,36.72 226.65,37.08 226.66,37.08 226.81,37.17 226.9,37.32 226.91,37.34 227.25,37.68 227.5,37.68
+3.3V_HDD_M2 on TOP (solid shape): 17.55,14.49 17.55,12.74 17.44,12.63 17.41,12.62 17.14,12.2 17.41,11.78 17.44,11.77 17.44,11.23 17.29,11.07 17.07,11.02 17.07,11.02 16.13,11.02 16.13,11.02 15.79,11.17 15.74,11.54 15.66,11.59 15.66,13.72 16.54,14.6 17.44,14.6
+3.3V_HDD_M2 on TOP (solid shape): outline of 278 points within 27.4,11.13 34.33,22.64
+3.3V_HDD_M2 on IN2 (solid shape): outline of 1399 points within 15.66,11.03 34.59,22.44
+3.3V_M_TPM on GND3: 161.33,44.28 161.33,49.76 162.71,51.14 167.32,51.14 168.19,50.27 168.19,50.1 167.83,49.74 164.02,49.74 162.98,48.7 162.98,46.46 164.13,45.32 164.13,44.89 163.51,44.28
+3.3V_MMI_IN on TOP (solid shape): 275.51,55.08 275.51,54.82 275.38,54.7 275,54.7 274.87,54.57 274.87,54.19 274.87,54.19 274.87,53.87 274.73,53.73 273.68,53.73 273.64,53.76 273.64,55.11 273.73,55.2 275.38,55.2
+3.3V_MMI_IN on TOP (solid shape): 277.92,53.81 277.92,52.54 277.79,52.41 277.41,52.41 277.36,52.36 277.21,52.36 277.21,52.21 277.16,52.16 276.9,52.16 276.78,52.28 276.78,53.17 276.9,53.3 277.28,53.3 277.33,53.34 277.42,53.34 277.42,53.82 277.54,53.93 277.79,53.93
+3.3V_MMI_IN on TOP (solid shape): 282.88,66.26 282.88,65.85 282.34,65.85 282.34,65.31 282.88,65.31 282.88,65.03 282.34,65.03 282.34,64.5 282.88,64.5 282.88,64.06 282.49,63.67 282.49,62.32 282.34,62.16 281.98,62.16 281.81,61.98 281.81,61.58 281.53,61.3 279.95,61.3 279.8,61.14 279.8,60.92 279.75,60.76 279.79,60.59 279.82,60.49 279.88,60.4 279.88,59.24 279.83,59.18 279.73,59.18 279.67,59.24 279.67,60.06 279.33,60.39 279.33,61.32 279.95,61.93 281.27,61.93 281.42,62.09 281.42,62.65 281.35,62.72 280.4,62.72 280.22,62.9 280.22,63.32 280.22,63.33 280.26,63.48 280.22,63.64 280.22,63.65 280.22,66.17 280.33,66.29 282.85,66.29
+3.3V_MMI_IN on IN1 (solid shape): outline of 396 points within 273.32,51.52 282.31,64.17
+3.3V_RUN on TOP (solid shape): 253.66,31.81 254.12,31.35 254.12,30.02 254.04,29.95 252.56,29.95 252.06,30.45 252.06,32.52 252.3,32.76 253.66,32.76
+3.3V_RUN on TOP (solid shape): 171.87,89.37 171.87,88.6 171.62,88.35 168.75,88.35 168.36,87.97 166.71,87.97 166.59,88.1 166.59,89.04 166.59,89.24 166.94,89.6 171.64,89.6
+3.3V_RUN on TOP (solid shape): 22.34,79.43 23.46,79.43 23.54,79.36 23.54,79.08 23.41,78.95 21.53,78.95 21.52,78.95 21.41,78.97 21.3,78.95 21.25,78.95 21.18,79.03 21.18,79.79 21.2,79.82 21.96,79.82
+3.3V_RUN on TOP (solid shape): 156.81,75.37 157.4,75.37 157.52,75.25 157.52,74.71 156.3,73.49 156.3,72.09 156.17,71.97 155.54,71.97 155.41,72.09 155.41,73.49 155.39,73.52 155.39,75.29 155.47,75.37 155.99,75.37 156.81,75.37
+3.3V_RUN on TOP (solid shape): 174.59,39.29 174.59,37.58 174.49,37.47 174.49,36.56 174.44,36.51 174.01,36.51 174.01,37.07 173.55,37.07 173.55,36.51 173.22,36.51 172.94,36.79 172.94,37.98 173.14,38.19 173.14,38.23 173.23,38.31 173.23,38.78 173.27,38.82 173.81,38.82 173.97,38.98 173.97,39.32 174.12,39.47 174.41,39.47
+3.3V_RUN on TOP (solid shape): 19.53,38.86 19.53,38.86 20.17,38.22 20.17,36.72 19.66,36.72 19.66,36.02 20.17,36.02 20.17,35.52 19.66,35.52 19.66,34.82 20.17,34.82 20.17,34.31 19.13,33.27 17.22,33.27 16.5,33.99 16.5,35.31 16.78,35.59 16.78,37.65 16.78,37.97 16.79,37.97 16.79,38.86 17.15,39.22 19.16,39.22
+3.3V_RUN on TOP (solid shape): 283.89,66.19 283.89,64.22 283.71,64.05 283.12,64.05 283.02,64.14 283.02,64.63 283.02,64.65 282.47,64.65 282.47,64.91 283.02,64.91 283.02,65.44 282.47,65.44 282.47,65.69 283.02,65.69 283.02,66.23 283.09,66.3 283.78,66.3
+3.3V_RUN on TOP (solid shape): 35.39,24.06 35.39,22.69 34.93,22.23 31.95,22.23 31.95,22.77 31.41,22.77 31.41,22.23 31.16,22.23 31.16,22.77 30.61,22.77 30.61,22.24 30.6,22.23 30.24,22.23 30.08,22.4 30.08,23.97 30.66,24.56 34.89,24.56
+3.3V_RUN on TOP (solid shape): 276.37,87.3 276.37,86.8 276.65,86.52 276.65,86.1 276.63,86.08 276.55,85.96 276.52,85.83 276.52,85.81 276.17,85.45 276.12,85.45 276.12,85.4 276.01,85.3 276.01,84.79 275.89,84.67 275.25,84.67 275.19,84.73 275.19,87.11 275.48,87.4 276.27,87.4
+3.3V_RUN on TOP (solid shape): 186.73,40.6 188.13,40.6 188.54,40.19 188.54,39.35 188.8,39.08 188.8,37.08 188.64,36.92 188.64,32.92 188.63,32.91 188.78,32.45 189.26,32.57 189.27,32.6 189.34,32.6 189.35,32.57 189.65,32.41 189.95,32.57 189.97,32.6 190.04,32.6 190.05,32.57 190.37,32.41 190.67,32.6 192.07,32.6 193.18,31.48 193.18,30.47 193.07,30.36 192.4,30.36 192.32,30.45 192.32,30.9 191.39,31.84 188.25,31.84 187.88,32.22 187.88,37.89 187.8,37.97 187.8,38.76 187.36,39.2 185.31,39.2 185.19,39.32 185.19,40.52 184.48,41.23 183.68,41.23 183.56,41.36 183.56,42 183.68,42.12 185.21,42.12
