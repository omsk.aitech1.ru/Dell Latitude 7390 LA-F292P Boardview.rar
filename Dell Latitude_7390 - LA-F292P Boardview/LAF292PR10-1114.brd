# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D56: length 32.5
  IN4 w0.08: v2(155.51,41.11) 155.11,41.51 153.39,41.51 152.73,42.17 152.73,42.29 153.08,42.64 153.08,42.75 152.97,42.87 152.86,42.87 152.5,42.51 152.39,42.51 152.16,42.74 152.16,43.82 149.03,46.95 149.03,47.42 149.12,47.51 149.2,47.51 149.29,47.6 149.29,47.74 149.2,47.83 149.12,47.83 149.03,47.92 149.03,52.42 148.82,52.63 148.82,54.11 148.28,54.65 148.14,54.65 147.92,54.42 147.77,54.42 147.63,54.57 147.63,54.71 147.85,54.94 147.85,55.08 147.71,55.22 147.57,55.22 147.38,55.04 147.24,55.04 147.09,55.18 147.09,55.33 147.28,55.51 147.28,55.66 147.09,55.84 147.09,56.9 146.78,57.21 146.78,58.01 146.05,58.74 144.64,58.74 143.32,60.06 143.19,60.06 143.14,60.11 143.14,60.11 142.93,60.32 142.93,60.32 142.59,60.66 142.59,61.6 142.6,61.61 142.6,61.62 142.96,61.97 v2(142.96,62.11)
  BOTTOM w0.076: UC1.AT22 v2(142.96,62.11) ; UD4.C9 v2(155.51,41.11)
DDR_B_D57: length 31.9
  IN4 w0.08: v2(142.96,61.46) 142.96,61.3 143.69,60.56 143.69,60.07 144.72,59.04 146.17,59.04 147.07,58.13 147.07,57.33 147.38,57.02 147.38,55.96 149.75,53.6 149.75,51.45 149.62,51.33 149.62,48.18 150.16,47.65 150.16,47.51 149.79,47.14 149.79,47.01 149.88,46.92 150.02,46.92 150.39,47.29 150.52,47.29 150.61,47.19 150.61,47.06 150.24,46.69 150.24,46.56 150.34,46.46 150.47,46.46 150.84,46.83 150.97,46.83 151.07,46.74 151.07,46.61 150.57,46.11 150.57,45.98 150.66,45.88 150.79,45.88 151.29,46.38 151.42,46.38 151.52,46.29 151.52,46.16 150.94,45.58 150.94,45.45 151.04,45.36 151.17,45.36 151.74,45.93 151.88,45.93 153.16,44.65 153.16,44.28 153.46,43.99 154.98,43.99 155.44,43.52 v2(155.51,43.52)
  BOTTOM w0.076: UC1.AU22 v2(142.96,61.46) ; UD4.C11 v2(155.51,43.52)
DDR_B_D58: length 31
  IN4 w0.08: v2(143.87,61.46) 144.1,61.46 145.37,60.19 145.37,60.13 145.6,59.9 145.88,59.9 145.98,60 146.61,60 148.07,58.54 148.07,57.71 148.38,57.41 148.38,56.82 150.51,54.69 151.17,54.03 151.17,53.52 151.27,53.43 151.36,53.43 151.45,53.33 151.45,53.2 151.36,53.11 151.27,53.11 151.17,53.01 151.17,52.88 151.27,52.79 151.36,52.79 151.45,52.69 151.45,52.56 151.36,52.47 151.27,52.47 151.17,52.37 151.17,52.24 151.27,52.15 151.36,52.15 151.45,52.05 151.45,51.92 151.36,51.83 151.27,51.83 151.17,51.73 151.17,51.6 151.27,51.51 151.36,51.51 151.45,51.41 151.45,51.28 151.36,51.19 151.27,51.19 151.17,51.09 151.17,50.96 151.27,50.87 151.36,50.87 151.45,50.77 151.45,50.64 151.36,50.54 151.27,50.54 151.17,50.45 151.17,50.32 151.27,50.22 151.36,50.22 151.45,50.13 151.45,50 151.36,49.9 150.91,49.9 150.82,49.81 150.82,49.68 150.91,49.58 151.36,49.58 151.45,49.49 151.45,49.36 151.36,49.26 150.73,49.26 150.64,49.17 150.64,49.04 150.73,48.94 151.36,48.94 151.45,48.85 151.45,48.72 151.36,48.62 151.27,48.62 151.17,48.53 151.17,48.14 153.69,45.63 155.4,45.63 155.55,45.48 155.66,45.48 155.71,45.53 155.82,45.53 155.94,45.41 155.94,45.3 155.89,45.25 155.89,45.14 156.25,44.78 156.25,44.27 156.83,43.7 v2(156.83,43.53)
  BOTTOM w0.076: UC1.AU21 v2(143.87,61.46) ; UD4.B11 v2(156.83,43.53)
DDR_B_D59: length 31.7
  IN4 w0.08: v2(143.87,62.11) 145.3,60.68 145.88,60.68 146.13,60.44 146.56,60.44 146.86,60.14 146.99,60.14 147.3,60.45 147.43,60.45 147.52,60.35 147.52,60.22 147.22,59.91 147.22,59.78 147.42,59.58 147.56,59.58 147.68,59.7 147.82,59.7 147.91,59.61 147.91,59.48 147.78,59.35 147.78,59.22 148.04,58.96 148.17,58.96 148.46,59.24 148.59,59.24 148.68,59.14 148.68,59.01 148.4,58.73 148.4,58.6 148.67,58.33 148.67,58.1 148.6,58.02 148.48,58.02 148.4,57.94 148.4,57.77 148.67,57.5 148.67,56.94 151.77,53.85 151.77,47.96 153.54,46.19 153.92,46.19 154.02,46.09 154.02,46 154.11,45.91 154.24,45.91 154.34,46 154.34,46.09 154.43,46.19 154.56,46.19 154.66,46.09 154.66,46 154.75,45.91 154.88,45.91 154.98,46 154.98,46.09 155.07,46.19 155.55,46.19 156.41,45.32 156.41,45.21 156.37,45.16 156.37,45.05 156.48,44.94 156.59,44.94 156.64,44.98 156.75,44.98 157.23,44.5 157.23,43.13 v2(156.83,42.73)
  BOTTOM w0.076: UD4.B10 v2(156.83,42.73) ; UC1.AT21 v2(143.87,62.11)
DDR_B_D60: length 33.9
  IN4 w0.08: v2(142.96,64.02) 142.42,63.48 142.42,61.97 142.05,61.6 142.05,60.56 144.44,58.17 144.99,58.17 146.51,56.65 146.51,54.13 147.36,53.27 147.36,53.26 148.02,52.6 148.02,47.05 151.42,43.65 151.42,42.39 153.99,39.82 154.59,39.82 154.7,39.71 154.7,39.28 154.78,39.2 155.13,39.2 155.21,39.28 155.21,39.91 v2(155.57,40.27)
  BOTTOM w0.076: v2(142.96,64.02) UC1.AN22 ; UD4.C8 155.57,40.44 v2(155.57,40.27)
DDR_B_D61: length 33.7
  IN4 w0.08: v2(156.16,41.11) 155.76,40.7 153.79,40.7 153.21,41.28 153.09,41.28 153.06,41.25 152.94,41.25 152.83,41.36 152.83,41.48 152.87,41.51 152.87,41.62 152.75,41.74 152.64,41.74 152.6,41.7 152.49,41.7 152.38,41.82 152.38,41.93 152.41,41.96 152.41,42.08 152.3,42.19 152.19,42.19 152.15,42.15 152.04,42.15 151.93,42.27 151.93,42.38 151.96,42.42 151.96,42.53 151.72,42.77 151.72,43.78 148.74,46.76 148.74,47.2 148.66,47.28 148.51,47.28 148.43,47.36 148.43,47.52 148.51,47.6 148.66,47.6 148.74,47.68 148.74,52.3 148.4,52.63 148.4,52.8 148.52,52.92 148.52,53.07 148.38,53.21 148.24,53.21 148.16,53.13 147.92,53.13 146.8,54.25 146.8,56.78 146.49,57.08 146.49,57.89 145.93,58.45 144.55,58.45 142.38,60.61 142.38,61.69 142.59,61.89 142.59,63.01 v2(142.96,63.38)
  BOTTOM w0.076: UC1.AP22 v2(142.96,63.38) ; UD4.B9 v2(156.16,41.11)
DDR_B_D62: length 33.2
  IN4 w0.08: v2(156.2,40.29) 156.2,40.45 157.82,42.06 157.82,44.74 155.83,46.73 153.76,46.73 152.35,48.14 152.35,54.09 149.82,56.62 149.26,57.19 149.26,60.2 148.43,61.02 146.36,61.02 146.26,61.12 145.51,61.12 145.17,61.46 145.17,63 v2(144.79,63.38)
  BOTTOM w0.076: UD4.B8 156.2,40.42 v2(156.2,40.29) ; UC1.AP21 v2(144.79,63.38)
DDR_B_D63: length 34.1
  IN4 w0.08: v2(156.19,41.91) 156.33,41.77 156.33,41.51 156.38,41.46 156.84,41.46 157.04,41.67 157.04,41.78 156.85,41.97 156.85,42.08 156.96,42.2 157.08,42.2 157.27,42.01 157.38,42.01 157.53,42.15 157.53,44.62 155.69,46.46 153.65,46.46 152.06,48.05 152.06,53.97 148.96,57.07 148.96,60.07 148.31,60.73 146.19,60.73 146.01,60.91 145.42,60.91 144.33,62 144.33,63.54 v2(143.87,63.99)
  BOTTOM w0.076: v2(143.87,63.99) 144.33,64.39 UC1.AN21 ; UD4.C10 v2(156.19,41.91)
DDR_B_DQS0: length 25.8
  IN1 w0.094: v2(132.85,42.75) 132.85,42.9 132.66,43.08 132.41,43.08 132.11,43.38 132.11,44.5 131.46,45.14 131.46,45.6 131.89,46.03 132.33,46.03 132.59,46.3 132.9,46.3 133.7,45.5 133.85,45.5 133.96,45.61 133.96,45.77 133.17,46.56 133.17,46.88 133.39,47.1 133.7,47.1 134.12,46.69 134.27,46.69 134.38,46.8 134.38,46.95 133.97,47.37 133.97,47.68 134.5,48.21 134.5,49.34 135.01,49.85 135.01,52.18 135.13,52.31 135.13,55.01 135,55.14 134.8,55.14 134.7,55.05 v2(134.7,54.93)
  BOTTOM w0.076: UD3.P10 v2(132.85,42.75) ; v2(134.7,54.93) 134.53,55.1 134.39,55.1 134.14,55.36 134.14,58.29 134.26,58.42 134.26,58.81 134.22,58.9 134.22,59.18 134.25,59.28 134.25,59.43 134.24,59.46 134.2,59.58 134.2,59.74 134.26,60.01 134.55,60.29 UC1.AY38
DDR_B_DQS1: length 21.3
  IN4 w0.094: v2(134.8,42.73) 134.8,42.86 134.64,43.03 134.46,43.03 134.19,43.29 134.19,47.52 136.91,50.24 136.91,54.87 136.21,55.57 136.21,56.11 136.65,56.55 136.92,56.55 v2(137.11,56.74)
  BOTTOM w0.076: UD3.L10 v2(134.8,42.73) ; v2(137.11,56.74) 137.26,56.6 137.55,56.6 137.62,56.67 137.62,57.27 137.29,57.6 137.29,58.41 137.25,58.6 137.25,58.83 137.29,58.95 137.29,59.02 137.24,59.18 137.24,59.43 137.3,59.65 137.3,59.74 137.24,59.88 137.19,59.94 137.08,59.94 137,59.86 UC1.BA34
DDR_B_DQS2: length 25.5
  IN1 w0.076: 135.89,59.51 135.88,59.51 134.37,61.02 134.37,62.32 134.13,62.56 133.99,62.56 v2(133.81,62.73)
  IN1 w0.094: 135.89,59.51 136.38,59.01 138.17,59.01 138.96,58.23 138.96,47.18 138.42,46.64 138.42,46.37 138.65,46.14 138.65,45.73 138.42,45.5 138.42,45.24 138.65,45.01 138.65,44.59 138.42,44.36 138.42,44.17 138.75,43.84 138.75,43.34 138.14,42.73 v2(138.06,42.73)
  BOTTOM w0.076: UC1.AR38 v2(133.81,62.73) ; UD3.G10 v2(138.06,42.73)
DDR_B_DQS3: length 29.3
  IN4 w0.076: v2(137.47,62.75) 137.69,62.53 137.69,62.2 137.81,62.08 137.81,61.26 138.18,60.9 138.43,60.9 139.91,59.42 140.47,59.42 140.79,59.1 140.79,59.08 140.81,59.07
  IN4 w0.094: v2(149.02,42.73) 148.84,42.55 148.84,42.28 148.64,42.08 146.3,42.08 144.87,43.5 144.87,47.36 143.65,48.58 143.65,56.6 142.02,58.24 141.64,58.24 140.81,59.07
  BOTTOM w0.076: UD4.P10 v2(149.02,42.73) ; UC1.AR32 v2(137.47,62.75)
DDR_B_DQS4: length 24
  IN4 w0.094: v2(139.76,55.27) 139.94,55.45 140.11,55.45 140.23,55.33 140.23,47.92 140.12,47.81 139.46,47.81 139.23,47.58 139.23,47.27 139.46,47.05 140.12,47.05 140.23,46.94 140.23,46.66 139.99,46.43 139.26,46.43 138.98,46.15 138.98,44.24 138.89,44.15 138.72,44.15 138.52,43.94 138.52,43.33 138.72,43.12 139.13,43.12 139.3,42.95 139.3,42.52 139.61,42.21 139.9,42.21 140.01,42.11 v2(140.01,41.89)
  BOTTOM w0.076: UD3.D10 v2(140.01,41.89) ; v2(139.76,55.27) 139.57,55.46 139.38,55.46 139.19,55.65 139.19,58.44 139.24,58.49 139.24,58.82 139.2,58.9 139.18,58.94 139.18,59.12 139.24,59.27 139.24,59.41 139.17,59.58 139.17,59.75 139.22,59.89 139.27,59.96 139.33,60.06 139.38,60.12 139.38,60.12 139.42,60.18 UC1.AY30
DDR_B_DQS5: length 26.9
  IN1 w0.094: v2(144.37,52.14) 144.37,52.19 144.59,52.41 144.75,52.41 144.86,52.52 145.22,52.52 145.47,52.27 145.47,45.79 146.44,44.83 146.44,42.42 146.75,42.11 149.93,42.11 150.46,42.63 150.46,42.78 150.72,43.04 150.88,43.04 150.98,42.93 v2(150.98,42.72)
  BOTTOM w0.076: 143.32,54.59 143.3,54.61 143.3,54.65 143.11,54.84 143.11,56.2 142.72,56.58 142.72,57.61 142.35,57.99 142.35,58.31 142.22,58.43 142.22,58.85 142.27,58.94 142.27,59.13 142.23,59.2 142.23,59.49 142.28,59.6 142.28,59.74 142.22,59.88 142.11,59.93 142.05,59.92 141.98,59.83 UC1.BA26 ; UD4.L10 v2(150.98,42.72)
  BOTTOM w0.13: 143.32,54.59 143.32,52.75 143.74,52.33 143.74,52.33 143.76,52.31 144.2,52.31 v2(144.37,52.14)
DDR_B_DQS6: length 30.4
  IN1 w0.076: 141.57,59.98 141.57,59.99 141.25,60.31 141.25,60.59 140.59,61.25 140.59,62.58 140.42,62.75 v2(140.21,62.75)
  IN1 w0.094: 141.57,59.98 143.15,58.4 145.96,58.4 146.21,58.16 146.21,57.1 147.91,55.4 148.93,55.4 151.16,53.17 151.16,52.18 150.03,51.05 150.03,47.8 153.11,44.72 153.11,44.26 152.69,43.84 152.69,43.4 153.14,42.95 153.35,42.95 v2(153.56,42.74)
  BOTTOM w0.076: v2(153.56,42.74) UD4.G10 ; UC1.AR27 v2(140.21,62.75)
DDR_B_DQS7: length 30.3
  IN4 w0.076: 144.58,60.32 144.56,60.33 144.55,60.33 144.04,60.84 143.93,60.84 143.5,61.27 143.5,62.9 143.57,62.98 143.73,62.98 143.87,62.83 v2(143.87,62.75)
  IN4 w0.094: v2(155.53,41.91) 155.53,41.95 155.82,42.23 155.94,42.23 156.37,42.66 156.37,43.51 154.74,45.14 153.56,45.14 150.21,48.5 150.21,51.09 150.33,51.21 150.33,54.31 149.07,55.57 148.78,55.57 148.75,55.55 148.62,55.55 148.33,55.84 148.33,55.98 148.35,56 148.35,56.29 147.97,56.67 147.97,57.26 147.68,57.55 147.68,58.35 146.43,59.61 145.28,59.61 144.58,60.32
  BOTTOM w0.076: UC1.AR21 v2(143.87,62.75) ; v2(155.53,41.91) UD4.D10
DDR_B_DQS#0: length 25.8
  IN1 w0.094: v2(132.85,43.53) 132.85,43.38 132.74,43.27 132.49,43.27 132.3,43.46 132.3,44.57 131.65,45.22 131.65,45.52 131.97,45.84 132.41,45.84 132.67,46.11 132.82,46.11 133.62,45.31 133.93,45.31 134.15,45.53 134.15,45.85 133.36,46.64 133.36,46.8 133.47,46.91 133.63,46.91 134.04,46.49 134.35,46.49 134.58,46.72 134.58,47.03 134.16,47.44 134.16,47.6 134.69,48.13 134.69,49.26 135.2,49.77 135.2,52.1 135.32,52.23 135.32,55.09 135.08,55.33 134.81,55.33 134.7,55.44 v2(134.7,55.61)
  BOTTOM w0.076: UD3.P11 v2(132.85,43.53) ; v2(134.7,55.61) 134.7,55.38 134.59,55.27 134.46,55.27 134.3,55.43 134.3,58.22 134.43,58.35 134.43,58.84 134.38,58.94 134.38,59.15 134.41,59.25 134.41,59.45 134.4,59.51 134.36,59.61 134.36,59.72 134.41,59.92 134.49,60 134.6,60 134.67,59.92 134.67,59.7 UC1.BA38
DDR_B_DQS#1: length 21.3
  IN4 w0.094: v2(134.81,43.54) 134.81,43.31 134.72,43.22 134.54,43.22 134.38,43.37 134.38,47.44 137.1,50.16 137.1,54.95 136.4,55.65 136.4,56.03 136.73,56.36 136.96,56.36 137.11,56.2 v2(137.11,56.16)
  BOTTOM w0.076: v2(137.11,56.16) 137.11,56.25 137.29,56.43 137.62,56.43 137.79,56.61 137.79,57.34 137.46,57.67 137.46,58.43 137.41,58.62 137.41,58.8 137.45,58.92 137.45,59.05 137.4,59.2 137.41,59.41 137.46,59.63 137.46,59.77 137.38,59.98 137.3,60.05 137.1,60.25 137.1,60.32 UC1.AY34 ; UD3.L11 v2(134.81,43.54)
DDR_B_DQS#2: length 25.5
  IN1 w0.076: v2(133.81,62.08) 133.81,62.31 133.9,62.39 134.06,62.39 134.19,62.25 134.19,60.95 135.71,59.44 135.71,59.43 135.76,59.38 135.76,59.37
  IN1 w0.094: 135.76,59.37 136.3,58.82 138.09,58.82 138.77,58.15 138.77,47.26 138.23,46.72 138.23,46.29 138.46,46.06 138.46,45.8 138.23,45.58 138.23,45.16 138.46,44.93 138.46,44.67 138.23,44.44 138.23,44.09 138.56,43.76 138.56,43.42 138.43,43.29 138.3,43.29 v2(138.06,43.53)
  BOTTOM w0.076: UC1.AT38 134.34,62.4 134.34,62.23 134.19,62.08 v2(133.81,62.08) ; v2(138.06,43.53) 138.15,43.44 138.15,43.31 137.96,43.12 UD3.G11
DDR_B_DQS#3: length 29.2
  IN4 w0.076: v2(138.39,62.75) 137.93,62.75 137.86,62.68 137.86,62.28 137.98,62.15 137.98,61.33 138.25,61.07 138.51,61.07 139.98,59.6 140.54,59.6 140.92,59.22 140.93,59.22 140.94,59.2
  IN4 w0.094: v2(148.36,42.71) 148.49,42.71 148.65,42.55 148.65,42.36 148.56,42.27 146.38,42.27 145.06,43.58 145.06,47.44 143.84,48.66 143.84,56.68 142.1,58.43 141.72,58.43 140.94,59.2
  BOTTOM w0.076: v2(148.36,42.71) 148.52,42.71 148.7,42.88 UD4.P11 ; UC1.AT32 v2(138.39,62.75)
DDR_B_DQS#4: length 24.1
  IN4 w0.094: v2(139.76,55.93) 139.76,55.82 139.94,55.64 140.19,55.64 140.42,55.41 140.42,47.84 140.2,47.61 139.54,47.61 139.43,47.5 139.43,47.35 139.54,47.24 140.2,47.24 140.42,47.02 140.42,46.58 140.07,46.24 139.34,46.24 139.17,46.07 139.17,44.16 138.97,43.96 138.8,43.96 138.71,43.86 138.71,43.4 138.8,43.31 139.21,43.31 139.49,43.03 139.49,42.6 139.68,42.41 139.91,42.41 140.01,42.5 v2(140.01,42.69)
  BOTTOM w0.076: v2(139.76,55.93) 139.76,55.7 139.68,55.62 139.45,55.62 139.35,55.72 139.35,58.37 139.4,58.42 139.4,58.85 139.35,58.97 139.35,58.98 139.35,59.08 139.41,59.24 139.41,59.44 139.33,59.61 139.33,59.72 139.37,59.81 139.45,59.94 139.59,59.97 139.68,59.92 139.71,59.81 UC1.BA30 ; UD3.D11 v2(140.01,42.69)
DDR_B_DQS#5: length 27
  IN1 w0.094: v2(150.98,43.52) 150.98,43.33 150.88,43.23 150.64,43.23 150.27,42.86 150.27,42.71 149.85,42.3 146.83,42.3 146.63,42.5 146.63,44.91 145.66,45.87 145.66,52.35 145.3,52.71 144.78,52.71 144.67,52.6 144.58,52.6 144.37,52.81 v2(144.37,52.85)
  BOTTOM w0.076: UD4.L11 v2(150.98,43.52) ; UC1.AY26 142.04,60.22 142.08,60.12 142.18,60.08 142.35,60.01 142.44,59.78 142.44,59.56 142.39,59.45 142.39,59.24 142.43,59.16 142.43,58.91 142.4,58.83 142.39,58.82 142.39,58.5 142.51,58.38 142.51,58.06 142.88,57.69 142.88,56.65 143.27,56.26 143.27,54.92 143.42,54.77 143.46,54.77
  BOTTOM w0.13: 143.46,54.77 143.53,54.7 143.53,52.84 143.83,52.54 143.83,52.54 143.85,52.52 144.2,52.52 144.37,52.69 v2(144.37,52.85)
DDR_B_DQS#6: length 30.4
  IN1 w0.076: 141.67,60.15 141.66,60.16 141.64,60.16 141.42,60.38 141.42,60.66 140.76,61.32 140.76,62.64 140.87,62.75 v2(141.13,62.75)
  IN1 w0.094: 141.67,60.15 142.02,59.8 142.02,59.8 143.23,58.59 146.04,58.59 146.4,58.24 146.4,57.18 147.99,55.59 149.01,55.59 151.35,53.25 151.35,52.1 150.22,50.97 150.22,47.88 153.3,44.8 153.3,44.18 152.88,43.76 152.88,43.48 153.22,43.14 153.43,43.14 153.58,43.29 v2(153.58,43.53)
  BOTTOM w0.076: UC1.AR25 v2(141.13,62.75) ; v2(153.58,43.53) UD4.G11
DDR_B_DQS#7: length 30.2
  IN4 w0.076: 144.44,60.18 144.43,60.19 144.43,60.21 143.97,60.66 143.86,60.66 143.32,61.2 143.32,62.98 143.5,63.15 143.65,63.15 143.87,63.37 v2(143.87,63.38)
  IN4 w0.094: v2(155.53,42.71) 155.53,42.56 155.66,42.42 155.86,42.42 156.18,42.74 156.18,43.43 154.66,44.95 153.48,44.95 150.02,48.42 150.02,51.17 150.14,51.29 150.14,54.23 148.99,55.38 148.86,55.38 148.83,55.36 148.54,55.36 148.14,55.76 148.14,56.06 148.16,56.08 148.16,56.21 147.78,56.59 147.78,57.18 147.49,57.47 147.49,58.27 146.35,59.42 145.21,59.42 144.44,60.18
  BOTTOM w0.076: v2(155.53,42.71) UD4.D11 ; UC1.AR22 v2(143.87,63.38)
DDR_B_ODT0: length 78.5
  IN1 w0.08: v2(151.89,40.03) 151.01,39.16 149.95,39.16 149.88,39.09 149.88,39.09 149.81,39.02 149.62,38.82 146.88,38.82 146.15,38.09 145.17,38.09 144.88,38.38 v2(142.79,38.38) 142.46,38.38 142.41,38.33 141.89,38.33 140.9,39.32 140.46,39.32 140.35,39.42 140.35,39.8 140.25,39.9 140.05,39.9 139.95,39.8 139.95,39.42 139.85,39.32 139.64,39.32 139.54,39.42 139.54,39.95 139.44,40.05 139.24,40.05 139.14,39.95 139.14,39.42 139.03,39.32 138.83,39.32 138.73,39.42 138.73,39.74 138.63,39.84 138.42,39.84 138.32,39.74 138.32,39.42 138.22,39.32 137.93,39.32 137.03,40.21 136.57,40.21 v2(136.55,40.2)
  IN2 w0.089: v2(133.16,57.31) 132.94,57.31 132.75,57.12 132.75,54.96 132.25,54.45 132.25,54.09 132.48,53.85 132.48,53.65 132.25,53.41 132.25,50.12 132.56,49.8 132.56,49.65 132.22,49.31 132.22,49.16 132.32,49.06 132.47,49.06 132.81,49.4 132.96,49.4 133.06,49.3 133.06,49.15 132.72,48.81 132.72,48.66 132.83,48.56 132.97,48.56 133.32,48.9 133.46,48.9 133.57,48.8 133.57,48.65 133.22,48.31 133.22,48.16 133.33,48.05 133.48,48.05 133.82,48.4 133.97,48.4 134.07,48.29 134.07,48.15 133.73,47.8 133.73,47.66 133.83,47.55 133.98,47.55 134.32,47.89 134.47,47.89 134.57,47.79 134.57,47.64 134.23,47.3 134.23,47.15 134.33,47.05 134.48,47.05 134.82,47.39 134.97,47.39 135.08,47.29 135.08,47.14 134.73,46.8 134.73,46.65 134.84,46.55 134.98,46.55 135.26,46.82 135.99,46.82 136.09,46.72 136.09,44.87 136.2,44.76 136.34,44.76 136.45,44.87 136.45,46.72 136.55,46.82 136.7,46.82 136.8,46.72 136.8,45.02 136.91,44.91 137.06,44.91 137.16,45.02 137.16,46.72 137.26,46.82 138.14,46.82 138.25,46.72 138.25,46.04 138.35,45.93 138.5,45.93 138.6,46.04 138.6,46.72 138.71,46.82 138.85,46.82 138.96,46.72 138.96,46.04 139.06,45.93 139.21,45.93 139.31,46.04 139.31,46.72 139.42,46.82 140.26,46.82 140.45,46.64 140.45,46.49 140.29,46.33 140.29,46.18 140.39,46.07 140.54,46.07 140.7,46.24 140.85,46.24 140.95,46.13 140.95,45.99 140.79,45.82 140.79,45.67 140.89,45.57 141.04,45.57 141.2,45.73 141.35,45.73 141.45,45.63 141.45,45.48 141.29,45.32 141.29,45.17 141.4,45.07 141.54,45.07 141.71,45.23 141.85,45.23 141.96,45.13 141.96,44.98 141.79,44.82 141.79,44.67 141.9,44.56 142.05,44.56 142.21,44.73 142.36,44.73 142.66,44.42 142.66,42.7 142.51,42.54 141.58,42.54 141.49,42.45 141.49,42.29 141.6,42.19 142.57,42.19 142.66,42.1 142.66,38.51 v2(142.79,38.38)
  BOTTOM w0.076: UD3.J8 136.55,40.59 v2(136.55,40.2) ; v2(133.16,57.31) 132.61,57.86 132.61,58.35 132.46,58.5 132.46,58.83 132.49,58.91 132.71,59.13 UC1.BA42 ; UD4.J8 v2(151.89,40.03)
  BOTTOM w0.127: v2(142.79,38.38) 142.79,37.72 142.18,37.11 142.18,36.46 142.46,36.18 142.46,33.35 RD64.1
DDR_VTT_CTRL: length 34.1
  TOP w0.086: v3(98.47,47.28) 98.47,46.97 98.53,46.92 98.63,46.87 UD5.2
  GND1 w0.086: v4(98.62,48.14) 98.47,47.99 v3(98.47,47.28)
  IN2 w0.061: v2(114.9,59.34) 115.29,59.72 117.44,59.72 117.8,59.37 117.8,58.88 110.69,51.77 110.08,51.77 106.45,48.14 v4(98.62,48.14)
  BOTTOM w0.076: v2(114.9,59.34) 114.9,59.33 115.84,58.39 116.09,58.39 116.33,58.62 116.33,59.1 116.43,59.2 116.43,59.36 117.14,60.08 117.28,60.08 117.8,60.6 UC1.AW67
DDR_XDP_WAN_SMBCLK: length 153.9
  TOP w0.086: v2(60.44,92.95) 60.87,92.53 JXDP1.53 ; RC319.1 161.36,75.25 162.32,75.25 163.54,76.47 163.54,79.82 164.22,80.49 164.22,81.71 v3(164.13,81.8) 163.97,81.95 163.62,81.95 163.39,81.72 163.39,80.73 162.85,80.19 162.85,78.64 162.3,78.09 v6(162.17,78.09) 162.17,77.96 161.85,77.64 161.65,77.64 161.18,77.17 160.32,77.17 159.89,76.74 156.52,76.74 156.19,77.07 156.19,77.81 155.96,78.04 154.51,78.04 153.85,77.38 152.8,77.38 151.87,76.45 QC2.1
  GND1 w0.086: v3(164.13,81.8) 164.36,82.03 v4(164.36,82.3)
  IN1 w0.051: v2(60.44,92.95) 60.44,93.02 61.8,94.38 78.74,94.38 79.66,93.45 85.97,93.45 89.22,90.2 91.69,90.2 95.53,94.04 95.78,94.04 113.16,94.04 114.29,92.91 123.59,92.91 126,95.31 143.45,95.31 148.04,90.72 151.76,90.72 153.46,92.41 153.46,93.84 v4(154.07,94.45)
  IN2 w0.061: v4(164.36,82.3) 164.89,82.84 164.89,83.85 165.47,84.44 165.47,89.21 161.31,93.38 161.31,94.45 160.85,94.9 154.53,94.9 v4(154.07,94.45)
DDR_XDP_WAN_SMBDAT: length 140.5
  TOP w0.086: v3(163.77,81.59) 163.77,80.87 v6(163.79,80.86) 163.79,80.64 163.19,80.04 163.19,78.5 161.99,77.3 161.61,77.3 161.23,76.92 161.13,76.92 RC318.1 160.54,76.34 159.39,76.34 158.48,75.42 157.66,75.42 157.54,75.55 154.2,75.55 QC2.4 ; JXDP1.51 61.47,92.53 v2(61.03,92.97)
  GND1 w0.086: v4(163.75,82.23) 163.77,82.2 v3(163.77,81.59)
  IN1 w0.051: v4(154.09,93.73) 154.09,92.62 151.89,90.41 147.92,90.41 143.32,95 126.15,95 123.6,92.46 114.05,92.46 112.77,93.74 95.65,93.74 91.82,89.9 89.1,89.9 85.85,93.15 79.53,93.15 78.61,94.07 62.13,94.07 v2(61.03,92.97)
  IN2 w0.061: v4(163.75,82.23) 163.75,82.25 164.57,83.08 164.57,83.98 165.16,84.57 165.16,89.08 160.99,93.25 160.99,94.32 160.72,94.59 154.95,94.59 v4(154.09,93.73)
DEBUG_TX: length 3.3
  BOTTOM w0.086: RE30.2 RE74.2 241.58,31.57 v1(241.03,31.01) JDEG1.9
DISP_ON: length 8.4
  BOTTOM w0.086: JEDP1.17 220.25,36.97 220.47,36.75 220.47,36.61 RV2.1 219.8,35.95 v1(219.8,34.55) 217.18,31.93 DV2.1
DISPLAY_HPD_EC#: length 317.4
  TOP w0.086: RV312.2 16.55,53.17 15.09,54.63 QV6.1 14.9,54.16 v2(14.42,53.68) ; v2(267.77,56.19) 267.39,56.57 UE1.L11
  IN2 w0.061: v4(267.56,44.05) 267.27,43.76 267.27,42.27 266.26,41.26 264.02,41.26 261.41,38.65 261.41,36.95 260.72,36.27 260.72,28.56 257.7,25.54 251.92,25.54 250.83,26.62 242.95,26.62 241.66,25.33 200.21,25.33 198.74,26.8 191.54,26.8 191.06,26.32 177.48,26.32 176.78,25.62 160.07,25.62 159.75,25.94 159.74,25.94 155.86,29.82 145.17,29.82 144.69,29.34 126.78,29.34 125.71,28.26 106.67,28.26 105.05,29.89 29.85,29.89 28.56,28.59 28.56,27.91 25.62,24.97 24.14,24.97 23.35,25.76 20.79,25.76 19.73,26.82 19.73,30.43 16.87,33.29 16.87,45.9 14.42,48.35 v2(14.42,53.68)
  IN4 w0.051: v4(267.56,44.05) 265.96,45.65 265.96,53.1 266.29,53.43 266.29,54.42 266.57,54.7 266.57,55.66 266.77,55.86 267.44,55.86 v2(267.77,56.19)
DMIC0: length 57.4
  TOP w0.086: v3(261.97,35.89) 262.07,35.89 262.44,35.52 UA1.5
  GND1 w0.086: v3(261.97,35.89) 261.97,35.58 v4(261.81,35.43)
  GND5 w0.086: v4(261.81,35.43) v5(262.3,35.43)
  BOTTOM w0.086: v5(262.3,35.43) 262.76,34.97 262.76,32.16 259.45,28.85 256.41,28.85 254.84,27.28 248.7,27.28 247.34,25.92 v1(237.7,25.92) 235.86,25.92 234.21,27.57 233.49,27.57 232.34,28.72 232.34,30.14 231.33,31.15 231.33,33.39 232.57,34.63 232.57,36.15 232.29,36.43 231.04,36.43 230.91,36.29 229.6,36.29 CA6.1 229.24,36.92 228.57,37.6 228.57,39.19 228.36,39.4 227.9,39.4 227.75,39.26 JEDP1.2
DMIC_CLK0: length 56.1
  TOP w0.086: v3(261.05,35.09) 260.54,35.09 CA54.1
  GND1 w0.117: v3(261.05,35.09) 261.14,35.01 v4(261.14,34.62)
  GND5 w0.127: v5(261.22,34.04) 261.14,34.12 v4(261.14,34.62)
  BOTTOM w0.086: v5(261.22,34.04) 261.98,33.28 261.98,31.69 260.56,30.27 257.48,30.27 254.7,27.49 248.57,27.49 247.35,26.27 236.07,26.27 v1(235.69,26.64) 234.52,27.82 233.55,27.82 232.55,28.81 232.55,30.27 231.54,31.28 231.54,33.3 232.78,34.54 232.78,36.24 232.38,36.64 CA5.1 230.44,36.67 229.86,37.25 229.22,37.25 228.78,37.69 228.78,39.33 228.22,39.89 227.04,39.89 226.75,39.59 JEDP1.4
DMIC_CLK_CODEC: length 2.2
  TOP w0.086: UA1.6 v1(262.93,35.12) 262.38,35.12 262.35,35.09 RA14.2
DPSNK0_DDC_CLK: length 3.4
  TOP w0.086: RT341.2 RT14.1 RT126.1 36.96,61.17 v2(36.6,61.53)
  BOTTOM w0.086: UT1.Y5 v2(36.6,61.53)
DPSNK0_DDC_DATA: length 5.2
  TOP w0.086: v2(34,62.18) v1(34,62.78) 33.95,62.84 RT127.1 34.38,64.27 34.38,65.06 34.84,65.52 RT15.1 34.03,65.67 RT342.2
  BOTTOM w0.086: UT1.R4 v2(34,62.18)
DPSNK1_DDC_CLK: length 5.4
  TOP w0.086: v1(39.44,58.91) 39.44,59.57 39.13,59.88 RT336.1 38.73,59.47 37.74,59.47 RT128.1 36.95,60.26 v3(36.77,60.26)
  GND1 w0.086: v4(36.29,60.39) 36.42,60.26 v3(36.77,60.26)
  GND5 w0.086: v5(36.77,60.25) 36.43,60.25 v4(36.29,60.39)
  BOTTOM w0.086: UT1.Y8 36.93,60.41 v5(36.77,60.25)
DPSNK_RBIAS: length 1.1
  TOP w0.086: RT38.1 36.58,55.66 v2(36.6,55.68)
  BOTTOM w0.102: v2(36.6,55.68) UT1.Y18
EC_FPM_EN: length 100.3
  TOP w0.086: UE1.D6 v2(263.02,62.58)
  IN2 w0.061: v4(202.2,36.38) 202.38,36.38 202.63,36.64 216.15,36.64 218.46,34.32 226.24,34.32 227.49,33.06 230.53,33.06 231.59,32 236.29,32 237.61,30.68 251.32,30.68 255.47,34.83 255.47,38.35 257.39,40.27 257.39,40.81 259.97,43.39 259.97,46.16 260.62,46.8 260.62,47.36 262.68,49.43 263.27,49.43 265.7,51.85 265.7,51.98 266.5,52.77 267.36,52.77 268.03,53.44 268.03,53.62 268.41,54.01 268.41,55.43 268.98,55.99 268.98,56.37 268.7,56.65 268.42,56.65 268.14,56.93 268.14,59.11 266.98,60.27 264.89,60.27 264.22,60.95 264.22,62 264.03,62.19 263.41,62.19 v2(263.02,62.58)
  GND5 w0.086: v4(202.2,36.38) 201.95,36.13 v5(201.79,36.13)
  BOTTOM w0.086: JUSH1.5 199.75,35.53 200.72,36.5 v1(201.58,36.5) 201.79,36.28 v5(201.79,36.13)
EDP_AUXN: length 117.3
  IN4 w0.062: v4(215.9,36.22) 215.69,36 215.69,35.84 215.53,35.68 206.26,35.68 204.46,37.47 204.46,37.78 200.8,41.44 188.27,41.44 182.51,47.21 182.15,47.21 178.61,50.75 178.61,56.07 177.32,57.37 177.32,58.52 175.99,59.85 175.99,61.33 174.62,62.71 174.62,63.52 173.13,65.02 173.13,67.39 168.19,72.32 166.26,72.32 164.26,74.32 163.24,74.32 160.98,76.59 160.98,76.71 160.98,78.47 159.43,80.02 151.55,80.02 151.32,80.26 143.52,80.26 142.04,81.73 140.44,81.73 139.32,80.61 131.01,80.61 129.76,79.36 129.76,78.64 129.82,78.58 130.02,78.58 130.16,78.72 v2(130.16,78.83)
  GND5 w0.076: v4(215.9,36.22) 215.67,35.98 215.67,35.69 215.76,35.6 216.11,35.6 v5(216.12,35.6)
  BOTTOM w0.076: UC1.E45 v2(130.16,78.83)
EDP_AUXN_C: length 3.7
  BOTTOM w0.088: JEDP1.29 214.25,37.86 214.09,37.7 214.09,37.53 214.24,37.37 215.5,37.37 215.71,37.16 215.71,36.92 CV1.2
EDP_AUXP: length 117.4
  IN4 w0.062: v2(130.16,78.19) 129.92,78.44 129.76,78.44 129.62,78.58 129.62,79.42 130.95,80.76 139.26,80.76 140.38,81.88 142.1,81.88 143.58,80.4 151.38,80.4 151.61,80.16 159.49,80.16 161.12,78.53 161.12,76.65 163.3,74.47 164.32,74.47 166.32,72.47 168.25,72.47 173.27,67.45 173.27,65.08 174.77,63.58 174.77,62.77 176.14,61.4 176.14,59.91 177.46,58.58 177.46,57.43 178.76,56.13 178.76,50.81 182.21,47.35 182.57,47.35 188.33,41.59 200.86,41.59 204.61,37.84 204.61,37.53 206.32,35.82 215.47,35.82 215.54,35.9 215.54,36 v4(215.32,36.22)
  GND5 w0.076: v5(215.1,35.6) 215.11,35.6 215.41,35.6 215.5,35.69 215.5,36.03 v4(215.32,36.22)
  BOTTOM w0.076: UC1.F45 130.61,77.95 v2(130.16,78.19)
EDP_AUXP_C: length 3.7
  BOTTOM w0.088: JEDP1.30 213.75,37.9 213.92,37.73 213.92,37.46 213.91,37.45 213.93,37.43 213.93,37.43 214.17,37.19 215.42,37.19 215.54,37.08 215.54,36.95 CV2.2
EDP_BIA_PWM: length 107.1
  IN2 w0.061: v4(149.9,72.91) 150.28,73.29 154.92,73.29 156.06,72.16 156.06,71.86 157.21,70.71 158.95,70.71 161.02,68.63 161.02,68.4 161.51,67.9 162.17,67.9 163.74,66.33 163.74,60.66 163.92,60.47 163.92,56.61 166.06,54.47 170.36,54.47 173.83,50.99 173.83,50.33 175.27,48.89 175.27,45.2 178.88,41.59 186.37,41.59 186.71,41.25 188.35,41.25 189.29,40.31 191.16,40.31 191.89,41.04 210.02,41.04 211.79,39.27 220.03,39.27 220.93,38.36 221.39,38.36 v4(221.59,38.57)
  GND5 w0.086: v5(150.15,73.34) 149.95,73.14 149.95,72.96 v4(149.9,72.91) ; v5(221.56,37.58) 221.56,38.53 v4(221.59,38.57)
  BOTTOM w0.086: v5(221.56,37.58) 221.78,37.35 221.78,34.76 220.95,33.92 220.95,31.95 DV1.3 219.03,29.51 219.44,29.1 v1(219.69,29.1)
EDP_COMP: length 1.4
  TOP w0.356: v2(126.46,78.24) 126.33,78.37 RC2.1
  BOTTOM w0.254: v2(126.46,78.24) 126.54,78.24 126.9,78.6 UC1.E52
EDP_HPD: length 95.8
  TOP w0.086: v2(218.79,40.04) v6(219.39,40.04)
  GND1 w0.086: v4(150.51,74.91) 150.16,75.27 v3(150.03,75.27)
  IN2 w0.061: v4(150.51,74.91) 151.07,74.36 154.49,74.36 156.5,72.34 156.5,72.13 156.91,71.73 158.72,71.73 159.31,71.13 159.31,70.87 161.48,68.71 161.48,68.51 161.7,68.28 162.32,68.28 164.12,66.49 164.12,63.71 166.63,61.19 168.89,61.19 170.74,59.35 170.74,55.29 177.76,48.27 177.76,46.06 180.17,43.65 185.11,43.65 186.94,41.82 188.58,41.82 189.52,40.88 190.93,40.88 191.66,41.6 210.25,41.6 212.02,39.83 216.64,39.83 217.3,40.5 218.33,40.5 v2(218.79,40.04)
  GND5 w0.086: v4(150.51,74.91) 150.8,75.2 v5(150.8,75.35)
  BOTTOM w0.086: RV7.1 219.05,36.45 218.67,36.83 218.67,37.28 218.25,37.7 JEDP1.21 218.25,39.48 218.69,39.91 218.69,39.98 218.75,40.04 v2(218.79,40.04)
EDP_TXN0: length 121.3
  IN4 w0.062: v2(128.67,83.76) 128.99,84.08 129.24,84.08 129.63,84.47 131.25,84.47 131.35,84.37 143.36,84.37 143.57,84.58 146.22,84.58 146.73,84.07 160.38,84.07 164.11,80.34 164.11,78.59 166.18,76.52 170.22,76.52 175.48,71.26 175.48,65.72 177.17,64.02 177.17,63.48 178.1,62.56 178.1,60.71 179.43,59.38 179.43,58.29 180.81,56.91 180.81,53.56 184.45,49.92 184.45,49.62 183.95,49.12 183.95,48.71 188.17,44.49 206.16,44.49 213.58,37.07 213.58,36.62 213.51,36.55 213.37,36.55 213.29,36.47 v4(213.29,36.22)
  GND5 w0.076: v4(213.29,36.22) 213.49,36.02 213.49,35.7 213.39,35.6 v5(213.07,35.6)
  BOTTOM w0.076: v2(128.67,83.76) arc(128.76,83.84) 128.87,83.87 128.93,83.87 arc(128.98,83.86) 129.03,83.84 arc(129.31,83.58) 129.48,83.24 arc(129.54,82.86) 129.53,82.47 129.47,82.07 arc(129.46,81.72) 129.49,81.37 arc(129.51,81.11) 129.48,80.85 arc(129.45,80.72) 129.45,80.58 arc(129.39,80.27) UC1.C47
EDP_TXN0_C: length 2.5
  BOTTOM w0.088: JEDP1.32 212.75,38 212.91,37.84 212.91,37.58 213.48,37.01 213.48,36.87 213.13,36.52 CV4.2
EDP_TXN1: length 114.7
  IN4 w0.062: v4(211.26,36.22) 211.24,36.23 211.24,36.54 211.3,36.6 211.63,36.6 211.7,36.67 211.7,36.88 204.62,43.96 187.97,43.96 183.34,48.59 183.34,49.12 180.28,52.17 180.28,56.62 178.89,58.01 178.89,59.18 177.56,60.51 177.56,61.96 176.24,63.28 176.24,64.17 174.73,65.69 174.73,68.81 168.95,74.59 168.64,74.59 168.64,74.59 167.35,74.59 163.59,78.34 163.59,79.23 159.73,83.09 146.98,83.09 146,84.07 144.28,84.07 144.06,83.86 131.69,83.86 131.53,83.7 131.53,83.6 131.8,83.33 v2(131.83,83.33)
  GND5 w0.076: v4(211.26,36.22) 211.45,36.02 211.45,35.71 211.34,35.6 211.05,35.6 v5(211.04,35.6)
  BOTTOM w0.076: v2(131.83,83.33) 131.8,83.32 arc(131.72,83.25) 131.67,83.16 131.65,83.02 arc(131.65,82.98) 131.65,82.94 arc(131.63,82.85) 131.58,82.77 arc(131.54,82.73) 131.5,82.7 arc(131.36,82.61) 131.22,82.53 arc(131.07,82.46) 130.95,82.36 130.88,82.28 arc(130.78,82.16) 130.72,82.02 arc(130.7,81.9) 130.71,81.78 arc(130.73,81.54) 130.73,81.29 arc(130.73,81.22) 130.71,81.15 arc(130.7,81.03) 130.71,80.9 arc(130.72,80.88) 130.72,80.87 arc(130.75,80.67) 130.71,80.48 arc(130.7,80.45) 130.69,80.41 130.67,80.25 arc(130.65,80.16) 130.65,80.07 arc(130.62,79.97) 130.58,79.88 arc(130.44,79.75) 130.26,79.7 UC1.D46
EDP_TXN1_C: length 2.5
  BOTTOM w0.088: CV6.2 211.07,36.52 211.48,36.92 211.48,37.1 211.91,37.54 211.91,37.84 211.75,38.01 JEDP1.34
EDP_TXN2: length 115.5
  IN4 w0.062: v4(209.22,36.22) 209.4,36.4 209.4,36.75 208.05,38.1 208.05,39.57 205.06,42.56 195.05,42.56 194.19,43.43 187.77,43.43 182.8,48.39 182.8,48.9 179.73,51.97 179.73,56.44 178.36,57.81 178.36,58.98 177.04,60.3 177.04,61.73 175.64,63.13 175.64,63.95 174.21,65.38 174.21,68.6 168.74,74.08 167.09,74.08 163.08,78.09 163.08,78.96 160.21,81.83 155.58,81.83 154.87,82.54 148.01,82.54 147.81,82.34 144.27,82.34 143.36,83.25 132.86,83.25 132.26,82.64 129.65,82.64 129.29,83.01 129.29,83.58 129.73,84.02 130.51,84.02 130.63,83.9 v2(130.63,83.33)
  GND5 w0.076: v4(209.22,36.22) 209.41,36.03 209.41,35.71 209.31,35.6 v5(209.01,35.6)
  BOTTOM w0.076: v2(130.63,83.33) arc(130.57,83.1) 130.34,83.04 arc(130.26,83.03) 130.21,82.97 arc(130.18,82.8) 130.18,82.64 130.24,81.95 arc(130.22,81.74) 130.12,81.56 arc(130.04,81.38) 130.02,81.18 arc(130.06,81.12) 130.13,81.09 arc(130.28,81.16) UC1.A45
EDP_TXN2_C: length 3.7
  BOTTOM w0.088: JEDP1.36 210.75,37.99 210.91,37.83 210.91,37.49 210.59,37.17 209.63,37.17 209.44,36.98 209.44,36.61 209.35,36.52 CV8.2
EDP_TXN3: length 114.6
  IN4 w0.062: v4(207.19,36.22) 207.38,36.4 207.38,39.51 204.91,41.98 194.9,41.98 194.01,42.87 187.59,42.87 182.72,47.74 182.36,47.74 179.21,50.88 179.21,56.19 177.84,57.57 177.84,58.73 176.53,60.05 176.53,61.52 175.13,62.92 175.13,63.74 173.7,65.17 173.7,68.39 168.52,73.57 166.79,73.57 159.73,80.63 151.68,80.63 151.54,80.77 145.11,80.77 143.15,82.74 137.94,82.74 136.38,81.17 128.48,81.17 127.94,81.71 127.94,82.9 128.09,83.05 128.55,83.05 v2(128.67,83.18)
  GND5 w0.076: v4(207.19,36.22) 207.37,36.03 207.37,35.69 207.28,35.6 206.98,35.6 v5(206.98,35.6)
  BOTTOM w0.076: UC1.A47 129.2,81.26 arc(129.19,81.15) 129.1,81.08 arc(128.99,81.1) 128.92,81.18 arc(128.91,81.39) 129,81.57 arc(129.17,81.85) 129.24,82.16 129.26,82.49 arc(129.18,82.78) 128.94,82.94 arc(128.78,83.03) v2(128.67,83.18)
EDP_TXN3_C: length 4.6
  BOTTOM w0.088: CV10.2 207.29,36.52 207.41,36.64 207.41,37.03 208,37.63 209.83,37.63 209.91,37.71 209.91,37.84 209.75,38 JEDP1.38
EDP_TXP0: length 121.3
  IN4 w0.062: v4(213.87,36.22) 213.72,36.37 213.72,36.56 213.72,36.56 213.72,37.13 206.22,44.64 188.23,44.64 184.1,48.77 184.1,49.06 184.59,49.56 184.59,49.98 180.95,53.62 180.95,56.97 179.57,58.35 179.57,59.44 178.24,60.77 178.24,62.62 177.32,63.54 177.32,64.08 175.63,65.78 175.63,71.32 170.28,76.67 166.24,76.67 164.25,78.65 164.25,80.4 160.44,84.22 146.79,84.22 146.28,84.73 143.51,84.73 143.3,84.51 131.41,84.51 131.31,84.62 129.57,84.62 129.18,84.22 128.79,84.22 v2(128.67,84.34)
  GND5 w0.076: v5(214.09,35.6) 213.78,35.6 213.65,35.72 213.65,36 v4(213.87,36.22)
  BOTTOM w0.076: UC1.C46 129.65,80.41 arc(129.63,80.44) 129.62,80.47 129.62,80.58 arc(129.62,80.7) 129.64,80.82 arc(129.68,81.11) 129.65,81.4 arc(129.62,81.72) 129.64,82.05 129.69,82.45 arc(129.7,82.87) 129.64,83.28 arc(129.42,83.72) 129.05,84.03 arc(129,84.05) 128.95,84.06 arc(128.77,84.16) v2(128.67,84.34)
EDP_TXP0_C: length 2.6
  BOTTOM w0.088: CV3.2 214.03,36.52 213.66,36.89 213.66,37.08 213.09,37.65 213.09,37.84 213.25,38.01 JEDP1.31
EDP_TXP1: length 114.7
  IN4 w0.062: v2(131.23,83.33) 131.38,83.48 131.38,83.76 131.63,84 144,84 144.22,84.21 146.06,84.21 147.04,83.24 159.79,83.24 163.74,79.29 163.74,78.4 167.41,74.74 168.58,74.74 169.01,74.74 174.87,68.87 174.87,65.75 176.39,64.23 176.39,63.34 177.71,62.02 177.71,60.57 179.04,59.24 179.04,58.08 180.43,56.68 180.43,52.23 183.48,49.18 183.48,48.65 188.03,44.1 204.68,44.1 211.84,36.94 v4(211.84,36.22)
  GND5 w0.076: v4(211.84,36.22) 211.62,36 211.62,35.72 211.75,35.6 212.05,35.6 v5(212.06,35.6)
  BOTTOM w0.076: v2(131.23,83.33) 131.26,83.31 arc(131.37,83.24) 131.44,83.13 131.49,83.05 131.48,83.02 131.49,83 arc(131.49,82.97) 131.49,82.94 arc(131.48,82.91) 131.47,82.89 131.47,82.89 arc(131.43,82.86) 131.39,82.83 arc(131.28,82.75) 131.15,82.69 arc(130.98,82.6) 130.83,82.47 130.76,82.4 arc(130.64,82.24) 130.56,82.06 arc(130.56,82.06) 130.56,82.05 arc(130.54,81.9) 130.55,81.75 arc(130.57,81.53) 130.57,81.3 arc(130.56,81.25) 130.55,81.19 arc(130.53,81.03) 130.55,80.86 arc(130.56,80.84) 130.56,80.81 arc(130.58,80.68) 130.56,80.54 130.53,80.47 arc(130.48,80.4) 130.4,80.36 130.4,80.35 arc(130.3,80.34) 130.19,80.33 130.17,80.34 arc(130.06,80.31) 130,80.23 129.99,80.2 arc(129.94,80.09) 129.92,79.97 arc(129.95,79.89) 130.02,79.86 130.19,79.86 arc(130.28,79.93) UC1.C45
EDP_TXP1_C: length 2.5
  BOTTOM w0.088: JEDP1.33 212.25,38 212.09,37.83 212.09,37.47 211.65,37.03 211.65,36.89 212.02,36.52 CV5.2
EDP_TXP2: length 115.5
  IN4 w0.062: v4(209.81,36.22) 209.81,36.48 209.75,36.54 209.61,36.54 209.55,36.61 209.55,36.81 208.2,38.16 208.2,39.63 205.12,42.71 195.11,42.71 194.25,43.57 187.83,43.57 182.95,48.45 182.95,48.96 179.87,52.03 179.87,56.5 178.5,57.87 178.5,59.04 177.19,60.36 177.19,61.79 175.79,63.19 175.79,64.01 174.36,65.44 174.36,68.66 168.8,74.22 167.15,74.22 163.23,78.15 163.23,79.02 160.27,81.97 155.64,81.97 154.93,82.69 147.95,82.69 147.75,82.48 144.33,82.48 143.42,83.39 132.8,83.39 132.2,82.79 129.71,82.79 129.43,83.07 129.43,83.52 129.79,83.88 130.45,83.88 130.49,83.84 130.49,83.73 130.38,83.63 130.09,83.63 130.03,83.56 v2(130.03,83.33)
  GND5 w0.076: v5(210.02,35.6) 210.02,35.6 209.7,35.6 209.58,35.71 209.58,35.99 v4(209.81,36.22)
  BOTTOM w0.076: UC1.B45 arc(130.28,80.85) 130.13,80.92 arc(129.95,80.99) 129.86,81.16 arc(129.88,81.42) 129.99,81.66 arc(130.06,81.79) 130.07,81.94 130.02,82.62 arc(130.02,82.82) 130.05,83.01 arc(130.07,83.17) v2(130.03,83.33)
EDP_TXP2_C: length 3.6
  BOTTOM w0.088: JEDP1.35 211.25,37.96 211.09,37.8 211.09,37.42 210.67,37 209.7,37 209.61,36.91 209.61,36.61 209.71,36.52 CV7.2
EDP_TXP3: length 114.6
  IN4 w0.062: v2(128.67,82.59) 128.47,82.59 128.39,82.67 128.39,82.84 128.33,82.9 128.15,82.9 128.09,82.84 128.09,81.77 128.54,81.32 136.32,81.32 137.88,82.88 143.21,82.88 145.17,80.92 151.6,80.92 151.74,80.77 159.79,80.77 166.85,73.71 168.58,73.71 173.85,68.45 173.85,65.23 175.28,63.8 175.28,62.98 176.67,61.58 176.67,60.11 177.99,58.79 177.99,57.63 179.36,56.25 179.36,50.94 182.42,47.88 182.78,47.88 187.65,43.01 194.07,43.01 194.96,42.12 204.97,42.12 207.52,39.57 207.52,36.45 207.75,36.22 v4(207.78,36.22)
  GND5 w0.076: v4(207.78,36.22) 207.54,35.98 207.54,35.7 207.64,35.6 v5(207.99,35.6)
  BOTTOM w0.076: UC1.B47 129.18,80.79 arc(129.15,80.87) 129.08,80.91 128.97,80.93 arc(128.84,81.01) 128.76,81.14 arc(128.75,81.42) 128.87,81.68 arc(129.01,81.91) 129.07,82.17 129.1,82.5 arc(129.05,82.68) 128.9,82.78 arc(128.73,82.75) v2(128.67,82.59)
EDP_TXP3_C: length 4.5
  BOTTOM w0.088: JEDP1.37 210.25,37.98 210.09,37.81 210.09,37.64 209.9,37.45 208.07,37.45 207.58,36.96 207.58,36.64 207.7,36.52 CV9.2
EDRAM_OPIO_RCOMP: length 1.3
  TOP w0.381: v2(117.96,76.9) 117.86,76.8 RC90.1
  BOTTOM w0.086: UC1.H66 118.15,76.71 v2(117.96,76.9)
EMMC_RCOMP: length 3.2
  TOP w0.102: v2(156.86,62.57) 157.7,62.57 v1(157.78,62.65)
  TOP w0.381: RC4.1 157.31,63.01 v2(156.86,62.57)
  BOTTOM w0.203: v2(156.86,62.57) UC1.AT1
EN_1.0V_PRIM_COREP: length 3.3
  BOTTOM w0.086: PR407.1 167.81,34.45 PR406.2 PC411.1 167.67,33.4 PU402.13
EN_1.8V: length 4.2
  TOP w0.086: v1(81.11,57.73) PR513.2 PR514.1 80.22,56.75 PC513.1 80.22,55.51 80.6,55.12 PU503.5
EN_1.8VALW: length 9.1
  TOP w0.086: PR504.2 209.47,31.5 PC505.1 ; PC505.1 210.37,32.75 210.48,32.86 212.18,32.86 v1(212.32,32.72) ; PC505.1 210.39,32.37 PR505.1 210.15,31.2 210.15,29.42 211.24,28.33 PU501.1
EN_1VS_VCCIO: length 9.2
  TOP w0.086: PR402.2 170.06,26.31 PC402.1 170.65,26.07 171.04,25.69 172.98,25.69 PR403.1 173.78,26.49 v3(174.16,26.49) 174.22,26.49 174.5,26.21 v1(174.5,26.11)
  GND1 w0.086: v4(176.31,26.35) 176.31,26.72 v3(176.56,26.97) ; v4(174.4,26.03) 174.16,26.27 v3(174.16,26.49)
  IN2 w0.061: v4(174.4,26.03) 174.81,26.44 176.21,26.44 v4(176.31,26.35)
EN_+1VALWP: length 4.6
  BOTTOM w0.086: v1(63.67,77.24) 63.82,77.09 64,77.09 64.51,76.58 PR312.2
  BOTTOM w0.203: PU301.11 64.32,73.38 64.43,73.49 64.43,75.32 PR302.1 PR312.2
EN_INVPWR: length 64.7
  TOP w0.086: v3(254.76,66.98) 254.92,66.81 254.92,66.64 RE55.1 255.4,66.17 256,66.17 257.02,65.14 258.2,65.14 259.1,64.25 259.68,64.25 260.12,63.81 UE1.B2
  GND1 w0.117: v4(255,67.53) 255,67.22 v3(254.76,66.98)
  IN4 w0.062: v2(229.28,32.29) 229.3,32.32 229.3,32.37 232.38,35.44 234.82,35.44 235.63,36.25 239.51,36.25 240.97,37.72 240.97,38.6 241.9,39.53 241.9,43.23 241.56,43.57 241.56,58.3 246.09,62.83 247.75,62.83 248.05,63.13 248.94,63.13 249.29,62.77 251.6,62.77 252.44,63.61 252.44,65.77 252.92,66.24 254.12,66.24 255,67.13 v4(255,67.53)
  BOTTOM w0.086: v1(231.13,30.57) 230.9,30.57 230.13,31.34 QV2.2 229.39,31.34 229.3,31.43 229.3,32.27 v2(229.28,32.29)
EN_LCDPWR: length 4.9
  TOP w0.086: v2(234.76,28.48) 235.12,28.13 DV3.1 v1(234.1,26.5) 233.85,26.25 RV3.2
  BOTTOM w0.086: UV24.4 234.59,28.66 v2(234.76,28.48)
EN_PD_HV_1: length 108.6
  TOP w0.086: v1(37.6,37.77) 36.98,38.39 PR1254.1 36.98,39.4 36.52,39.86 36.52,40.34 v3(36.04,40.81) ; PR1232.2 38.64,85.26 39.01,84.9 v2(39.49,84.9) 40.38,84.9 41.04,84.24 41.04,83.38 41.24,83.18 PQ1224.5 41.69,83.19 42.54,83.19 PR1285.2
  GND1 w0.086: v4(35.56,40.63) 35.86,40.63 v3(36.04,40.81) ; v4(64.27,85.94) 64.27,85.6 v3(64.46,85.41)
  IN1 w0.051: v2(39.49,84.9) 38.8,84.21 38.8,81.46 38.38,81.04 36.94,81.04 35.86,79.96 35.86,77.94 36.31,77.48 36.31,70.62 35.12,69.43 34.23,69.43 v4(33.57,68.76)
  IN3 w0.061: v4(33.57,68.76) 33.29,69.05 32.68,69.05 32.28,68.64 32.28,67.32 33.19,66.4 33.19,64.22 34.87,62.54 34.87,61.93 35.49,61.31 35.49,60.58 36.25,59.82 36.85,59.82 37.37,59.29 37.37,55.22 37.22,55.07 37.22,51.21 37.37,51.06 37.37,49.62 36.73,48.97 36.39,48.97 35.32,47.91 35.32,45.98 35.64,45.66 35.64,42.51 36.11,42.05 36.11,41.17 v4(35.56,40.63)
  IN4 w0.051: v2(39.49,84.9) 39.49,85.15 38.35,86.29 38.35,86.75 38.65,87.05 40.95,87.05 42.56,88.65 47.7,88.65 48.49,87.86 54.02,87.86 55.82,86.06 58.87,86.06 59.56,85.38 63.72,85.38 64.27,85.93 v4(64.27,85.94) 64.29,85.94 64.77,86.42 71.82,86.42 v4(72.12,86.72)
  GND5 w0.086: v5(71.82,86.15) 72.12,86.45 v4(72.12,86.72) ; v5(33.84,68.32) 33.57,68.59 v4(33.57,68.76)
  BOTTOM w0.086: PR1293.1 69.33,83.96 70.21,84.83 70.21,85.31 70.64,85.74 71.41,85.74 v5(71.82,86.15)
EN_PD_HV_1#: length 1.6
  TOP w0.086: PR1278.2 38.85,83.18 PQ1224.2 PQ1224.3
EN_PD_HV_1_R: length 2.5
  BOTTOM w0.076: UT5.C2 33.47,71.28 33.47,70.32
  BOTTOM w0.086: 33.47,70.32 33.84,69.94 RT70.1
EN_PD_HV_2: length 166.6
  TOP w0.086: PQ1226.5 46.44,33.11 46.03,33.52 44.65,33.52 44.65,33.51 v3(44.59,33.51) ; v2(78.12,86.78) 78.12,91.1 v2(78,91.22) ; PR1217.1 47.87,90.74 47.46,90.33 v3(47.41,90.33) ; v3(43.35,33.46) 43.1,33.46 42.89,33.26 PR1245.1 42.05,32.95 PR1286.2
  TOP w0.102: PR1286.2 42.03,33.69 42.31,33.97 v1(42.31,34.34)
  GND1 w0.086: v3(47.41,90.33) 46.87,89.79 46.69,89.79 46.69,89.77 v4(46.72,89.77) ; v3(44.59,33.51) 44.58,33.49 44.27,33.49 44.24,33.46 v4(43.91,33.46) v3(43.35,33.46)
  IN2 w0.061: v4(30.52,83.12) 27.55,83.12 21.91,77.47 21.11,77.47 20.17,76.53 20.17,74.56 20.17,74.56 20.17,72.57 17.1,69.5 17.1,64.52 17.47,64.15 17.47,58.07 17.1,57.7 17.1,55.48 16.69,55.07 16.69,50.38 15.99,49.69 15.99,47.31 17.25,46.06 17.25,40.3 v2(17.96,39.58)
  IN3 w0.061: v4(30.52,83.12) 30.52,83.5 34.84,87.82 34.84,89.79 36.52,91.47 44.24,91.47 46.07,89.65 46.6,89.65 v4(46.72,89.77) 46.86,89.63 46.86,88.76 48.77,86.84 50.27,86.84 51.99,85.13 56.19,85.13 57.34,86.27 57.34,86.57 59.23,88.46 59.23,91.16 60.2,92.13 65.8,92.13 66.05,92.39 72.92,92.39 73.38,91.92 77.29,91.92 v2(78,91.22) ; v4(43.91,33.46) 43.64,33.2 36.5,33.2 33.94,30.63 32.34,30.63 29.66,33.31 27.76,33.31 25.41,35.66 20.1,35.66 19.52,36.23 19.52,38.77 18.71,39.58 v2(17.96,39.58)
  GND5 w0.086: v5(44.9,33.56) 44.8,33.46 v4(43.91,33.46)
  BOTTOM w0.086: PR1294.1 77.39,86.1 78.06,86.78 v2(78.12,86.78) ; v5(44.9,33.56) 44.9,33.05 44.44,32.6 PR1269.2 ; RT166.2 20.52,42.1 20.52,41.69 18.41,39.58 v2(17.96,39.58)
EN_PD_HV_2#: length 3.1
  TOP w0.086: PR1281.2 48.56,33.85 PQ1226.3 PQ1226.2
  TOP w0.102: PR1281.2 48.56,36.03 v1(48.47,36.11)
EN_PD_HV_2_R: length 5.4
  BOTTOM w0.076: UT11.C2 26.47,42.88 26.33,42.88 26.33,42.88 26.13,42.88 26.13,42.88 25.53,42.88
  BOTTOM w0.086: RT166.1 22.32,42.99 v1(22.81,42.99) 22.92,43.09 23.45,43.09 23.79,42.76 25.4,42.76 25.53,42.88
ENLDO_3V5V: length 54.3
  IN2 w0.061: v2(76.73,45.09) 75.75,45.09 74.48,46.36 74.48,56.05 71.97,58.56 71.97,60.78 70.62,62.13 68.5,62.13 65.9,64.73 65.9,66.23 63.62,68.5 63.62,73.97 64.18,74.54 64.18,75.52 62.91,76.79 59.32,76.79 57.07,74.54 57.07,73.78 56.53,73.24 v2(54.86,73.24)
  BOTTOM w0.086: PU102.11 54.03,71.98 54.65,72.6 PR103.1 PR102.1 55.21,73.24 v2(54.86,73.24)
  BOTTOM w0.117: v2(76.73,45.09) 76.69,45.05 PU100.11
ENVDD_PCH: length 117.9
  TOP w0.086: v1(233.13,29.42) DV3.3 234.63,29.42 235.04,29.83 v3(235.09,29.83)
  GND1 w0.086: v4(234.76,30.31) 234.76,30.16 v3(235.09,29.83)
  IN2 w0.061: v4(234.76,30.31) 234.31,29.85 229.16,29.85 228.75,30.27 226.9,30.27 224.58,32.58 217.03,32.58 216.05,33.56 200.72,33.56 200.23,33.08 195.48,33.08 194.76,33.79 181.95,33.79 181.55,34.2 177.57,34.2 174.77,36.99 172.32,36.99 168.76,40.55 168.76,42.01 168.34,42.43 167.15,42.43 165.9,43.67 165.87,43.67 161.36,48.18 161.36,48.6 158.69,51.27 158.69,52.84 150.46,61.07 150.46,62.54 149.8,63.2 149.8,64.95 148.65,66.1 148.65,68.11 148.99,68.46 148.99,69.3 148.81,69.49 148.81,69.91 149.06,70.16 150.66,70.16 150.92,70.42 150.92,70.88 150.34,71.46 149.57,71.46 v4(149.16,71.87)
  GND5 w0.086: v5(148.85,72.28) 148.85,72.12 149.11,71.87 v4(149.16,71.87)
EOPIO_RCOMP: length 2.7
  TOP w0.381: v3(118.53,75.92) RC91.1
  GND1 w0.381: v4(119.12,75.95) 119.08,75.91 118.54,75.91 v3(118.53,75.92)
  GND5 w0.381: v4(119.12,75.95) 119.49,76.32 v5(119.49,76.71)
ESPI_ALERT#: length 164.8
  TOP w0.086: UE1.H7 v2(263.82,58.64)
  IN2 w0.061: v2(263.82,58.64) 263.41,59.04 262.76,59.04 262.58,58.86 262.58,57.67 262.37,57.46 259.33,57.46 258.97,57.82 258.64,57.82 257.4,56.57 v4(257.4,56.45)
  IN4 w0.051: v4(162.3,51.47) 162.83,51.47 163.16,51.14 163.16,46.62 165.88,43.9 166.9,43.9 168.52,42.29 168.52,40.19 172.18,36.53 172.18,35.34 172.96,34.55 176.06,34.55 178.79,31.82 179.96,31.82 180.42,31.35 192.28,31.35 192.89,30.74 194.56,30.74 194.81,31 195.56,31 195.89,30.67 205.26,30.67 205.99,29.94 209.64,29.94 211.01,31.3 218.75,31.3 219.14,31.69 225.17,31.69 225.93,30.94 231.4,30.94 231.87,31.4 236.11,31.4 237.4,30.1 251.19,30.1 254.21,33.12 254.21,38.82 253.64,39.39 253.64,41.31 252.83,42.12 252.83,47.11 251.86,48.08 251.86,53.14 252.26,53.54 253.27,53.54 254.78,55.05 256,55.05 v4(257.4,56.45)
  GND5 w0.086: v5(161.71,51.42) 161.76,51.42 161.79,51.39 162.22,51.39 v4(162.3,51.47)
  BOTTOM w0.076: UC1.AY11 149.9,59.9 149.69,59.54 149.58,59.43 149.58,57.74 150.72,56.6 151,56.6
  BOTTOM w0.086: 151,56.6 153.17,54.43 v1(153.94,54.43) 158.42,54.43 160.32,52.54 161.68,52.54 RC21.1 161.84,51.42 v5(161.71,51.42)
ESPI_CLK: length 14.9
  BOTTOM w0.076: UC1.AW9 151.04,60.3 150.84,59.67 150.84,59.59 150.79,59.43 150.79,59.29 150.85,59.07 150.85,58.55 153.99,55.41
  BOTTOM w0.086: RC16.1 160.88,54.52 v1(160.1,55.29) 159.98,55.41 153.99,55.41
ESPI_CLK_5105: length 158.7
  TOP w0.086: v2(166.9,51.75) 166.8,51.75 v1(165.68,50.63) 165.54,50.49 165.54,48.8 163.01,46.26 163.01,43.49 163.92,42.58 163.92,39.25 162.15,37.47 v3(162.15,37.4) ; UE1.G7 v2(263.82,59.44) ; v2(197.81,32.09) 197.3,31.58 197.1,31.58 196.98,31.46 JESPI.10
  GND1 w0.086: v4(161.82,37.83) 162.07,37.58 162.07,37.47 v3(162.15,37.4) ; v4(253.66,57.9) 253.53,57.77 v3(253.53,57.29)
  IN1 w0.051: v4(253.66,57.9) 252.47,56.71 252.47,56.22 252.01,55.76 252.01,48.5 251.97,48.46 251.97,44.78 252.16,44.59 252.16,44.3 252.26,44.21 252.26,39.59 251.88,39.21 251.88,37.92 252.26,37.54 252.26,36.33 250.22,34.3 247.57,34.3 247.35,34.08 239.03,34.08 238.54,34.58 236.06,34.58 235.19,35.45 231.34,35.45 229.63,33.74 227.28,33.74 226.44,34.58 224.98,34.58 223.48,33.07 218.94,33.07 218.49,32.62 198.34,32.62 v2(197.81,32.09) 197.35,32.55 192.4,32.55 192.04,32.19 183.79,32.19 181.56,34.43 176.17,34.43 175.9,34.69 172.98,34.69 170.91,36.76 170.58,36.76 170.53,36.8 170.46,36.8 170.13,37.13 164.81,37.13 164.11,37.83 v4(161.82,37.83)
  IN4 w0.051: v4(253.66,57.9) 254.37,58.61 256.89,58.61 257.75,59.47 259.14,59.47 259.83,60.16 262.83,60.16 262.99,60 263.51,60 263.82,59.69 v2(263.82,59.44)
  BOTTOM w0.086: RC16.2 CC316.1 162.88,53.46 164.83,53.46 165.41,54.04 166.22,54.04 166.9,53.37 v2(166.9,51.75)
ESPI_CS#: length 174
  TOP w0.086: v3(198.11,37.74) 198.11,37.73 198.11,36.14 199.13,35.11 199.13,34.53 199.26,34.41 199.26,33.99 199.13,33.87 198.8,33.87 198.54,34.12 195.72,34.12 v1(195.67,34.06) 195.48,33.88 JESPI.7 ; UE1.H6 v2(263.02,58.64)
  GND1 w0.086: v4(198.8,38.41) 198.75,38.41 198.11,37.78 v3(198.11,37.74)
  IN2 w0.061: v4(158.09,54.87) 158.09,54.82 159.93,52.98 159.93,52.07 162.94,49.06 162.94,48.83 167.46,44.31 168.43,44.31 168.96,43.77 168.96,43.34 169.46,42.84 169.89,42.84 173.64,39.1 173.64,38.49 174.2,37.92 175.8,37.92 176.63,37.09 185.13,37.09 185.74,36.48 186.45,36.48 186.96,36.99 187.42,36.99 187.48,36.93 187.48,36.28 187.6,36.15 187.89,36.15 188.01,36.28 188.01,36.9 188.08,36.97 188.54,36.97 188.62,36.88 188.62,36.28 188.71,36.18 189.13,36.18 189.22,36.28 189.22,36.87 189.33,36.98 189.67,36.98 189.78,36.86 189.78,36.46 189.86,36.38 190.24,36.38 190.31,36.46 190.31,36.85 190.44,36.98 191.92,36.98 192.14,37.19 194.28,37.19 194.98,36.49 196.58,36.49 197.91,37.83 198.33,37.83 198.8,38.3 v4(198.8,38.41) 198.8,38.78 199.05,39.04 202.96,39.04 203.28,38.71 203.37,38.71 203.68,39.02 203.78,39.02 204.09,38.71 204.09,38.63 203.77,38.31 203.77,38.22 204.24,37.76 204.41,37.76 204.56,37.92 204.56,38.13 204.64,38.21 204.79,38.21 205.24,37.76 217.45,37.76 218.83,36.39 230.25,36.39 230.31,36.33 230.31,35.1 230.37,35.04 230.82,35.04 230.88,35.1 230.88,36.33 230.94,36.39 231.38,36.39 231.45,36.33 231.45,35.48 231.99,34.93 239.03,34.93 241.02,32.94 247.02,32.94 247.08,33 247.41,33 247.63,33.22 250.52,33.22 251.17,33.87 251.77,33.87 253.89,35.99 253.89,41.36 256.08,43.55 256.08,45.65 258,47.57 258,49.43 258.43,49.86 259.7,49.86 260.44,50.61 260.44,52.21 260.63,52.4 261.36,52.4 263.07,54.11 264.02,54.11 264.38,54.47 264.38,57.97 264.08,58.28 263.38,58.28 v2(263.02,58.64)
  GND5 w0.086: v5(157.8,54.03) 157.8,54.44 158.08,54.72 158.08,54.86 v4(158.09,54.87)
  BOTTOM w0.076: 150.94,56.35 150.74,56.35 149.41,57.67 149.41,59.64 UC1.BA12
  BOTTOM w0.086: v5(157.8,54.03) 157.72,54.11 153.17,54.11 150.94,56.35
ESPI_IO0: length 151
  TOP w0.086: v1(192.78,32.46) 193.08,32.16 v2(193.39,32.16) 193.48,32.06 JESPI.3 ; UE1.K5 v2(262.22,57.04)
  IN4 w0.051: v4(160.21,50.71) 161.38,51.88 162.65,51.88 163.42,51.11 163.42,49.84 165,48.26 165.32,48.26 165.6,47.98 165.6,47.23 168.86,43.97 168.86,40.33 172.33,36.86 172.33,35.4 173.03,34.71 176.12,34.71 178.86,31.97 180.02,31.97 180.48,31.51 192.39,31.51 192.93,32.05 193.28,32.05 v2(193.39,32.16) 194.19,31.35 195.64,31.35 196.02,30.97 205.38,30.97 206.11,30.24 209.52,30.24 210.88,31.61 218.63,31.61 219.02,32 225.3,32 226.02,31.28 230.19,31.28 230.65,31.74 236.25,31.74 237.58,30.41 251.06,30.41 253.87,33.21 253.87,38.68 253.3,39.25 253.3,41.17 252.49,41.98 252.49,45.09 251.52,46.06 251.52,53.29 252.12,53.89 253.14,53.89 255.11,55.86 256.21,55.86 259.36,59.01 261.64,59.01 261.82,58.84 261.82,57.44 v2(262.22,57.04)
  GND5 w0.086: v4(160.21,50.71) 159.58,50.71 v5(159.53,50.66)
  BOTTOM w0.086: v5(159.53,50.66) 159.17,50.3 RC366.2
ESPI_IO0_R: length 15.2
  BOTTOM w0.076: 150.92,54.98 v1(149.23,56.67) 148.67,57.23 148.67,58.4 148.55,58.53 148.55,58.8 148.6,58.92 148.6,59.06 148.54,59.29 148.54,59.41 148.61,59.62 148.71,59.73 148.81,59.84 UC1.AY13
  BOTTOM w0.086: RC366.1 156.91,52.71 153.19,52.71 150.92,54.98
