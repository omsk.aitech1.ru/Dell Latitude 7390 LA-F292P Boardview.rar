# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PANEL_BKEN_EC: length 79.3
  TOP w0.086: UE1.J9 v2(266.16,57.84)
  IN1 w0.051: v4(258.28,38.67) 258.61,38.99 258.61,40.82 260.55,42.77 260.55,44.64 261.19,45.27 261.19,45.43 262.34,46.59 262.34,46.88 262.93,47.47 263.23,47.47 263.9,48.14 263.9,49.67 264.76,50.53 264.76,52.41 265.3,52.94 265.3,53.73 264.75,54.28 264.75,56.38 265.02,56.65 266.34,56.65 266.57,56.88 266.57,57.44 266.17,57.84 v2(266.16,57.84)
  IN4 w0.051: v4(231.61,27.19) 232.26,26.54 242.18,26.54 242.76,27.13 254.51,27.13 255.01,27.64 256.08,27.64 257.46,29.02 257.46,33.91 258.63,35.09 258.63,38.32 v4(258.28,38.67)
  GND5 w0.086: v4(231.61,27.19) 231.61,27.26 231.74,27.39 v5(231.74,27.67)
  BOTTOM w0.086: v5(231.74,27.67) 231.74,27.72 231.6,27.86 231.6,28.96 231.09,29.47 227.65,29.47 227.05,28.87 224.6,28.87 224.45,28.72 218.57,28.72 v1(218.34,28.96) 217.53,29.76 DV2.2
PANEL_BKLEN: length 107.3
  IN2 w0.061: v4(221.05,38.79) 220.39,39.46 211.87,39.46 210.09,41.23 191.81,41.23 191.08,40.5 189.37,40.5 188.43,41.44 186.78,41.44 186.45,41.78 178.96,41.78 175.46,45.28 175.46,49.06 174.08,50.44 174.08,51.01 170.4,54.69 166.15,54.69 164.15,56.7 164.15,60.56 163.93,60.78 163.93,66.41 162.24,68.09 161.59,68.09 161.21,68.48 161.21,68.71 159.02,70.9 157.33,70.9 156.28,71.95 156.28,72.25 155.01,73.52 149.9,73.52 v4(149.26,72.88)
  GND5 w0.086: v4(149.26,72.88) 149.5,73.12 v5(149.5,73.34) ; v4(221.05,38.79) 220.58,38.32 v5(220.58,37.63)
  BOTTOM w0.086: DV2.3 216.23,30.04 218.23,32.04 v1(218.23,32.41) 218.23,32.63 219.59,33.99 220.14,33.99 220.85,34.69 220.85,37.36 v5(220.58,37.63)
PANEL_SIZE_DET: length 109.4
  TOP w0.086: RC503.1 170.73,51.24 170.73,52.56 172.34,54.16 v3(172.46,54.16)
  GND1 w0.086: v4(172.91,54.49) 172.79,54.49 v3(172.46,54.16)
  IN3 w0.061: 172.94,54.49 v4(172.91,54.49) ; 172.94,54.49 172.94,54.47 175.88,51.53 176.16,51.53 177.95,49.73 177.95,46.97 181.25,43.68 184.83,43.68 187.36,41.15 190.56,41.15 190.98,40.74 214.66,40.74 v2(214.72,40.8) ; 172.94,54.49 172.94,54.52 172.89,54.52 171.17,56.23 171.17,59.35 169.13,61.39 163.83,61.39 161.65,59.21 156.69,59.21 154.22,61.68 152.77,61.68 152.57,61.88 152.57,63.56 152.42,63.71 152.01,63.71 151.8,63.93 151.8,64.08 151.48,64.4 151.07,64.4 150.72,64.75 150.72,65.46 150.5,65.68 149.25,65.68 148.58,65.01 148.15,65.01 148.12,65.03 147.26,65.03 147.03,65.26 147.03,65.64 147.03,65.64 147.37,65.98 147.37,68.28 147.24,68.41 147.24,69 147.95,69.71 147.95,70.85 148.73,71.64 148.73,72.91 149.82,74 149.82,75.07 150.38,75.62 151.27,75.62 151.6,75.96 151.6,78.57 v2(152.03,79)
  BOTTOM w0.086: v2(214.72,40.8) 215.25,40.28 JEDP1.27 ; v2(152.03,79) 152.4,79.37 UC1.D7
PBAT_CHARGER_SMBCLK: length 263.4
  TOP w0.086: v2(67.55,41.17) v1(67.94,40.78) 68.64,40.09 69.44,40.09 PD2.3 69.06,41.61 66.41,41.61 65.5,42.53 65.5,43.95 66.18,44.64 66.69,44.64 66.83,44.5 PRP1.3 ; 260.19,54.8 259.33,53.93 258.27,53.93 258.08,53.74 v2(258.08,53.5) RE43.1
  TOP w0.117: UE1.N2 260.19,54.8
  GND1 w0.117: v4(57.19,32.39) 57.02,32.22 v3(57.02,31.89)
  IN1 w0.051: v4(57.19,32.39) 57.22,32.42 57.22,34.59 57.8,35.17 57.8,37.33 61.16,40.7 67.08,40.7 v2(67.55,41.17) 68.13,41.17 70.73,43.77 75.89,43.77 76.67,44.56 79.27,44.56 80.08,45.37 83.52,45.37 84.97,43.93 86.52,43.93 86.76,43.68 86.76,42.26 87.29,41.73 87.29,39.66 87.94,39.01 87.94,38.37 88.78,37.53 88.78,35.12 91.21,32.69 95.08,32.69 95.91,31.87 107.34,31.87 110.35,28.86 126.47,28.86 127.96,30.35 140.73,30.35 142.29,31.92 158.74,31.92 159.61,32.79 162.67,32.79 163.09,32.38 163.09,31.25 165.25,29.09 171.8,29.09 173.29,30.58 180.44,30.58 182.55,28.47 195.54,28.47 195.71,28.29 200.03,28.29 200.73,28.99 206.54,28.99 207.66,27.87 219.52,27.87 220.11,28.46 220.16,28.46 220.16,28.46 220.54,28.46 220.54,28.46 228.65,28.46 229.27,29.07 252.23,29.07 255.57,32.42 255.57,38.83 256.47,39.73 256.47,45.75 257.44,46.71 257.44,52.86 v2(258.08,53.5)
PBAT_CHARGER_SMBDAT: length 256.5
  TOP w0.086: PRP1.2 67.33,43.75 67.63,43.44 68.7,43.44 PD1.2 69.01,42.69 v2(68.57,42.25) ; RE37.1 259,52.79 259,53.51 v2(258.98,53.53) 259.38,53.53 260.6,54.75 260.6,55.42 UE1.M3
  GND1 w0.117: v3(56.13,31.89) 56.13,32.42 v4(56.18,32.47)
  IN1 w0.051: v2(258.98,53.53) 258.62,53.89 257.92,53.89 257.27,53.24 257.27,46.78 256.3,45.82 256.3,39.78 255.42,38.89 255.42,32.5 252.16,29.24 229.23,29.24 228.59,28.61 220.6,28.61 220,28.61 219.41,28.02 207.75,28.02 206.61,29.16 200.69,29.16 199.97,28.44 195.78,28.44 195.6,28.62 182.64,28.62 180.51,30.75 173.22,30.75 171.73,29.26 169.41,29.26 168.13,30.54 164.04,30.54 163.26,31.32 163.26,32.45 162.74,32.96 159.54,32.96 158.67,32.09 142.22,32.09 140.66,30.52 127.89,30.52 127.88,30.51 127.87,30.51 127.01,29.65 109.8,29.65 107.41,32.04 95.98,32.04 95.15,32.86 91.28,32.86 88.95,35.19 88.95,37.6 88.12,38.44 88.12,39.08 87.46,39.73 87.46,41.77 86.91,42.33 86.91,43.75 86.58,44.08 85.03,44.08 83.58,45.53 80.02,45.53 79.2,44.71 74.1,44.71 73.32,43.93 70.25,43.93 v2(68.57,42.25) 67.91,41.59 66.95,41.59 66.29,40.93 61.15,40.93 57.62,37.4 57.62,35.24 56.18,33.79 v4(56.18,32.47)
PBAT_PRES#: length 269.1
  TOP w0.086: PD1.3 69.95,43.14 v3(69.12,43.96) 69.11,43.96 68.3,44.77 68.3,45.23 PR1.2 67.83,45.52 PRP1.1 ; v3(258.56,60.31) 258.67,60.21 265.3,60.21 265.7,60.61 UE1.F9 ; PR931.1 59.85,33.47 60.37,33.99 60.8,33.99 61.36,33.44 v1(61.36,33.28) 61.48,33.16 65.11,33.16 65.48,33.54 65.48,34.88 66.08,35.48 66.08,36.65 v2(65.85,36.88)
  GND1 w0.086: v3(69.12,43.96) 68.48,43.96 v4(68.32,43.8)
  GND1 w0.117: v3(258.56,60.31) 258.39,60.49 258.16,60.49 258.14,60.51 v4(258.11,60.51)
  IN1 w0.051: v4(68.32,43.8) 69.91,43.8 70.19,44.08 73.25,44.08 74.04,44.87 75.87,44.87 76.56,45.55 77.77,45.55 77.9,45.68 83.65,45.68 85.1,44.23 86.64,44.23 87.06,43.81 87.06,42.39 87.63,41.82 87.63,39.8 88.29,39.15 88.29,38.59 89.13,37.75 89.13,35.26 91.35,33.03 95.22,33.03 96.04,32.21 107.49,32.21 109.87,29.83 126.94,29.83 128.04,30.93 128.04,31.45 128.85,32.26 158.6,32.26 159.47,33.13 162.81,33.13 163.43,32.52 163.43,31.39 164.13,30.69 168.19,30.69 169.47,29.41 171.67,29.41 173.18,30.92 180.56,30.92 182.7,28.77 195.66,28.77 195.84,28.6 199.91,28.6 200.64,29.33 206.68,29.33 207.84,28.17 219.35,28.17 219.93,28.76 220.04,28.76 226.36,28.76 227.25,29.65 230.29,29.65 230.52,29.41 252.09,29.41 255.27,32.59 255.27,38.96 256.13,39.82 256.13,45.89 257.06,46.81 257.06,53.24 257.24,53.43 257.24,54.61 256.53,55.32 256.53,58.64 258.13,60.24 258.13,60.49 v4(258.11,60.51)
  IN3 w0.061: 65.7,37.03 65.7,42.2 67.34,43.84 68.28,43.84 v4(68.32,43.8)
  IN3 w0.097: 65.7,37.03 v2(65.85,36.88)
PBAT_PRES#_C: length 17.6
  TOP w0.086: PRP1.8 67.83,42.28 v2(67.94,42.17)
  BOTTOM w0.086: v2(67.94,42.17) 67.39,41.63 67.1,41.63 65.28,39.81 v1(62.02,39.81) 61.59,39.81 61.49,39.91 55.87,39.91 55.27,40.51 53.91,40.51 PBATT1.6
PBAT_SMBCLK_C: length 13.4
  TOP w0.086: v2(66.59,42.15) 66.83,42.38 PRP1.6
  BOTTOM w0.086: v2(66.59,42.15) 64.97,40.52 v1(63.14,40.52) 56.04,40.52 55.37,41.19 PBATT1.4
PBAT_SMBDAT_C: length 15.6
  TOP w0.086: PRP1.7 67.33,42.22 v2(67.3,42.2)
  BOTTOM w0.086: PBATT1.5 54.12,41.13 54.53,40.73 55.36,40.73 55.93,40.15 65.25,40.15 v2(67.3,42.2)
PBATT+_C: length 0.9
  BOTTOM w0.203: 61.54,45.2 61.8,45.2 PC1.1
  vias: v2(57.19,50.95) v2(57.19,50.36) v2(57.19,49.73) v2(57.19,48.98) v2(57.19,48.35) v2(57.19,47.71) v2(59.61,51.09) v2(59.61,50.5) v2(59.61,49.87) v2(59.58,49.09) v2(59.58,48.46) v2(59.58,47.82) v2(59.59,47.23) v2(60.43,44.48) v2(60.44,43.9) v2(61.02,44.48) v2(61.03,43.9) v2(61.6,44.5) v2(61.61,43.9) v3(58.08,51.01) v3(58.08,50.63) v3(58.08,50.25) v3(58.08,49.87) v3(58.08,48.87) v3(58.08,48.48) v3(58.08,48.1) v3(58.08,47.72) v3(58.46,51.01) v3(58.46,50.63) v3(58.46,50.25) v3(58.46,49.87) v3(58.46,48.87) v3(58.46,48.48) v3(58.46,48.1) v3(58.46,47.72) v3(58.84,51.01) v3(58.84,50.63) v3(58.84,50.25) v3(58.84,49.87) v3(58.84,48.87) v3(58.84,48.48) v3(58.84,48.1) v3(58.84,47.72) v4(57.73,47.24) v4(57.83,49.34) v4(58.06,51.55) v4(58.08,46.68) v4(58.35,47.21) v4(58.41,49.37) v4(58.64,51.55) v4(58.67,46.54) v4(58.93,47.23) v4(59.02,49.34) v4(59.23,51.55) v4(59.22,46.72) v5(57.79,51.02) v5(57.79,50.64) v5(57.79,50.26) v5(57.79,49.88) v5(57.84,48.85) v5(57.84,48.47) v5(57.84,48.09) v5(57.84,47.71) v5(58.31,51.02) v5(58.31,50.64) v5(58.31,50.26) v5(58.31,49.88) v5(58.32,48.84) v5(58.32,48.46) v5(58.32,48.08) v5(58.32,47.7) v5(58.98,48.85) v5(58.98,48.47) v5(58.98,48.09) v5(58.98,47.71) v5(59.06,51.02) v5(59.06,50.64) v5(59.06,50.26) v5(59.06,49.88) v6(58.11,46.41) v6(59.89,45.94) v6(61.98,45.28)
PCH_3.3V_TS_EN: length 46.8
  TOP w0.086: v1(181.93,41.67) 181.07,40.81 v3(181.07,40.73) ; v2(153.02,63.3) 153.41,63.69 RC282.1
  GND1 w0.086: v4(181.07,39.89) v3(181.07,40.73)
  IN1 w0.051: v4(181.07,39.89) 178.91,39.89 178.83,39.97 178,39.97 176.59,41.37 173.74,41.37 172.39,42.73 169.46,42.73 168.29,43.9 165.85,43.9 163.29,46.46 163.29,48.64 157.29,54.64 157.29,55.08 157.29,55.84 155.11,58.03 155.11,62.7 154.51,63.3 v2(153.02,63.3)
  BOTTOM w0.086: UC1.AP5 153.47,63.76 v2(153.02,63.3)
PCH_ALW_ON: length 49.9
  TOP w0.086: v3(242.92,32.32) 242.89,32.34 241.29,32.34 238.92,29.97 v1(238.66,29.97) 237.55,29.97 236.77,30.74 RZ65.1 ; UE1.M8 v2(265.36,55.44) ; RPE10.3 256.59,41.92 256.3,41.64 255.47,41.64 v3(255.34,41.77)
  GND1 w0.086: v4(254.86,41.77) v3(255.34,41.77) ; v4(243.37,32.5) 243.2,32.32 v3(242.92,32.32)
  IN2 w0.061: v2(265.36,55.44) 265.24,55.32 265.24,54.9 264.27,53.92 263.15,53.92 261.37,52.14 261.37,51.12 259.93,49.68 258.51,49.68 258.18,49.35 258.18,47.49 256.27,45.58 256.27,43.18 v4(254.86,41.77) 254.78,41.77 254.11,41.1 254.11,35.95 251.84,33.68 251.25,33.68 249.67,32.09 247,32.09 246.38,32.71 243.59,32.71 v4(243.37,32.5)
PCH_BATLOW#: length 9.9
  TOP w0.086: RC72.1 154.01,55.21 149.04,60.19 v1(149.04,60.41) 149.04,60.69 148.44,61.28 v2(148.44,61.48)
  BOTTOM w0.086: UC1.AU13 148.78,61.81 v2(148.44,61.48)
PCH_CL_CLK1: length 128
  IN1 w0.051: JNGFF1.42 242.11,45.9 241.04,46.98 241.04,47.71 237.52,51.22 229.6,51.22 229.24,51.58 228.07,51.58 227.3,50.81 226.56,50.81 v4(226.09,51.28)
  IN3 w0.061: v2(163.54,83.07) 164.63,84.15 168.43,84.15 169.16,84.15 170.42,82.9 171.48,82.9 172.38,82 172.38,68.57 174.43,66.51 174.43,60.54 178.05,56.93 178.05,55.17 182.33,50.89 182.33,49.89 185.39,46.83 186.14,46.83 188.06,44.91 199.87,44.91 200.75,44.03 211.49,44.03 214.49,47.02 215.94,47.02 216.93,46.03 218.81,46.03 219.8,47.02 222.29,47.02 226.09,50.82 v4(226.09,51.28)
  BOTTOM w0.076: 157.31,79.55 156.02,78.27 155.85,78.2 155.64,78.14 155.52,78.14 155.09,77.95 154.96,77.81 UC1.G3
  BOTTOM w0.086: 157.31,79.55 157.88,80.12 160.12,80.12 v1(160.96,80.95) 162.74,82.74 163.21,82.74 v2(163.54,83.07)
PCH_CL_DATA1: length 125.8
  IN1 w0.051: v4(226.67,51.36) 227.24,51.36 228.08,52.2 234.36,52.2 234.73,51.82 237.53,51.82 241.47,47.89 241.47,47.16 242.22,46.4 JNGFF1.40
  IN3 w0.061: v4(226.67,51.36) 226.67,50.78 222.48,46.58 220.44,46.58 219.45,45.59 216.91,45.59 215.02,43.71 213.44,43.71 213.33,43.59 200.56,43.59 199.68,44.47 187.88,44.47 185.96,46.39 185.17,46.39 173.99,57.57 173.99,66.33 171.9,68.42 171.9,81.8 171.29,82.42 170.27,82.42 168.98,83.71 168.61,83.71 165.22,83.71 164.17,82.66 163.32,82.66 v2(162.93,82.27)
  BOTTOM w0.076: UC1.G2 155.91,78.04 156.09,78.11 156.38,78.11 157.35,79.08
  BOTTOM w0.086: 157.35,79.08 157.45,79.18 159.85,79.18 v1(162.16,81.49) v2(162.93,82.27)
PCH_CL_RST1#: length 127.7
  IN1 w0.051: JNGFF1.38 242.33,46.9 241.9,47.34 241.9,48.07 237.34,52.63 227.77,52.63 227.16,52.02 v4(226.7,52.02)
  IN3 w0.061: v4(226.7,52.02) 227.11,51.61 227.11,49.88 223.37,46.14 220.63,46.14 219.64,45.15 217.09,45.15 215.21,43.27 213.63,43.27 213.51,43.15 200.38,43.15 199.5,44.03 187.69,44.03 185.77,45.95 184.84,45.95 182.8,47.98 181.71,47.98 180.23,49.47 180.23,50.71 173.55,57.38 173.55,66.15 171.01,68.69 171.01,81.06 168.8,83.27 166.01,83.27 163.9,81.16 v2(162.65,81.16)
  BOTTOM w0.076: UC1.G1 156.41,77.81 157.32,78.71
  BOTTOM w0.086: v2(162.65,81.16) 162.57,81.16 v1(160.78,79.37) 160.13,78.71 157.32,78.71
PCH_DPWROK: length 183.8
  TOP w0.086: v2(273.94,64.05) 273.55,64.45 273.55,66.47 v6(273.32,66.7) 272.03,67.99 RE536.1
  IN2 w0.061: v2(273.94,64.05) 274.45,63.55 274.45,62.68 273.37,61.6 273.37,56.48 271.06,54.17 271.06,53.17 270.67,52.78 270.67,50.81 269.49,49.64 268.72,49.64 267.99,48.9 267.99,48.24 266.53,46.79 266.25,46.79 265.51,46.05 263.8,46.05 262.88,45.14 262.88,43.78 261.23,42.13 261.23,41.43 259.01,39.21 259.01,35.38 257.71,34.08 257.71,31.88 253.24,27.41 252.08,27.41 251.25,28.24 235.81,28.24 235.3,27.74 233.72,27.74 233.54,27.91 227.06,27.91 223.94,31.03 216.39,31.03 215.4,32.02 210.36,32.02 209.69,31.35 209.69,30.44 208.7,29.45 200.86,29.45 200.39,29.91 188.09,29.91 187.57,30.43 180.98,30.43 179.93,31.47 174.74,31.47 173.67,32.54 171.9,34.31 169.12,34.31 166.48,36.96 165.54,36.96 163.43,39.07 163.43,41.48 162.45,42.45 162.45,43.29 161.25,44.49 161.25,45.69 158.85,48.09 152.82,48.09 150.66,50.25 v4(150.66,50.66)
  GND5 w0.086: v4(150.66,50.66) 150.66,50.76 150.58,50.84 v5(150.58,51.22)
  BOTTOM w0.076: 146.83,54.8 146.83,55.85 146.07,56.61 146.07,57.21 145.39,57.88 145.39,58.47 UC1.BB20
  BOTTOM w0.086: v5(150.58,51.22) CC266.1 RC220.1 148.81,51.98 146.83,53.96 146.83,54.8
PCH_DPWROK_EC: length 15.6
  TOP w0.086: v2(267.99,66.15) 267.99,66.4 269.77,68.18 269.77,68.97 RE536.2 271.11,70.91 v1(271.47,71.27) ; UE1.F8 v2(265.36,60.98)
  BOTTOM w0.086: v2(265.36,60.98) 265.81,60.54 267.86,60.54 268.17,60.84 268.17,65.97 v2(267.99,66.15)
PCH_JTAG_TCK: length 79
  TOP w0.086: v3(60.51,90.7) 60.27,90.94 JXDP1.55
  GND1 w0.086: v3(60.51,90.7) v4(60.14,91.07)
  IN4 w0.051: v2(121.16,87.5) 121.1,87.56 121.1,88.9 118.58,91.42 114.95,91.42 112.99,93.38 95.5,93.38 91.91,89.79 89.2,89.79 85.56,93.43 77.23,93.43 76.42,94.24 71.67,94.24 70.53,93.1 70.53,92.8 70.15,92.41 62.04,92.41 60.7,91.07 v4(60.14,91.07)
  BOTTOM w0.076: 123.63,83.81 123.69,83.76 123.69,82.79 124.14,82.33 124.14,81.66 123.96,81.48 123.96,81.22 124.02,81.1 124.02,80.88 UC1.B56
  BOTTOM w0.086: v2(121.16,87.5) 121.1,87.44 121.1,86.29 121.53,85.86 RC86.1 123.63,83.81
PCH_JTAG_TDI: length 47.8
  TOP w0.086: v3(87.8,88.88) 88,88.88 v1(88.38,88.5)
  TOP w0.117: v3(87.8,88.88) 87.77,88.88 87.4,88.51 RC229.2
  GND1 w0.086: v3(87.8,88.88) 87.8,89.47 v4(87.98,89.65)
  IN4 w0.051: v4(120.11,87.49) 118.1,89.49 114.06,89.49 113.27,90.28 94.01,90.28 92.36,88.63 88.58,88.63 87.98,89.24 v4(87.98,89.65)
  GND5 w0.086: v5(120.57,87.77) 120.29,87.49 v4(120.11,87.49)
  BOTTOM w0.076: 122.89,84.03 122.89,82.65 122.95,82.59 122.95,81.91 123.31,81.55 123.31,81.19 123.27,81.09 123.27,80.9 123.31,80.81 123.31,80.56 123.29,80.52 123.25,80.36 123.17,80.08 123.17,79.97 123.09,79.7 UC1.D59
  BOTTOM w0.086: 122.89,84.03 121.56,85.35 121.08,85.35 CC304.1 120.57,86.04 120.06,86.55 120.06,87.26 v5(120.57,87.77)
PCH_JTAG_TDO: length 50.8
  TOP w0.086: RC230.2 87.94,85.96 92.12,85.96 94.53,88.37 103.18,88.37 105.16,90.35 105.83,90.35 108.7,93.22 114.55,93.22 115.64,92.13 v6(117.07,92.13) 118.23,90.98 v2(118.23,90.43)
  BOTTOM w0.076: UC1.A56 124.32,81.42 124.32,82.43 123.85,82.9 123.85,84.11
  BOTTOM w0.086: 122.52,85.86 123.85,84.53 123.85,84.11 ; 122.52,85.86 123.49,85.86 CC303.1 123.84,85.86 124.02,86.04 124.02,87 122.87,88.15 122.3,88.15 121.16,89.29 120.01,89.29 119.27,90.03 118.64,90.03 v2(118.23,90.43) ; 122.52,85.86 RC82.1
PCH_JTAG_TMS: length 53.6
  TOP w0.086: v2(84.77,91.32) 84.32,91.78 82.97,91.78 81.64,90.45 v6(81.56,90.45) 80.32,90.45 79.58,89.71 RC228.2
  IN4 w0.051: v2(84.77,91.32) 85.36,91.32 88.42,88.26 92.57,88.26 93.37,89.06 117.75,89.06 119.27,87.54 v4(119.27,87.49)
  GND5 w0.086: v5(119.68,87.77) 119.4,87.49 v4(119.27,87.49)
  BOTTOM w0.076: UC1.C59 123.06,80.33 123.14,80.59 123.14,80.76 123.08,80.95 123.08,81.1 123.14,81.22 123.14,81.48 122.77,81.85 122.77,82.54 122.71,82.6 122.71,83.92 122.45,84.19
  BOTTOM w0.086: 122.45,84.19 121.49,85.14 120.36,85.14 120.03,85.47 120.03,86.28 119.68,86.64 v5(119.68,87.77)
PCH_PCIE_WAKE#: length 473.1
  TOP w0.086: v2(268.59,48.89) 268.79,48.89 RE274.2 ; v2(20.31,13.1) 20.31,14.06 RT422.2 ; v2(258.72,56.8) 259.19,56.8 UE1.L1
  IN3 w0.061: v2(20.31,13.1) 20.31,13.1 21.7,14.49 27.65,14.49 30.77,17.61 30.77,22.98 31.97,24.18 31.97,25.14 32.34,25.51 32.9,25.51 33.25,25.86 34.07,25.86 38.2,29.99 50.55,29.99 50.72,29.82 58.69,29.82 58.9,29.61 91.49,29.61 91.83,29.26 105.18,29.26 108.46,25.99 142.34,25.99 144.73,28.38 155.2,28.38 157.95,25.63 176.96,25.63 177.49,26.16 178.9,26.16 179.33,25.73 191.36,25.73 191.62,25.46 193.18,25.46 193.45,25.73 226.93,25.73 227.67,26.46 230.54,26.46 231.28,25.72 240.08,25.72 241.48,27.12 251.44,27.12 252.71,25.85 257.68,25.85 260.64,28.8 260.64,35.56 261.04,35.96 261.04,39.66 265.45,44.07 265.45,44.71 267.91,47.18 267.91,48.22 v2(268.59,48.89)
  IN4 w0.051: v2(155.14,51.85) 155.14,51.7 154.73,51.29 154.73,50.89 155.64,49.97 155.64,49.46 158.6,46.5 158.7,46.5 159.52,45.69 161.86,45.69 163.52,44.02 164.28,44.02 164.83,43.46 164.83,40.37 163.82,39.35 163.82,38.46 168.55,33.73 170.06,33.73 173.09,30.7 175.45,30.7 176.4,29.76 178.76,29.76 179.99,28.53 194.01,28.53 194.43,28.11 200.11,28.11 200.54,28.55 204.37,28.55 205,27.92 205,27.48 205.62,26.86 218.79,26.86 219.78,27.85 224.2,27.85 224.28,27.77 229.77,27.77 230.56,28.56 233.32,28.56 234.02,27.86 235.21,27.86 235.4,28.04 253.93,28.04 256.35,30.46 256.35,45.88 256.58,46.11 v4(256.58,46.97) 256.66,47.05 256.66,50.99 256.25,51.39 256.05,51.39 255.59,51.85 255.59,53.66 258.72,56.78 v2(258.72,56.8)
  GND5 w0.086: v5(256.58,47.46) v4(256.58,46.97)
  BOTTOM w0.076: UC1.BB15 147.5,58.61 147.5,57.42 148.32,56.6 148.32,56.45 149.95,54.82 149.95,54.67
  BOTTOM w0.086: 149.95,54.67 v1(151.3,53.32) 152.59,52.03 154.04,52.03 RC67.1 155.14,51.49 v2(155.14,51.85) ; v5(256.58,47.46) 257.07,46.97 258.87,46.97 259.3,46.54 260.44,46.54 262.22,48.32 264.99,48.32 265.56,48.89 v2(268.59,48.89) ; v2(20.31,13.1) 19.58,13.84 19.58,14.3 18.36,15.52 15.46,15.52 14.08,14.14 13.27,14.14 12.3,13.16 12.3,12.69 11.13,11.53 RT445.1
PCH_PLTRST#: length 59.8
  IN3 w0.061: v4(178.11,37.9) 182.89,37.9 184.47,36.32 v4(187.08,36.32) ; v4(156.02,58) 154.12,58 150.61,61.5 150.61,62.75 151.21,63.34 v4(151.21,63.82)
  IN4 w0.051: v4(156.02,58) 158.62,58 161.51,55.1 163.32,55.1 165.04,53.37 166.01,53.37 168.25,51.13 168.25,49.56 172.31,45.5 172.31,43.01 174.59,40.72 174.59,39.98 174.64,39.93 174.64,38.36 175.25,37.75 177.96,37.75 v4(178.11,37.9)
  GND5 w0.086: v5(187.22,35.85) 187.08,35.99 v4(187.08,36.32) ; v5(150.73,64.41) 150.73,64.3 v4(151.21,63.82)
  BOTTOM w0.086: UC7.2 188.65,35.99 RC244.1 ; RC244.1 188.49,36.64 UC7.1 187.41,36.64 187.22,36.45 v5(187.22,35.85) ; RC244.1 189.03,36.37 RC60.1
PCH_PLTRST#_5105: length 9.3
  TOP w0.086: UE6.4 253.85,54.58 v1(254.12,54.85) RE340.1 255.06,56.6 255.31,56.85 255.96,56.85 256.38,56.43 257.81,56.43 258.23,56.85 258.23,57.44 258.64,57.84 258.96,57.84 UE1.K1
PCH_PLTRST#_AND: length 337.6
  TOP w0.076: JNGFF3.50 22.1,12.67 22.19,12.76
  TOP w0.086: v2(186.5,33.11) 187.94,31.67 191.29,31.67 192.12,30.84 192.12,29.61 192.85,28.88 v2(192.85,25.98) ; v2(19.19,22.17) 19.19,21.66 20.01,20.85 v6(20.71,20.85) 20.95,20.85 21.47,21.37 RT419.2 21.96,17.12 22.47,16.61 22.47,13.04 22.19,12.76 ; CZ61.1 189.41,41.35 v3(189.68,41.61)
  TOP w0.117: RZ114.1 CZ61.1
  GND1 w0.086: v4(190.09,42.21) 190.03,42.15 190.01,42.15 189.68,41.82 v3(189.68,41.61)
  IN1 w0.069: JNGFF1.66 242.24,39.9 241.98,40.17 241.98,42.85 JNGFF1.52
  IN2 w0.061: v2(19.19,22.17) 20.03,23.01 28.25,23.01 30.88,25.64 33.75,25.64 37.43,29.32 104.82,29.32 106.44,27.7 106.91,27.7 126,27.7 127.08,28.78 144.92,28.78 145.4,29.26 154.74,29.26 156.92,27.08 158.08,27.08 159.95,25.2 178.64,25.2 179.38,25.94 191.21,25.94 191.69,26.43 192.41,26.43 v2(192.85,25.98) ; JNGFF2.50 231.42,76.4 230.72,75.7 230.72,70.27 229.89,69.44 229.89,67.12 229.99,67.01 232.89,67.01 v2(233.21,67.33) ; v4(190.09,42.21) 190.61,42.73 210.74,42.73 211.77,41.71 220.72,41.71 220.8,41.62 222.39,41.62 223.23,40.78 230.4,40.78 231.84,42.22 240.2,42.22 240.4,42.02 241.27,42.02 242,42.76 242,42.87 JNGFF1.52
  GND5 w0.086: v5(189.25,41.46) 189.34,41.46 v4(190.09,42.21) ; v5(186.5,34.07) v2(186.5,33.11)
  BOTTOM w0.086: v2(233.21,67.33) 233.55,66.99 240.64,66.99 243.3,64.33 243.3,60.28 241.47,58.45 241.47,57.06 241.8,56.73 241.8,44.13 JNGFF1.52 ; v2(19.19,22.17) 19.88,22.17 20.08,21.97 21.9,21.97 RT446.1 ; v5(189.25,41.46) 188.99,41.21 187.7,41.21 187.5,41.01 JTS1.2 187.5,37.86 186.73,37.09 185.01,37.09 184.62,36.71 RC65.1 184.62,35.7 184.99,35.34 UC7.4 185.95,35.01 185.74,34.81 RC325.1 186.2,34.38 v5(186.5,34.07)
PCH_PLTRST#_EC: length 104.9
  TOP w0.086: RE375.2 197.1,32.6 198.24,32.6 198.62,32.22 198.62,31.13 197.47,29.98 v2(197.47,29.52) 197.47,29.38 197.74,29.1 198.23,29.1 200.32,27.01 202.75,27.01 203.79,28.04 203.79,29.66 204.49,30.36 204.49,33.27 207.22,36 210.89,36 v6(213.08,38.19) v2(215.69,40.8) ; UE6.2 253.2,52.84 v3(253.15,52.89)
  GND1 w0.117: v4(252.6,53.15) 252.76,53.15 252.87,53.04 253,53.04 v3(253.15,52.89)
  IN2 w0.061: v4(252.6,53.15) 253,53.56 253,55.51 252.82,55.69 252.82,58.48 252.65,58.66 252.65,58.66 251.73,59.57 251.73,60.56 v4(251.58,60.71)
  IN3 w0.061: v4(251.58,60.71) 250.3,60.71 249.44,61.57 243.22,61.57 242.41,60.77 239.51,60.77 235.2,56.46 235.08,56.46 232.51,53.89 232.51,50.26 225.08,42.82 223.34,42.82 221.99,41.48 217.48,41.48 216.8,40.8 v2(215.69,40.8)
  BOTTOM w0.086: v2(197.47,29.52) 197.47,29.71 195.95,31.22 192.59,31.22 191.93,31.89 189.22,31.89 188.38,32.72 188.38,33.92 188.65,34.18 188.65,35.42 188.99,35.76 189.62,35.76 189.81,35.95 RC244.2
PCH_POPIRCOMP: length 10.3
  TOP w0.381: v2(146.62,61.43) 146.62,60.93 147.16,60.39 147.16,57.8 v1(149.28,55.68) 149.95,55 RC89.1
  BOTTOM w0.254: UC1.AU16 147.07,61.76 146.88,61.62 v2(146.62,61.43)
PCH_PRIM_EN: length 227.6
  TOP w0.086: v3(168.2,36.06) 168.17,36.06 167.73,36.5 ; 167.73,36.5 167.73,35.77 RC442.2 166.67,34.71 166.67,30.06 166.58,29.97 166.46,29.97 166.18,29.97 165.91,30.23 v3(162.63,30.23) ; 167.73,36.5 RC441.2 ; v3(235.96,30.68) 235.88,30.76 RZ64.1 ; v1(208.28,32.83) 208.28,32.58 v3(208.65,32.22) 208.86,32.42 PR504.1 ; v3(93.82,40.45) 93.82,40.49 UZ34.1
  GND1 w0.086: v4(235.37,30.31) 235.59,30.31 v3(235.96,30.68) ; v3(93.82,40.45) 93.77,40.39 93.77,39.86 v4(93.79,39.84) ; v4(162.17,30.07) 162.47,30.07 v3(162.63,30.23) ; v4(208,32) 208.43,32 v3(208.65,32.22) ; v3(168.2,36.06) 168.58,36.06 168.62,36.03 168.92,36.03 v4(169.32,35.62)
  IN2 w0.061: v4(169.32,35.62) 169.57,35.37 175.58,35.37 177.35,33.6 181.3,33.6 182.61,32.29 192.17,32.29 192.77,32.89 195.41,32.89 196.71,31.59 203.21,31.59 203.43,31.81 207.81,31.81 v4(208,32) 209.38,33.38 215.97,33.38 216.95,32.39 224.5,32.39 226.82,30.08 228.67,30.08 229.14,29.6 234.67,29.6 v4(235.37,30.31) ; v4(64.09,76.93) 64.23,77.07 65.54,77.07 66.9,75.71 66.9,74 64.37,71.47 64.37,68.81 66.7,66.48 66.7,64.98 68.8,62.88 70.92,62.88 72.73,61.08 72.73,58.86 77.19,54.41 77.19,48.26 78.12,47.33 81.86,47.33 85.36,43.82 89.48,43.82 89.49,43.81 89.49,43.81 91.69,41.61 91.69,41.46 91.69,41.15 93.01,39.84 v4(93.79,39.84) 94.89,38.74 94.89,33.37 96.91,31.35 105.18,31.35 106.31,30.22 126.07,30.22 126.5,30.65 140.9,30.65 141.89,31.64 158.78,31.64 160.34,30.07 v4(162.17,30.07)
  GND5 w0.086: v5(63.59,76.29) 63.59,76.44 v4(64.09,76.93) ; v5(169.32,35.11) v4(169.32,35.62)
  BOTTOM w0.086: v5(169.32,35.11) 169.32,35.03 PR406.1
PCH_PWROK: length 175.6
  TOP w0.086: v1(64.42,77.1) 64.79,77.47 v2(64.79,77.73) 64.82,77.77 64.82,78.03 65.59,78.79 65.59,79.57 65.92,79.91 66.9,79.91 PR614.1
  IN2 w0.061: v2(147.29,51.34) 146.73,51.9 146.17,51.9 143.91,49.64 143.91,48.99 144.2,48.7 149.25,48.7 152.33,45.62 155.81,45.62 156.24,45.19 156.24,42.62 156.66,42.2 157.48,42.2 159.09,40.59 159.09,33.73 157.37,32.01 97.2,32.01 95.55,33.67 95.55,39.53 94.48,40.6 93.11,40.6 92.3,41.41 92.3,41.86 89.74,44.42 85.29,44.42 82.04,47.68 82.04,49.28 80.92,50.39 80.92,54.17 79.1,55.99 76.15,55.99 73.11,59.03 73.11,68.4 72.64,68.87 72.64,71.26 71.57,72.32 69.59,72.32 67.4,74.51 67.4,75.74 65.56,77.58 64.94,77.58 v2(64.79,77.73)
  BOTTOM w0.076: UC1.BA20 144.9,59.08 144.9,58.54 145.23,58.21 145.23,57.81 145.89,57.15 145.89,56.55 146.64,55.81 146.64,53.84
  BOTTOM w0.086: 146.64,53.84 147.92,52.57 RC411.1 147.41,51.22 v2(147.29,51.34)
PCH_RSMRST#: length 144.7
  TOP w0.086: v2(253.81,42.64) 253.18,42.01 RE342.1 252.65,40.7 252.01,40.7 251.53,40.22 251.53,37.83 251.76,37.6 251.76,36.33 250.77,35.34 249.47,35.34 248.99,34.86 248.99,32.62 248.2,31.84 245.79,31.84 245.25,32.37 244.37,32.37 240.11,28.11 v3(239.64,28.11) ; UE1.M5 v2(262.22,55.44) ; v3(166.32,30.31) 165.94,30.69 164.86,30.69 163.8,31.76 163.8,32.32 164.18,32.7 164.41,32.7 164.79,33.08 164.79,34.95 168.14,38.3 168.14,39.27 168.6,39.73 168.6,43.65 v6(166.17,46.08) 166.11,46.14 165.05,46.14 v3(164.47,46.72)
  GND1 w0.086: v4(164.21,46.32) 164.47,46.58 v3(164.47,46.72) ; v4(166.69,29.55) 166.34,29.9 166.34,30.29 v3(166.32,30.31) ; v3(239.64,28.11) 239.64,27.67 v4(239.6,27.63)
  IN2 w0.061: v2(262.22,55.44) 262.11,55.44 261.53,54.85 259.87,54.85 259.07,54.06 258.77,54.06 258.51,53.81 258.51,53.06 257.06,51.6 257.06,48.72 255.2,46.86 255.2,44.03 v2(253.81,42.64)
  IN3 w0.061: v4(239.6,27.63) 238.68,26.7 231.55,26.7 230.98,27.28 227.12,27.28 226.7,26.86 222.06,26.86 222.05,26.87 181.62,26.87 179.06,29.44 176.67,29.44 175.64,28.41 169.61,28.41 169.41,28.61 167.21,28.61 166.69,29.13 v4(166.69,29.55)
  GND5 w0.086: v4(164.21,46.32) 163.93,46.04 v5(163.93,45.64)
  BOTTOM w0.086: v5(163.93,45.64) 163.89,45.64 163.84,45.59 UZ6.1
PCH_RSMRST#_AND: length 312.1
  TOP w0.086: v3(161.33,29.04) 161.33,29.63 163.29,31.58 163.29,33.08 164.38,34.17 164.38,35.1 167.71,38.42 v6(167.71,42.82) 167.71,43.93 166.49,45.14 164.78,45.14 v3(164.07,45.86)
  GND1 w0.086: v4(163.7,46.65) 163.81,46.54 163.81,46.12 v3(164.07,45.86) ; v3(161.33,29.04) v4(161.33,28.41)
  IN2 w0.061: v4(15.89,56.14) 16.55,56.8 16.55,57.93 16.92,58.3 16.92,63.92 16.55,64.29 16.55,69.93 15.36,71.12 15.36,72.94 18.19,75.77 18.19,77.48 20.67,79.96 22.62,79.96 28.52,85.86 35.07,85.86 35.73,86.52 v4(36.75,86.52)
  IN4 w0.051: v4(36.75,86.52) 37.63,87.41 40.62,87.41 42.89,89.67 44.06,89.67 44.73,89.01 47.85,89.01 48.64,88.22 58.66,88.22 58.84,88.04 65.11,88.04 65.96,88.88 67.27,88.88 v4(67.68,88.47) ; v4(161.33,28.41) 161.28,28.46 160.43,28.46 158.23,30.67 111.6,30.67 110.52,31.75 95.26,31.75 94.88,32.12 92.1,32.12 89.57,34.66 89.57,39.91 88.99,40.48 88.99,40.95 87.87,42.07 87.63,42.07 86.3,43.4 86.08,43.62 73.71,43.62 73.36,43.98 70.46,43.98 69.11,42.63 65.38,42.63 63.75,41 60.35,41 59.51,41 58.99,41.53 53.92,41.53 53.22,42.22 51.85,42.22 51.39,41.77 48.64,41.77 46.73,39.86 45.14,39.86 44.34,39.06 42.11,39.06 41.51,39.66 39.33,39.66 38.31,38.64 34.72,38.64 33.68,37.6 33.17,37.6 32.28,36.71 28.19,36.71 27.42,35.94 27.42,35.63 26.99,35.19 26.69,35.19 26.19,35.19 22.4,38.97 19.44,38.97 17.72,40.69 17.72,41.88 16.71,42.9 16.71,50.17 17.07,50.54 17.07,54.96 15.94,56.09 15.94,56.09 v4(15.89,56.14)
  GND5 w0.086: v4(67.68,88.47) 67.73,88.52 v5(67.73,89.14) ; v4(163.7,46.65) 163.56,46.8 v5(163.24,46.8)
  BOTTOM w0.076: UC1.AY17 146.19,59.62 146.12,59.41 146.12,59.29 146.18,59.06 146.18,58.92 146.13,58.8 146.13,58.54 146.29,58.38 146.29,56.85 147.05,56.1 147.05,55.38
  BOTTOM w0.086: 147.05,55.38 147.05,55.14 147.21,54.98 147.21,53.86 147.77,53.3 148.38,53.3 149.9,51.77 150.94,51.77 151.47,51.25 RC75.1 151.47,51.19 RC215.2 150.99,49.89 153.56,49.89 154.55,48.9 161.61,48.9 162.15,48.37 162.15,47.52 UZ6.4 162.17,47.19 162.56,46.8 v5(163.24,46.8) ; RC124.1 67.02,90.56 67.73,89.85 v5(67.73,89.14)
PCH_RTCRST#: length 190.6
  TOP w0.086: v2(147.53,64.65) 148.17,64.02 148.53,64.02 148.83,63.72 148.83,61.45 149.31,60.97 149.31,60.59 154.9,55 RC57.1 ; RE94.2 258.08,70.52 v2(257.83,70.27) ; CC25.1 164.79,44.37 CMOS1.1 164.79,43.44 164.14,42.79 164.14,42.67 164.14,42.67 164.14,41.35 v3(164.33,41.16) ; v3(198.29,34.98) 197.48,35.8 197.48,39.53 196.72,40.29 v6(194.1,40.29) 193.16,40.29 192.28,41.17 190.93,41.17 190.84,41.26 JAPS1.9
  GND1 w0.086: v3(198.29,34.98) 198.57,34.7 v4(198.68,34.7) ; v3(164.33,41.16) v4(164.33,40.65)
  IN1 w0.051: v4(229.96,41.42) 229.96,41.2 229.41,40.65 229.41,37.27 229.15,37.02 224.83,37.02 223.4,35.58 218.83,35.58 218.26,35.01 206.14,35.01 205.94,34.81 200.38,34.81 200.11,35.09 199.07,35.09 v4(198.68,34.7) 198.03,35.35 185.32,35.35 183.25,37.42 179.31,37.42 178.08,38.65 175.72,38.65 175.23,38.16 173.92,38.16 172.03,40.05 166.48,40.05 165.98,40.55 164.43,40.55 v4(164.33,40.65) 163,41.98 162.36,41.98 161.38,42.96 161.38,43.73 160.81,44.3 160.81,44.31 160.81,45.51 160.34,45.98 159.13,45.98 157.86,47.26 156.96,47.26 154.81,49.41 154.81,50.12 155.57,50.89 155.57,55.09 149.97,60.68 148.91,60.68 148.55,61.05 147.43,61.05 147.13,61.35 147.13,64.32 147.46,64.65 v2(147.53,64.65)
  IN2 w0.061: v4(229.96,41.42) 230.54,41.42 232.47,43.34 233.44,43.34 237.74,47.63 237.74,48.34 239.79,50.4 239.79,53.3 v4(240.68,54.19)
  IN4 w0.051: v4(240.68,54.19) 240.68,58.36 246.18,63.86 249.88,63.86 250.64,63.1 251.25,63.1 251.53,63.38 251.53,65.46 252.54,66.48 252.54,67.43 253.27,68.16 258.16,68.16 258.36,68.36 258.36,69.73 v2(257.83,70.27)
  BOTTOM w0.086: UC1.AM16 v2(147.53,64.65)
PCH_RTCX1: length 18.5
  TOP w0.086: v3(158.81,61.85) RC54.2 CC23.1 158.78,63.7 YC2.1
  GND1 w0.086: v3(158.81,61.85) 158.81,61.73 v4(158.54,61.45)
  IN4 w0.051: v4(146.58,65.36) 146.58,65.23 146.78,65.02 148.63,65.02 148.77,65.16 149.62,65.16 149.8,64.98 149.8,64.58 150,64.37 151.27,64.37 151.93,63.71 153.38,63.71 153.97,63.13 154.15,63.13 155.77,61.5 158.49,61.5 v4(158.54,61.45)
  GND5 w0.086: v5(146.16,65.06) 146.46,65.36 v4(146.58,65.36)
PCH_RTCX2: length 19.5
  TOP w0.088: v1(160.1,61.86) 160.58,62.35 RC296.1 159.75,62.79 v3(159.73,62.77)
  GND1 w0.088: v3(159.73,62.77) v4(159.73,62.16)
  IN4 w0.062: v4(159.73,62.16) 159.68,62.11 155.96,62.11 153.78,64.3 153.1,64.3 152.15,65.25 151.14,65.25 150.59,65.8 147.33,65.8 147.26,65.72 146.63,65.72 146.33,66.02 145.76,66.02 145.64,65.9 v4(145.64,65.74)
  GND5 w0.088: v5(145.57,65.27) 145.57,65.68 v4(145.64,65.74)
  BOTTOM w0.088: v5(145.57,65.27) 145.54,65.27 145.4,65.12 UC1.AM20
PCH_RTCX2_R: length 6
  TOP w0.088: YC2.2 161.28,64.85 160.58,64.16 CC26.1 160.69,63.68 161.5,62.87 RC296.2 161.5,62.48 160.2,61.18 v1(160.2,60.47)
PCH_SMB_ALERT#: length 7.2
  TOP w0.086: v3(151.36,72.53) 151.44,72.44 v1(154.29,72.44) 154.61,72.44 155.54,71.51 RC23.1
  GND1 w0.086: v4(151.1,71.87) 151.1,72.27 v3(151.36,72.53)
  GND5 w0.086: v4(151.1,71.87) 151.12,71.89 151.12,72.65 v5(151.02,72.75)
  BOTTOM w0.086: UC1.R10 v5(151.02,72.75)
PCH_SPI_CLK: length 34.1
  TOP w0.086: JSPI1.13 173.45,47.57 173.29,47.73 173.27,47.73 173.14,47.86 171.99,47.86 171.53,47.4 RC35.2 170.93,47.36 v6(170.35,46.78) 170.22,46.65 170.22,45.35 v3(170.81,44.76)
  GND1 w0.086: v3(170.81,44.76) 171.09,44.76 171.49,45.17 v4(171.49,45.22)
  IN1 w0.051: v4(157.06,60.49) 157.06,58.77 164,51.83 164,51.62 165.53,50.09 165.53,47.35 167.19,45.69 169.44,45.69 169.91,45.22 v4(171.49,45.22)
  GND5 w0.086: v5(157.04,61.27) 157.04,60.51 v4(157.06,60.49)
  BOTTOM w0.076: v5(157.04,61.27) 156.86,61.45 155.87,61.45 155.63,61.21 UC1.AV2
PCH_SPI_CLK_0_R: length 15.9
  TOP w0.086: RPC1.7 174.54,58.49 175.28,59.22 v3(175.45,59.22) 176.98,59.22 v1(177.35,59.58) RC29.1
  GND1 w0.086: v4(174.97,59.42) 175.17,59.22 v3(175.45,59.22)
  GND5 w0.086: v5(174.63,59.76) 174.63,59.74 174.95,59.42 v4(174.97,59.42)
  BOTTOM w0.086: UC5.6 171.27,60.24 171.35,60.16 172.05,60.16 172.23,60.34 173.35,60.34 173.43,60.26 173.43,58.97 173.52,58.89 173.9,58.89 173.98,58.97 173.98,60.71 173.9,60.79 173.74,60.79 173.68,60.86 173.68,61.14 173.76,61.23 174.43,61.23 174.53,61.12 174.53,60.62 175.18,59.97 175.18,59.63 175.09,59.55 174.85,59.55 v5(174.63,59.76)
PCH_SPI_CLK_1_R: length 14.5
  BOTTOM w0.086: UC6.6 169.76,55.05 169.56,54.85 169.56,54.65 169.65,54.57 170.17,54.57 170.27,54.47 170.27,54.24 170.07,54.03 170.07,53.15 169.59,52.66 169.21,52.66 169.08,52.79 169.08,53.33 168.99,53.42 168.82,53.42 168.67,53.27 168.42,53.27 168.06,53.63 168.06,54.48 167.98,54.57 167.67,54.57 167.58,54.48 167.58,54.15 167.49,54.07 167.37,54.07 167.24,54.2 167.06,54.2 166.9,54.04 166.9,53.91 167.28,53.54 v1(167.28,53.32) 167.28,52.75 167.36,52.66 167.61,52.66 167.69,52.75 167.69,53.03 167.78,53.12 168,53.12 168.57,52.55 RC28.1 RC408.2
PCH_SPI_CLK_2_R: length 16.1
  BOTTOM w0.086: UZ12.19 167.38,44.94 166.86,45.46 166.73,45.46 166.37,45.83 v1(165.41,45.83) 165.07,45.83 164.97,45.92 164.97,46.17 165.06,46.26 165.77,46.26 165.85,46.34 165.85,46.52 165.77,46.6 165.06,46.6 164.97,46.69 164.97,46.86 165.06,46.95 165.77,46.95 165.85,47.03 165.85,47.21 165.77,47.29 165.06,47.29 164.97,47.38 164.97,47.59 164.85,47.72 164.17,47.72 164.08,47.8 164.08,48.01 164.17,48.09 165.19,48.09 165.25,48.03 165.25,47.82 165.34,47.74 166.03,47.74 166.13,47.83 166.13,48.09 166.04,48.18 165.75,48.18 165.46,48.47 RZ63.2 167.81,48.52 RZ60.2
PCH_SPI_CLK_R1: length 20
  TOP w0.086: v3(172.44,47.36) 173.14,47.36 173.43,47.07 JSPI1.14 ; v3(169.49,51.73) 169.49,52.09 v1(170.5,53.11) 173.22,55.83 173.82,55.83 174.54,56.55 RPC1.2
  GND1 w0.086: v3(169.49,51.73) v4(169.49,51.24) ; v4(171.95,46.9) 171.98,46.9 v3(172.44,47.36)
  IN1 w0.051: v4(171.95,46.9) 170.78,48.07 170.78,50.78 170.13,51.42 169.66,51.42 v4(169.49,51.24)
  GND5 w0.086: v5(169.38,50.68) 169.49,50.78 v4(169.49,51.24)
  BOTTOM w0.086: v5(169.38,50.68) 168.9,50.2 RZ60.1 168.57,50.3 RC408.1
PCH_SPI_CS#0: length 31.6
  TOP w0.086: JSPI1.11 173.73,48.57 173.47,48.83 171.95,48.83 171.53,48.41 RC36.2 v1(170.63,48.34) 169.29,48.34 169.13,48.5 v3(169.11,48.5)
  GND1 w0.086: v4(168.62,48.5) v3(169.11,48.5)
  IN1 w0.051: v4(168.62,48.5) 168.85,48.73 168.85,50.33 168.39,50.78 168.39,51.49 163.59,56.29 163.59,59.8 162.2,61.19 161.7,61.19 161.63,61.26 161.63,61.4 161.7,61.47 162.2,61.47 162.27,61.53 162.27,61.81 162.04,62.04 v4(160.54,62.04)
  GND5 w0.086: v5(160.01,61.65) 160.39,62.04 v4(160.54,62.04)
  BOTTOM w0.076: UC1.AU3 155.3,62.17 155.59,62.17 155.8,62.26 156,62.33 156.39,62.33 156.55,62.17 157.06,62.17 157.2,62.3 157.69,62.3 157.8,62.42 159.24,62.42 v5(160.01,61.65)
PCH_SPI_CS#0_R1: length 24
  TOP w0.086: RC36.1 173.43,48.34 173.7,48.07 JSPI1.12 176,48.07 v2(176.32,48.4)
  BOTTOM w0.086: v2(176.32,48.4) 176.4,48.47 176.4,49.06 176.07,49.39 175.74,49.39 175.45,49.09 175.08,49.09 174.77,49.4 174.77,50.18 176.92,52.33 182.38,52.33 182.47,52.42 182.47,56.08 v1(181.92,56.63) 181.47,57.08 181.47,58.06 180.28,59.24 RC37.1
PCH_SPI_CS#0_R2: length 4.1
  BOTTOM w0.086: RC37.2 180.26,61.18 v2(179.96,61.47) 179.57,61.86 179.57,62.59 178.86,63.3 UC5.1
PCH_SPI_CS#1: length 31.6
  TOP w0.086: JSPI1.19 173.38,44.57 173.35,44.61 172.02,44.61 RC32.2 170.96,44.12 v1(170.39,44.69) 169.71,45.37 169.71,46.59 168.17,48.14 v3(168.17,48.27)
  GND1 w0.086: v4(168.17,48.9) v3(168.17,48.27)
  IN1 w0.051: v4(160.54,61.45) 161.3,60.69 162.21,60.69 163.44,59.46 163.44,56.23 168.17,51.5 168.17,50.8 168.29,50.67 168.29,49.03 v4(168.17,48.9)
  GND5 w0.086: v5(160.01,61.27) 160.36,61.27 v4(160.54,61.45)
  BOTTOM w0.076: UC1.AU2 155.94,62.12 156.03,62.17 156.32,62.17 156.5,61.99 157.12,61.99 157.27,62.14 157.75,62.14 157.83,62.22 158.98,62.22 159.92,61.27 v5(160.01,61.27)
PCH_SPI_CS#1_R1: length 22.5
  TOP w0.086: JSPI1.20 173.13,44.07 173.08,44.12 RC32.1 172.44,43.29 v1(172.56,43.18) 173.28,43.18 173.78,43.67 174.67,43.67 175.01,44.01 175.01,45.66 176.75,47.41 176.75,51.44 176.09,52.1 176.09,55.53 v3(176.17,55.61)
  GND1 w0.086: v4(176.67,55.84) 176.4,55.84 176.29,55.73 176.28,55.73 v3(176.17,55.61)
  GND5 w0.086: v4(176.67,55.84) v5(177.21,55.84)
  BOTTOM w0.086: RC42.1 180.23,55.69 177.36,55.69 v5(177.21,55.84)
PCH_SPI_CS#1_R2: length 2.1
  BOTTOM w0.086: RC42.2 180.18,56.63 179.21,57.59 UC6.1
PCH_SPI_CS#2: length 43.2
  IN1 w0.051: v4(160.52,60.87) 161.63,59.75 162.15,59.75 163.29,58.61 163.29,56.16 167.96,51.49 167.96,50.78 168.11,50.63 168.11,49.77 167.78,49.44 167.78,49.28 167.73,49.23 167.2,49.23 167.15,49.28 167.15,50.07 167.1,50.12 167,50.12 166.95,50.07 166.95,49.28 166.9,49.23 166.79,49.23 166.74,49.28 166.74,50.17 166.69,50.22 166.59,50.22 166.54,50.17 166.54,49.76 166.49,49.71 166.22,49.71 166.17,49.66 166.17,49.56 166.22,49.51 166.49,49.51 166.54,49.46 166.54,49.28 166.49,49.23 166.24,49.23 166.18,49.18 166.18,49.08 166.24,49.03 167.73,49.03 167.78,48.98 167.78,48.88 167.73,48.82 166.24,48.82 166.18,48.77 166.18,48.67 166.24,48.62 167.73,48.62 167.78,48.57 167.78,48.47 167.73,48.42 166.22,48.42 166.17,48.37 166.17,48.27 166.22,48.22 168.3,48.22 169.98,46.53 169.98,46.45 169.85,46.32 169.76,46.32 168.91,47.17 168.83,47.17 168.77,47.1 168.7,47.1 168.62,47.18 168.62,47.25 168.69,47.32 168.69,47.39 168.62,47.46 168.55,47.46 168.42,47.33 168.34,47.33 168.27,47.4 168.27,47.47 168.4,47.6 168.4,47.68 168.28,47.8 v4(166.52,47.8)
  GND5 w0.086: v5(160.01,60.89) 160.06,60.84 160.49,60.84 v4(160.52,60.87) ; v4(166.52,47.8) 166.52,47.41 v5(166.32,47.21)
  BOTTOM w0.076: v5(160.01,60.89) 159.94,60.89 158.82,62.01 157.86,62.01 157.82,61.97 157.33,61.97 157.17,61.81 156.23,61.81 UC1.AU1
PCH_SPI_CS#2_R: length 2.5
  BOTTOM w0.086: RZ61.2 166.37,46.3 166.87,45.8 167.01,45.8 v1(167.19,45.63) 167.67,45.14 167.71,45.14 167.88,44.98 UZ12.20
PCH_SPI_D0: length 84.1
  TOP w0.086: v3(170.55,45.63) 170.98,45.2 RC33.2 171.53,45.26 172.03,45.75 173.63,45.75 173.81,45.57 JSPI1.17 ; RC10.2 165.75,90 v1(167.02,90) 171.53,90 172.54,88.99 172.54,84.82 174.29,83.07 174.29,76.9 171.14,73.75 171.14,67.55 170.35,66.77 170.35,60.69 170.87,60.16 170.87,56.68 168.87,54.67 164.69,54.67 v3(163.57,53.55)
  GND1 w0.086: v3(163.57,53.55) v4(163.06,53.55) ; v3(170.55,45.63) v4(171.04,45.63)
  IN1 w0.051: v4(171.04,45.63) 169.94,45.63 169.57,46 167.31,46 165.85,47.46 165.85,50.2 164.3,51.75 164.3,52.31 v4(163.06,53.55) 159.17,57.44 v4(159.17,59.7)
  GND5 w0.086: v5(158.92,59.24) 158.95,59.24 159.17,59.47 v4(159.17,59.7)
  BOTTOM w0.076: UC1.AV3 154.51,60.53 154.68,60.36 155.76,60.36 156.01,60.11 156.29,60.11 157.16,59.24 v5(158.92,59.24)
PCH_SPI_D0_0_R: length 13.1
  TOP w0.086: v3(174.51,58.95) 173.56,58.95 172.81,58.2 v1(172.81,57.84) 172.94,57.72 173.58,57.72 174.05,58.18 RPC1.8
  GND1 w0.086: v3(174.51,58.95) 174.69,58.77 v4(174.69,57.92)
  GND5 w0.086: v5(174.69,58.4) v4(174.69,57.92)
  BOTTOM w0.086: v5(174.69,58.4) 174.41,58.12 171.31,58.12 171.23,58.21 171.23,58.8 171.31,58.89 172.55,58.89 172.64,58.97 172.64,59.41 172.55,59.49 UC5.5
PCH_SPI_D0_1_R: length 13.7
  BOTTOM w0.086: UC6.5 171.33,53.72 174.58,53.72 174.64,53.65 174.64,53.32 174.55,53.23 173.13,53.23 172.92,53.02 172.1,53.02 172.05,52.97 172.05,52.77 171.97,52.69 171.65,52.69 171.57,52.76 171.57,52.92 171.47,53.02 170.36,53.02 170.27,52.93 170.27,52.67 170.36,52.59 170.98,52.59 171.29,52.28 171.29,50.94 171.23,50.87 170.89,50.87 170.83,50.94 170.83,52.03 170.76,52.1 RC409.2
PCH_SPI_D0_2_R: length 12.7
  BOTTOM w0.086: RZ59.2 v1(169.41,48.35) 168.11,48.35 167.84,48.07 167.01,48.07 166.9,47.95 166.9,47.7 166.98,47.61 167.43,47.61 167.53,47.51 167.53,47.29 167.44,47.2 166.98,47.2 166.89,47.12 166.89,46.94 166.98,46.86 167.44,46.86 167.53,46.77 167.53,46.6 167.44,46.51 166.98,46.51 166.89,46.43 166.89,46.25 166.98,46.17 167.44,46.17 167.53,46.08 167.53,45.79 167.61,45.7 167.83,45.7 168.06,45.94 168.74,45.94 168.88,45.81 168.88,45.64 168.79,45.55 168.44,45.55 168.39,45.6 168.17,45.6 167.97,45.4 167.97,45.28 168.05,45.2 168.22,45.2 168.38,45.04 UZ12.21
PCH_SPI_D0_R1: length 28.1
  TOP w0.086: JSPI1.18 173.6,45.07 173.47,45.2 v3(173.08,45.2) RC33.1 ; RPC1.1 174.05,56.54 173.68,56.17 173.08,56.17 v1(168.99,52.08) 168.7,51.79 v3(168.7,51.55)
  GND1 w0.086: v3(173.08,45.2) 173.08,45.64 v4(172.89,45.83) ; v4(168.7,52.03) v3(168.7,51.55)
  IN1 w0.051: v4(172.89,45.83) 172.24,45.83 169.18,48.89 169.18,50.58 169.08,50.68 169.08,51.65 v4(168.7,52.03)
  GND5 w0.086: v4(172.89,45.83) 172.51,45.83 172.49,45.81 v5(172.4,45.81)
  BOTTOM w0.086: v5(172.4,45.81) 171.59,45.81 171.33,46.07 171.33,46.07 171.15,46.25 170.46,46.25 170.08,46.63 170.08,48.58 170.22,48.73 170.73,48.73 170.86,48.85 170.86,49.69 RZ59.1 RC409.1
PCH_SPI_D1: length 31.4
  TOP w0.086: v3(171.02,46.48) 171.34,46.48 RC34.2 171.53,46.34 171.99,46.8 173.12,46.8 173.34,46.57 JSPI1.15
  GND1 w0.086: v4(170.68,46.14) 170.68,46.17 170.98,46.48 v3(171.02,46.48) ; v4(160.52,59.7) v3(160.52,59.22)
  IN1 w0.051: v4(160.52,59.7) 160.52,59.2 162.81,56.91 162.81,56 165.04,53.76 165.04,52.22 165.4,51.86 165.4,50.87 166.02,50.25 166.02,47.52 166.46,47.08 167.69,47.08 168.62,46.15 169.63,46.15 169.71,46.07 170.62,46.07 v4(170.68,46.14)
  GND5 w0.086: v4(160.52,59.7) 160.11,59.87 v5(160.09,59.93)
  BOTTOM w0.076: UC1.AW3 155.13,60.92 156.32,60.92 156.54,60.7 156.87,60.7 157.11,60.95 157.72,61.55 158.53,61.55 159.39,60.7 159.39,60.63 160.03,59.98 160.04,59.98 v5(160.09,59.93)
PCH_SPI_D1_0_R: length 13
  TOP w0.086: v3(176.65,58.48) 176.29,58.84 175.38,58.84 175.04,58.5 RPC1.6
  GND1 w0.086: v3(176.65,58.48) 176.65,58.11 v4(176.31,57.76)
  GND5 w0.086: v5(176.17,58.23) 176.31,58.09 v4(176.31,57.76)
  BOTTOM w0.086: UC5.2 177.57,62.03 177.48,62.12 177.48,62.99 177.4,63.08 176.11,63.08 175.48,62.44 175.48,60.76 175.59,60.65 176.43,60.65 176.54,60.53 176.54,58.6 v5(176.17,58.23)
PCH_SPI_D1_1_R: length 13.1
  TOP w0.086: v3(175.4,56.14) 175.43,56.12 RC410.2
  GND1 w0.086: v4(175.61,56.75) 175.4,56.55 v3(175.4,56.14)
  GND5 w0.086: v4(175.61,56.75) 175.86,57.01 v5(176.24,57.01)
  BOTTOM w0.086: UC6.2 177.67,56.32 177.56,56.42 177.56,57.29 177.49,57.36 177.13,57.36 177.08,57.31 177.08,56.41 176.9,56.23 176.9,55.46 176.99,55.37 177.38,55.37 177.46,55.29 177.46,54.87 177.38,54.78 176.99,54.78 176.9,54.69 176.9,53.68 176.82,53.59 176.52,53.59 176.43,53.68 176.43,56.43 176.55,56.55 176.55,56.83 176.37,57.01 v5(176.24,57.01)
PCH_SPI_D1_2_R: length 12.7
  BOTTOM w0.086: RZ58.2 172.56,44.28 172.11,44.74 171.88,44.74 171.8,44.65 171.8,44.23 171.92,44.1 171.92,43.8 171.8,43.67 171.8,43.11 171.7,43.01 171.44,43.01 171.33,43.12 171.33,45.77 171.24,45.86 170.93,45.86 170.86,45.78 170.86,44.16 170.77,44.08 170.49,44.08 170.43,44.14 170.43,45.86 170.35,45.93 169.97,45.93 169.88,45.84 UZ12.24
PCH_SPI_D1_R1: length 20.8
  TOP w0.086: RC34.1 v3(173.08,46.28) 173.29,46.07 JSPI1.16 ; RPC1.3 175.04,56.57 174.51,56.04 RC410.1 174.51,55.56 174.42,55.47 173.34,55.47 v1(172.6,54.73) 170.04,52.17 170.04,51.12 v3(170.05,51.11)
  GND1 w0.086: v4(170.05,50.63) v3(170.05,51.11) ; v3(173.08,46.28) v4(172.48,46.28)
  IN1 w0.051: v4(172.48,46.28) 172,46.28 170.27,48.01 170.27,50.4 v4(170.05,50.63)
  GND5 w0.086: v5(172.97,46.32) 172.89,46.32 172.85,46.28 v4(172.48,46.28)
  BOTTOM w0.086: RZ58.1 173.47,43.95 172.89,44.54 172.89,46.24 v5(172.97,46.32)
PCH_SPI_D2: length 27.6
  TOP w0.086: v2(167.3,50.48) 167.33,50.5 169.56,50.5 170.39,49.68 v1(170.62,49.68) 170.67,49.68 171.05,49.29 RC38.2 171.53,49.35 171.95,49.77 173.61,49.77 173.81,49.57 JSPI1.9
  IN1 w0.051: v2(167.3,50.48) 167.57,50.75 167.57,50.96 167.16,51.37 166.69,51.37 165.35,52.71 165.35,53.89 163.11,56.13 163.11,57.04 162.45,57.7 162.45,58.78 v4(162.31,58.93)
  GND5 w0.086: v5(161.68,59.11) 161.87,58.93 v4(162.31,58.93)
  BOTTOM w0.076: 159.12,60.41 159.12,60.68 158.51,61.29 157.69,61.29 157.23,60.83 156.91,60.51 156.48,60.51 156.24,60.75 155.61,60.75 UC1.AW2
  BOTTOM w0.086: 159.12,60.41 160.9,58.63 RC11.2 161.68,59.09 v5(161.68,59.11)
PCH_SPI_D2_0_R: length 15
  BOTTOM w0.086: RC39.2 179.67,58.99 179.67,59.8 179.39,60.08 177.58,60.08 177.38,59.88 177.38,58.47 177.26,58.35 176.97,58.35 176.85,58.47 176.85,60.69 176.65,60.89 176.21,60.89 176,61.1 176,62.44 176.09,62.53 176.82,62.53 176.88,62.47 176.88,62.18 176.81,62.1 176.65,62.1 176.58,62.03 176.58,61.78 177.22,61.14 177.22,61.08 177.54,60.76 UC5.3
PCH_SPI_D2_1_R: length 12.8
  BOTTOM w0.086: UC6.3 179.54,55.05 179.74,54.84 179.74,53.6 179.95,53.4 180.76,53.4 180.87,53.3 v6(180.87,53.08) 180.87,52.8 180.95,52.71 181.24,52.71 181.32,52.8 181.32,53.31 181.41,53.4 181.67,53.4 181.75,53.31 181.75,52.61 181.82,52.55 182.15,52.55 182.25,52.65 182.25,53.73 182.17,53.82 180.32,53.82 180.2,53.93 180.2,55.12 180.28,55.2 180.65,55.2 180.74,55.12 RC43.2
PCH_SPI_D2_R1: length 25.9
  TOP w0.086: RC30.1 178.48,56.6 178.08,56.99 177.14,56.99 v3(177.08,57.05) ; RC38.1 173.31,49.29 173.53,49.07 JSPI1.10 174.75,49.07 174.97,48.85 175.89,48.85 v2(175.94,48.9)
  GND1 w0.086: v3(177.08,57.05) 176.67,56.65 176.67,56.48 v4(176.65,56.48)
  GND5 w0.086: v4(176.65,56.48) 176.51,56.63 v5(176.17,56.63)
  BOTTOM w0.086: RC43.1 181.65,55.2 v1(181.42,55.44) 180.98,55.88 180.98,57.37 180.86,57.49 RC39.1 180.05,57.49 179.44,58.1 176.88,58.1 175.92,57.14 175.92,56.87 v5(176.17,56.63) 176.22,56.57 176.22,51.98 174.46,50.22 174.46,49.36 174.95,48.88 175.91,48.88 v2(175.94,48.9)
PCH_SPI_D3: length 27.7
  TOP w0.086: v3(167.38,51.38) 167.93,50.83 169.56,50.83 170.15,50.25 RC40.2 171.54,50.34 171.96,50.76 173.19,50.76 173.38,50.57 JSPI1.7
  GND1 w0.086: v3(167.38,51.38) v4(166.99,50.99)
  IN1 w0.051: v4(166.99,50.99) 166.94,51.04 166.44,51.04 165.19,52.28 165.19,53.83 162.96,56.06 162.96,56.98 161,58.94 161,59.83 v4(160.54,60.28)
  GND5 w0.086: v4(160.54,60.28) 160.37,60.28 160.14,60.51 v5(159.98,60.51)
  BOTTOM w0.076: v5(159.98,60.51) 159.86,60.51 158.57,61.81 157.4,61.81 157.22,61.63 154.46,61.63 UC1.AU4
PCH_SPI_D3_0_R: length 14.7
  TOP w0.086: RPC1.5 175.54,57.98 175.94,57.59 v3(175.94,57.31)
  GND1 w0.086: v4(175.3,57.26) 175.86,57.26 175.91,57.31 v3(175.94,57.31)
  GND5 w0.086: v4(175.3,57.26) 175,56.96 175,56.9 v5(174.97,56.88)
  BOTTOM w0.086: v5(174.97,56.88) 175.18,57.08 175.18,58.76 175.52,59.1 175.52,60.12 174.94,60.69 174.94,62.4 174.86,62.49 174.55,62.49 174.46,62.57 174.46,63.12 174.37,63.2 173.95,63.2 173.87,63.12 173.87,62.57 173.78,62.49 173.36,62.49 173.27,62.57 173.27,63.12 173.18,63.2 172.76,63.2 172.68,63.12 172.68,62.57 172.59,62.49 172.36,62.49 171.91,62.03 UC5.7
PCH_SPI_D3_1_R: length 14.7
  BOTTOM w0.086: UC6.7 172.78,56.32 173.17,55.92 174.76,55.92 174.85,55.84 174.85,55.42 174.76,55.33 173.23,55.33 173.14,55.24 173.14,54.91 173.23,54.82 173.72,54.82 173.8,54.74 173.8,54.34 173.71,54.25 172.8,54.25 172.7,54.34 172.7,55.39 172.46,55.64 169.87,55.64 v1(169.23,55) 168.62,54.39 RC407.2
PCH_SPI_D3_R1: length 23.3
  TOP w0.086: RC316.1 RC31.1 ; RC31.1 176.27,56.98 175.73,56.98 RPC1.4 175.54,57.53 175.28,57.79 173.96,57.79 172.74,56.57 172.74,56.43 v1(171.22,54.91) v2(169.61,53.3) ; RC31.1 176.05,56.55 175.86,56.36 175.86,49.64 175.46,49.23 175.01,49.23 174.9,49.35 174.9,49.69 174.51,50.07 JSPI1.8 173.45,50.07 173.27,50.25 RC40.1
  BOTTOM w0.086: RC407.1 169.61,53.99 v2(169.61,53.3)
PCH_SPI_DO2_XDP: length 279.7
  TOP w0.086: v3(51.53,89.11) v6(52.05,88.6) 52.47,88.17 56.27,88.17 57.33,89.24 58.57,89.24 58.77,89.05 JXDP1.60 ; v3(160.44,56.6) 160.44,53.15 159.62,52.32 159.62,48.28 159.1,47.76 159.1,44.42 162.29,41.23 162.29,39.98 155.73,33.43 154.11,33.43 150.81,30.13 147.49,30.13 145.56,28.2 139.68,28.2 138.88,29 133.43,29 130.86,26.44 111.74,26.44 107.92,30.26 82.1,30.26 v2(80.83,31.53)
  GND1 w0.086: v3(51.53,89.11) 51.08,89.56 v4(50.88,89.56) ; v3(160.44,56.6) v4(160.95,56.6)
  IN2 w0.061: v4(50.88,89.56) 49.55,89.56 48.99,90.13 48.03,90.13 47.28,89.38 45.37,89.38 43.32,87.33 40.17,87.33 38.34,85.5 36.44,85.5 34.84,83.91 29.89,83.91 29.4,83.42 27.59,83.42 21.83,77.66 21.03,77.66 19.98,76.61 19.98,74.64 19.98,74.64 19.98,72.65 16.91,69.58 16.91,64.44 17.28,64.07 17.28,58.15 16.91,57.77 16.91,55.56 15.7,54.35 15.7,53.74 14.83,52.86 14.83,48.21 17.06,45.98 17.06,33.37 19.92,30.51 19.92,26.9 20.86,25.95 24.33,25.95 v4(24.86,25.42) ; v4(64.23,33) 64.33,33 64.89,33.56 66.15,33.56 68.03,31.69 70.18,31.69 70.46,31.4 80.7,31.4 v2(80.83,31.53)
  IN3 w0.061: v4(24.86,25.42) 25.84,26.4 27.96,26.4 28.31,26.76 28.31,28.53 29.58,29.8 34.66,29.8 37.49,32.63 50.97,32.63 51.95,31.65 58.2,31.65 58.75,32.2 63.52,32.2 64.23,32.9 v4(64.23,33)
  GND5 w0.086: v5(160.95,57.39) v4(160.95,56.6)
  BOTTOM w0.086: v5(160.95,57.39) 160.98,57.39 162.14,58.55 RC11.1
PCH_SPI_DO_XDP: length 123.1
  TOP w0.086: v3(165.99,90.8) 165.19,91.6 RC10.1
  GND1 w0.086: v3(165.99,90.8) 165.68,90.48 v4(165.24,90.48)
  IN3 w0.061: v4(59.73,90.64) 59.73,91.22 60.01,91.5 60.67,91.5 60.92,91.26 65.19,91.26 66.13,92.2 72.84,92.2 73.31,91.74 76.36,91.74 77.28,90.81 81.29,90.81 82.42,91.95 85.39,91.95 87,90.34 88.04,90.34 88.79,89.59 102.76,89.59 104.24,91.07 105.41,91.07 106.6,92.26 108.39,92.26 109,91.65 115.22,91.65 115.52,91.96 115.68,91.96 115.68,91.96 122.27,91.96 124.62,94.31 128.81,94.31 129.65,94.31 130.68,93.29 130.68,92.59 133.37,89.89 136.16,89.89 137.16,90.89 137.16,93.51 138.29,94.64 143.97,94.64 148.5,90.12 154.53,90.12 155.39,90.98 164.75,90.98 v4(165.24,90.48)
  GND5 w0.086: v4(59.73,90.64) 59.66,90.64 59.34,90.95 v5(59.34,91.1)
  BOTTOM w0.086: v5(59.34,91.1) RC128.1
PCH_TBT_PERST#: length 256.1
  TOP w0.086: v2(158.66,70.32) 159.31,69.67 v1(159.33,69.67) 159.54,69.47 RC558.1 RC557.1 ; v3(180.57,39.82) 180.79,39.61 181.53,39.61 183.07,38.06 183.07,35.67 183.5,35.25 184.36,35.25 185.46,34.15 185.46,32.83 187.21,31.07 191,31.07 191.29,30.78 191.29,30.12 192.63,28.79 192.63,26.39 v2(192.22,25.98) ; v2(19.7,21.75) 20.65,21.75 RT420.2
  GND1 w0.086: v3(180.57,39.82) 180.57,40.23 v4(180.65,40.3)
  IN2 w0.061: v2(158.66,70.32) 159.07,70.32 160.83,68.56 160.83,68.27 161.41,67.69 162.11,67.69 163.55,66.25 163.55,60.58 163.74,60.39 163.74,56.53 165.98,54.28 170.28,54.28 173.65,50.92 173.65,50.25 174.48,49.42 175.09,48.81 175.09,45.12 178.82,41.39 179.56,41.39 v4(180.65,40.3) ; v2(192.22,25.98) 191.81,25.57 179.28,25.57 178.64,24.94 159.95,24.94 158,26.89 156.85,26.89 154.66,29.07 145.48,29.07 145,28.59 127.16,28.59 126.08,27.51 106.98,27.51 106.36,27.51 104.74,29.13 37.51,29.13 33.83,25.45 30.96,25.45 28.33,22.82 20.16,22.82 19.7,22.36 v2(19.7,21.75)
  BOTTOM w0.086: UC1.AB1 158.2,69.86 v2(158.66,70.32) ; RT444.1 22.52,21.75 v2(19.7,21.75)
PCI_CLK_LPC1: length 16.3
  BOTTOM w0.076: 152.22,57.55 151.53,58.24 151.53,58.63 151.49,58.85 151.36,58.97 151.25,59.01 151.1,59.04 150.99,59.18 150.96,59.29 150.96,59.41 151.03,59.62 151.13,59.73 151.24,59.84 UC1.AY9
  BOTTOM w0.086: RC22.1 163.24,54.36 163.24,54.82 162.98,55.08 161.83,55.08 v1(161.37,55.53) 161.21,55.69 154.08,55.69 152.22,57.55
