# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_PTX_DRX_P1: length 189
  TOP w0.088: v2(273.1,68.31) 273.36,68.56 275.49,68.56 CI16.2
  IN1 w0.062: v4(214.82,46) 214.72,46.1 214.03,46.1 211.94,44.01 198.51,44.01 197.91,44.61 191.86,44.61 191.32,45.15 187.5,45.15 177.99,54.66 177.99,59.62 174.47,63.14 174.47,68.39 172.81,70.05 172.55,70.05 159.03,83.58 156.32,83.58 155.3,84.6 151.82,84.6 151.48,84.94 151.48,85.39 v4(151.28,85.59)
  IN4 w0.062: v2(273.1,68.31) 272.83,68.58 272.66,68.58 272.5,68.74 272.5,69.84 274.11,71.45 274.11,72.4 272.94,73.57 272.63,73.57 270.83,75.37 270.83,76.41 267.91,79.34 264.63,79.34 264.26,79.7 247.48,79.7 242.98,75.2 242.98,67.23 242.16,66.41 238.1,66.41 237.42,65.73 236.96,65.73 236.71,65.49 235.93,65.49 235.19,64.75 235.19,64.4 232.45,61.66 232.45,59.27 231.51,58.33 231.51,55.89 230.64,55.02 229.81,55.02 228.47,53.68 227.81,53.68 219.71,45.59 215.78,45.59 215.15,46.21 215.03,46.21 v4(214.82,46)
  GND5 w0.081: v5(151.38,85.12) 151.48,85.22 151.48,85.38 v4(151.28,85.59)
  BOTTOM w0.076: v5(151.38,85.12) 151.44,85.06 arc(151.47,85) 151.49,84.94 arc(151.48,84.91) 151.46,84.88 149.67,83.09 arc(149.43,82.79) 149.24,82.46 149.17,82.29 149.1,82.12 arc(149.08,82.08) 149.06,82.04 arc(148.97,81.91) 148.85,81.8 148.75,81.73 arc(148.58,81.49) 148.57,81.2 arc(148.6,81.04) 148.59,80.87 arc(148.58,80.68) 148.61,80.49 arc(148.62,80.36) 148.6,80.24 arc(148.55,80.07) 148.54,79.89 arc(148.6,79.72) 148.75,79.61 arc(148.9,79.52) UC1.D13
USB3_PTX_DRX_P2: length 119.6
  GND1 w0.088: v3(228.95,57.38) 228.64,57.38 228.56,57.3 228.56,56.64 v4(228.76,56.43)
  IN4 w0.062: v4(228.76,56.43) 228.57,56.24 228.57,55.69 227.93,55.05 227.68,55.05 222.35,49.72 218.64,49.72 218.13,49.21 215,49.21 210.89,45.09 188.41,45.09 186.91,46.59 186.91,49.05 181.92,54.05 181.92,57.38 180.59,58.7 180.59,59.84 179.22,61.21 179.22,62.99 178.27,63.94 178.27,64.78 176.7,66.35 176.7,71.89 172.64,75.95 172.64,79.04 171.98,79.7 171.98,81.72 169.9,83.8 165.86,83.8 164.1,85.56 152.46,85.56 152.29,85.72 v4(152.29,86.45)
  GND5 w0.081: v4(152.29,86.45) 152.51,86.22 152.51,86.15 152.51,86.14 152.51,86.11 v5(152.39,85.99)
  BOTTOM w0.076: UC1.A13 arc(149.01,81.12) 149.2,81.05 arc(149.23,81.06) 149.25,81.07 arc(149.51,81.33) 149.63,81.67 arc(149.87,82.47) 150.36,83.14 151.99,84.77 152.46,85.24 arc(152.53,85.35) 152.55,85.47 152.55,85.61 arc(152.54,85.65) 152.51,85.67 arc(152.49,85.68) 152.46,85.68 arc(152.41,85.7) 152.37,85.73 arc(152.35,85.77) 152.35,85.81 arc(152.38,85.9) v5(152.39,85.99)
USB3_PTX_DRX_P3: length 205.8
  IN2 w0.083: v2(21.76,27.39) 21.86,27.49 21.86,30.14 21.15,30.85 21.15,35.79 20,36.94 20,39.51 19.18,40.33 19.18,41 18.47,41.71 18.47,49.7 18.15,50.02 18.15,54.47 18.23,54.55 18.23,57.21 18.94,57.92 18.94,69.66 21.3,72.02 21.3,74.09 22.6,75.4 22.6,76.31 23.26,76.97 25.04,76.97 27.29,79.22 31,79.22 35.51,83.73 39.45,83.73 39.78,84.07 46.9,84.07 49.01,86.18 56.62,86.18 57.16,86.72 57.16,87.18 58.59,88.6 61.82,88.6 63.59,90.38 85.69,90.38 87.76,88.31 92.51,88.31 96.88,92.68 113.85,92.68 114.83,91.69 123.6,91.69 126.6,88.69 142.26,88.69 143.32,89.75 145.66,89.75 145.92,89.49 v4(145.92,88.73)
  GND5 w0.088: v5(145.84,88.02) 145.71,88.15 145.71,88.52 v4(145.92,88.73)
  BOTTOM w0.076: UC1.A15 147.65,81.33 147.64,81.71 147.64,82.07 arc(147.69,82.31) 147.82,82.52 148.97,83.66 arc(149.25,84.08) 149.35,84.57 149.35,84.66 149.36,84.66 149.36,84.68
  BOTTOM w0.088: 149.36,84.68 149.36,86.52 148.58,87.29 145.88,87.29 145.74,87.44 145.74,87.63 145.83,87.72 146.17,87.72 146.25,87.79 146.25,87.93 146.16,88.02 v5(145.84,88.02) ; v2(21.76,27.39) 21.99,27.16 21.99,25.74 v7(20.98,24.74) 20.02,23.77 19.38,23.77 19.34,23.73 19.1,23.73 19.01,23.81 19.01,24.07 18.86,24.22 CI4.2
USB3_PTX_DRX_P4: length 202
  TOP w0.088: v2(276.6,65.03) 276.37,64.8 276.37,64.6 273.65,61.88 273.65,60.33 273.74,60.24 274.02,60.24 274.11,60.33 CR31.1
  IN1 w0.062: v4(150.87,86.67) 150.87,86.38 150.81,86.32 150.64,86.32 150.59,86.27 150.59,85.18 151.54,84.23 155.14,84.23 156.16,83.21 158.84,83.21 172.39,69.66 172.68,69.66 174.11,68.23 174.11,62.94 177.58,59.46 177.58,54.12 186.94,44.76 191.19,44.76 191.72,44.23 197.71,44.23 198.29,43.65 198.35,43.65 198.36,43.64 214.78,43.64 215.97,44.83 215.97,46.97 216.93,47.93 218.74,47.93 218.78,47.97 218.78,48.16 218.72,48.22 218.43,48.22 218.36,48.29 v4(218.36,48.55)
  IN4 w0.062: v4(218.36,48.55) 218.52,48.71 218.52,49.04 218.83,49.35 222.51,49.35 227.59,54.43 228.12,54.43 229.54,55.86 229.54,57.45 231.8,59.7 231.8,62.63 235.31,66.14 236.44,66.14 236.69,66.39 237.15,66.39 237.82,67.06 240.94,67.06 242.33,68.45 242.33,75.52 247.17,80.37 248.55,80.37 248.99,80.81 264.11,80.81 264.88,80.04 268.18,80.04 271.22,76.99 271.55,76.99 274.89,73.65 274.89,68.34 275.93,67.3 275.93,66.41 276.6,65.75 v2(276.6,65.03)
  GND5 w0.081: v4(150.87,86.67) 150.68,86.48 150.68,85.98 v5(150.79,85.86)
  BOTTOM w0.076: 149.85,83.95 149.83,83.94 149.83,83.94 148.46,82.57 148.15,82.27 arc(148.11,82.19) 148.09,82.11 148.09,81.33 arc(148.08,81.25) 148.07,81.17 arc(148.04,81) 148.06,80.83 arc(148.08,80.67) 148.06,80.51 arc(148.04,80.35) 148.07,80.19 148.1,80.06 arc(148.09,79.84) 147.95,79.67 arc(147.92,79.65) 147.9,79.64 arc(147.85,79.61) 147.81,79.59 147.8,79.59 arc(147.7,79.51) UC1.D15
  BOTTOM w0.088: 149.85,83.95 150.15,84.25 arc(150.55,84.85) 150.69,85.56 150.69,85.61 arc(150.72,85.75) v5(150.79,85.86)
USB20_N1: length 164.2
  IN1 w0.062: v4(45.54,60.42) 45.54,60.42 45.66,60.31 45.86,60.31 45.93,60.38 45.93,61.71 45.07,62.57 45.07,70.7 53.4,79.03 58.01,79.03 59.04,80.06 68.16,80.06 69.92,81.82 94.09,81.82 95.63,83.36 109.07,83.36 111.69,80.74 111.69,80.23 112.68,79.25 115.14,79.25 116.05,78.33 117.03,78.33 117.43,78.74 119.28,78.74 119.54,78.48 119.54,78.07 120.4,77.22 140.87,77.22 142.25,75.84 142.25,75.28 143.32,74.21 143.32,72.52 142.99,72.19 142.99,71.19 143.16,71.02 143.97,71.02 144.2,70.79 146.13,70.79 146.94,69.98 148.67,69.98 148.93,70.23 151.36,70.23 151.5,70.09 151.5,69.94 v2(151.76,69.69)
  IN2 w0.083: v4(45.54,60.42) 45.32,60.2 44.99,60.2 44,59.21 44,54.84 42.8,53.63 42.8,48.7 42.3,48.2 41.78,48.2 38.65,45.08 36.29,45.08 33.93,47.44 32.73,47.44 31.99,48.17 29.39,48.17 28.88,48.69 28.67,48.69 v4(28.47,48.89)
  GND5 w0.088: v5(27.93,48.98) 28.14,48.78 28.38,48.78 28.47,48.86 v4(28.47,48.89)
  BOTTOM w0.086: UC1.AB9 v2(151.76,69.69)
USB20_N2: length 202.5
  TOP w0.088: v2(29.62,27.17) 29.42,27.38 29.05,27.38 28.64,26.97 28.64,26.91 28.22,26.49 28.16,26.49 28.09,26.41 27.67,26.41 27.5,26.25 LI3.1
  IN1 w0.062: v4(40.36,34.67) 40.55,34.47 40.55,34.39 40.35,34.18 40.35,34.09 40.48,33.95 40.61,33.95 40.94,34.28 40.94,36.31 42.1,37.47 42.1,40.1 43.9,41.9 43.9,42.52 43.74,42.69 43.61,42.69 43.5,42.58 43.5,42.43 43.32,42.25 v4(43.21,42.25) ; v4(111.01,78.69) 111.19,78.87 111.66,78.87 111.98,78.55 114.89,78.55 116.15,77.3 119.19,77.3 119.94,76.55 140.39,76.55 140.61,76.33 140.61,75.44 141.33,74.73 141.33,70.84 142.42,69.74 144.35,69.74 144.61,70.01 145.92,70.01 146.91,69.02 146.91,68.62 147.57,67.96 153.29,67.96 153.48,68.15 153.48,68.54 v2(153.58,68.64)
  IN4 w0.062: v4(40.36,34.67) 40.36,34.31 40.47,34.2 40.47,33.96 39.8,33.29 39.09,33.29 35.23,29.43 32.31,29.43 30.46,27.58 30.46,27.3 30.34,27.17 v2(29.62,27.17) ; v4(43.21,42.25) 43.17,42.29 42.64,42.29 42.48,42.46 40.23,42.46 39.18,43.51 39.18,45.87 40.91,47.6 42.61,47.6 42.98,47.97 42.98,53.83 44.6,55.45 44.6,60.85 44.45,60.99 44.45,71.37 50.86,77.77 55.74,77.77 62.02,84.05 64.38,84.05 65.75,85.42 72.19,85.42 73.98,87.2 77.06,87.2 78.57,85.69 78.57,85.07 79.23,84.41 92.82,84.41 94.58,86.17 111.93,86.17 113.17,84.93 113.17,82.52 111.95,81.3 111.95,78.9 111.72,78.67 111.03,78.67 v4(111.01,78.69)
  BOTTOM w0.076: UC1.AD6 153.64,68.84 153.64,68.69 v2(153.58,68.64)
USB20_N2_R: length 18.1
  TOP w0.088: v2(19.91,24.36) 19.7,24.57 19.7,24.81 19.79,24.9 v7(20.72,24.9) 21.68,24.9 22.04,24.55 22.04,24.39 22.65,23.78 DI2.3 22.8,24.57 22.89,24.66 23.39,24.66 24.38,25.65 24.45,25.65 25.22,26.41 25.4,26.41 25.57,26.25 LI3.2
  IN2 w0.083: JUSB2.2 13.14,25.6 13.38,25.36 13.38,24.98 13.54,24.82 15.35,24.82 15.51,24.98 19.47,24.98 19.71,24.75 19.71,24.57 v2(19.91,24.36)
USB20_N3: length 167.7
  GND1 w0.088: v3(24.99,72.09) 25.29,72.4 v4(25.57,72.4)
  IN3 w0.083: v4(154.12,66.54) 154.39,66.81 154.39,66.93 154.07,67.24 154.07,67.85 154.37,68.16 155.34,68.16 155.76,68.58 155.76,72.58 157.95,74.76 157.95,75.19 159.27,76.51 159.67,76.51 160.39,77.23 160.39,80.08 157.4,83.07 150.51,83.07 149.7,83.88 146.72,83.88 146.03,84.56 142.42,84.56 141.9,84.04 139.68,84.04 139.4,84.33 130.26,84.33 128.68,85.9 124.82,85.9 124.65,86.08 105.55,86.08 103.82,84.35 78.78,84.35 77.07,86.06 67.02,86.06 65.65,84.69 61.51,84.69 61.2,84.38 61.19,84.38 59.33,82.52 44.75,82.52 42.22,79.99 41.64,79.99 v4(41.44,79.79)
  IN4 w0.062: v4(25.57,72.4) 25.57,72.44 25.81,72.68 25.97,72.68 26.12,72.83 26.12,73.55 25.49,74.19 25.49,77.33 27.21,79.05 31.72,79.05 33.07,80.41 39.17,80.41 39.53,80.06 41.18,80.06 v4(41.44,79.79)
  GND5 w0.086: v4(154.12,66.54) 154.12,66.48 154.43,66.18 v5(154.45,66.18)
  BOTTOM w0.088: v5(154.45,66.18) 154.45,66.23 154.51,66.29 UC1.AH3
USB20_N4: length 169
  TOP w0.088: RI48.1 226.39,86.63 LI8.4 226.1,86.78 225.89,86.98 225.73,86.98 v3(225.61,86.86)
  GND1 w0.088: v4(226.1,86.76) 225.87,86.99 225.74,86.99 v3(225.61,86.86)
  IN1 w0.062: v4(226.1,86.76) 226.31,86.98 226.56,86.98 226.64,86.9 226.64,80.98 227.78,79.84 228.84,79.84 229.48,79.19 229.48,77.55 229.94,77.1 229.94,72.93 227.89,70.88 227.89,68.71 231.31,65.29 231.31,64.68 231.61,64.37 231.66,64.33 235.19,64.33 235.85,63.66 236.7,63.66 237.23,64.2 238.64,64.2 238.76,64.08 238.76,63.88 238.64,63.76 238.46,63.76 238.34,63.64 v4(238.34,63.42)
  IN4 w0.062: v4(238.34,63.42) 238.34,63.16 238.4,63.1 238.67,63.1 238.76,63.01 238.76,62.69 238.89,62.56 238.89,60.19 236.88,58.19 236.88,52.6 231.06,46.78 230.46,46.78 219,35.33 217.78,35.33 217.16,34.71 209.62,34.71 209.08,34.17 205.99,34.17 202.81,37.35 196.46,37.35 195.03,35.91 188.3,35.91 185.51,38.71 184.92,38.71 183.86,39.77 183.86,43.13 182.36,44.64 181.29,44.64 176.27,49.66 176.27,53.83 173.75,56.35 173.75,61.5 173.11,62.14 173.11,62.74 171.62,64.23 171.62,64.64 167.75,68.52 164.09,68.52 163.34,69.27 161.41,69.27 160.86,69.83 156.86,69.83 155.14,68.11 151.42,68.11 151.35,68.18 151.35,68.29 151.68,68.62 v2(151.76,68.62)
  BOTTOM w0.076: UC1.AD9 151.61,68.84 v2(151.76,68.62)
USB20_N4_L: length 3.3
  TOP w0.088: v2(228.61,86.79) 228.42,86.98 227.81,86.98 227.61,86.78 LI8.3 227.32,86.61 RI48.2
  BOTTOM w0.088: v2(228.61,86.79) 228.84,87.02 228.95,87.02 229.14,86.83 229.35,86.83 229.53,86.65 JNGFF2.9
USB20_N5: length 97.8
  IN4 w0.062: v2(157.14,65.29) 157.24,65.39 157.24,66.1 158.25,67.11 160.88,67.11 161.34,66.65 161.95,66.65 162.22,66.38 162.22,64.6 164.72,62.1 168.94,62.1 171.34,59.7 171.34,54.72 173.65,52.41 173.65,48.94 177.21,45.39 177.21,43.78 179.64,41.35 179.64,39.75 180.12,39.28 181.23,39.28 186.13,34.38 195.83,34.38 196.32,34.88 197.82,34.88 198.95,33.74 204.03,33.74 205.2,32.57 209.72,32.57 210.25,33.11 218,33.11 218.56,33.66 221.74,33.66 223.99,35.91 225.23,35.91 225.42,35.73 225.42,35.03 v4(225.43,35.02)
  GND5 w0.076: v4(225.43,35.02) 225.21,34.8 225.21,34.71 v5(225.44,34.48)
  BOTTOM w0.076: v2(157.14,65.29) 157.26,65.29 157.4,65.42 157.4,65.7 157.3,65.79 156.45,65.79 156.14,65.48 156.03,65.48 155.82,65.7 155.82,65.8 155.89,65.88 UC1.AJ1
USB20_N5_R: length 3
  BOTTOM w0.088: JEDP1.7 225.25,37.8 225.11,37.66 225.11,37.41 225.23,37.29 225.23,37.02 225.28,36.98 225.28,36.39 225.23,36.35 225.23,36.03 225.44,35.83 LZ1.2
USB20_N6: length 190.8
  TOP w0.088: RR21.1 275.98,52.22 275.98,51.83 275.79,51.65 275.34,51.65 274.52,52.47 274.22,52.47 274.13,52.38 274.13,52.26 v2(274.38,52.02)
  IN4 w0.062: v2(152.98,67.55) 152.95,67.55 152.72,67.32 152.72,67.23 152.82,67.13 154.99,67.13 156.08,66.05 156.08,65 156.87,64.21 157.64,64.21 157.94,63.91 161.49,63.91 164.07,61.32 168.85,61.32 170.83,59.35 170.83,54.47 173.14,52.16 173.14,48.64 175.78,46 175.78,44.36 179.08,41.06 179.08,39.57 179.89,38.76 181.02,38.76 185.91,33.86 196.05,33.86 196.46,34.27 197.69,34.27 200.18,31.78 205.68,31.78 205.78,31.88 207.13,31.88 207.4,31.61 208.48,31.61 208.77,31.9 209.81,31.9 210.48,32.57 218.23,32.57 218.72,33.06 224.21,33.06 226.03,34.88 226.03,37.85 226.36,38.19 227.52,38.19 228.34,39 229.62,39 240.4,49.78 240.4,53.15 239.5,54.06 239.5,57.89 246.7,65.1 247.53,65.1 249.98,67.55 249.98,68.72 251.43,70.16 253.08,70.16 253.86,70.94 259.31,70.94 260.54,72.16 263.81,72.16 267.56,68.42 268.39,68.42 270.06,66.74 270.06,61.95 269.08,60.97 269.08,58.27 270.32,57.03 270.32,55.52 271.38,54.46 271.38,53.39 272.26,52.52 272.9,52.52 273.14,52.75 273.91,52.75 274.12,52.54 274.12,52.27 v2(274.38,52.02)
  BOTTOM w0.076: v2(152.98,67.55) 153.4,67.98 UC1.AF6
USB20_N6_R: length 3.9
  TOP w0.088: UR1.10 278.18,55.15 278.05,55.03 278.05,54.83 277.78,54.56 v7(277.12,54.56) 276.41,54.56 275.96,54.1 275.96,53.89 RR21.2
USB20_N7: length 121.2
  IN4 w0.062: v2(238.84,53.11) 238.89,53.06 239.67,53.06 239.96,52.77 239.96,49.96 229.75,39.74 227.28,39.74 221.59,34.05 218.31,34.05 217.76,33.49 210.11,33.49 209.58,32.96 205.37,32.96 203.06,35.27 196.17,35.27 195.64,34.74 186.28,34.74 181.66,39.36 181.66,39.85 177.65,43.87 177.65,45.47 174.07,49.05 174.07,52.52 171.71,54.88 171.71,60.54 169.68,62.57 166.47,62.57 164.26,64.78 164.26,65.27 161.97,67.56 160.99,67.56 160.47,68.08 157.8,68.08 157.71,67.99 157.71,67.87 157.91,67.67 v2(157.94,67.67)
  BOTTOM w0.076: UC1.AH1 155.81,66.4 155.88,66.33 156.05,66.33 156.12,66.4 156.12,66.57 156.19,66.63 157.21,66.63 157.73,67.15 157.73,67.46 v2(157.94,67.67)
  BOTTOM w0.088: v2(238.84,53.11) 238.61,53.11 238.51,53.01 238.51,52.77 238.43,52.69 237.79,52.69 237.69,52.79 237.69,52.92 237.91,53.14 LI9.1 237.91,53.34 RI49.1
USB20_N7_L: length 4.8
  BOTTOM w0.088: JNGFF1.5 240.18,55.15 240.02,55.31 239.54,55.31 239.4,55.46 238.45,55.46 238.41,55.42 237.82,55.42 237.78,55.46 237.56,55.46 237.48,55.37 237.48,55.14 237.57,55.05 237.76,55.05 237.91,54.9 LI9.2 238.04,54.4 RI49.2
USB20_N8: length 51.4
  GND1 w0.088: v3(175.64,39.02) 176.1,38.56 176.1,38.22 v4(176.17,38.16)
  IN4 w0.062: v4(176.17,38.16) 176.14,38.16 175.75,38.55 175.75,40.38 174.06,42.07 174.06,46.05 171.65,48.47 171.65,48.92 171.5,49.07 170.81,49.07 170.75,49.13 170.75,49.58 170.81,49.64 171.2,49.64 171.35,49.79 171.35,50.34 171.2,50.49 170.65,50.49 170.59,50.55 170.59,51 170.65,51.06 171.5,51.06 171.65,51.21 171.65,52.15 171,52.8 170.79,52.8 170.43,52.44 170.34,52.44 170.03,52.76 170.03,52.85 170.39,53.21 170.39,53.41 169.87,53.93 166.62,53.93 166.34,54.21 165.75,54.21 163.44,56.52 163.44,59.9 160.55,62.79 157.43,62.79 157.07,63.15 156.29,63.15 153.89,65.55 152.69,65.55 152.19,66.05 151.45,66.05 151.17,66.33 151.17,66.63 151.44,66.9 151.44,67.25 v2(151.74,67.55)
  BOTTOM w0.076: v2(151.74,67.55) 152.1,67.92 UC1.AF8
USB20_N8_R: length 25.2
  TOP w0.088: LV27.4 177.18,39.02 177.42,38.79 177.73,38.79 177.97,38.55 177.97,37.9 178.06,37.8 178.17,37.8 DV4.2 179.04,37.91 179.16,37.79 179.54,37.79 180,38.25 180,39.13 179.3,39.83 179.3,40.62 179.36,40.68 179.36,40.74 179.78,41.16 179.84,41.16 180.36,41.68 181.11,41.68 182.03,42.61 v2(182.03,42.87)
  BOTTOM w0.088: v2(182.03,42.87) 182.03,42.58 181.93,42.48 181.93,42.16 182.48,41.61 183.99,41.61 184.45,41.16 186.07,41.16 186.71,41.79 192.2,41.79 192.63,41.37 192.63,41.11 192.3,40.78 JTS1.8
USB20_N9: length 162.1
  TOP w0.088: UI3.2 268.31,74.09 268.15,73.93 268.02,73.93 267.84,74.11 v2(267.84,74.17)
  IN4 w0.062: v4(156.38,67.67) 156.29,67.67 156.05,67.91 156.05,68.09 156.98,69.03 160.43,69.03 161.33,68.13 162.57,68.13 163.17,67.53 164.63,67.53 169.08,63.08 169.89,63.08 172.22,60.75 172.22,55.74 174.6,53.37 174.6,49.28 179.41,44.47 179.98,44.47 181.33,43.12 181.33,41.07 187.15,35.26 195.39,35.26 195.96,35.83 203.26,35.83 205.6,33.49 209.37,33.49 209.91,34.03 217.5,34.03 218.07,34.6 219.34,34.6 228.05,43.3 229.68,43.3 238.39,52.01 238.39,57.3 247.75,66.67 247.75,68.67 250.66,71.57 250.66,73.59 252.66,75.59 265.16,75.59 266.04,74.71 268.21,74.71 268.53,74.39 268.53,73.77 268.42,73.66 268.25,73.66 268.19,73.73 268.19,74.16 268.09,74.26 267.93,74.26 v2(267.84,74.17)
  GND5 w0.088: v5(156.13,67.21) 156.38,67.45 v4(156.38,67.67)
USB20_N9_R: length 19.5
  TOP w0.088: v2(282.91,72.12) 283.12,71.91 283.12,71.74 283.03,71.65 v7(279.93,71.65) 279.2,71.65 277.53,73.31 276.98,73.31 276.88,73.41 DI5.2 276.52,73.97 276.52,73.57 276.4,73.45 275.87,73.45 275.76,73.57 275.43,73.57 275.26,73.74 LI7.2
  IN4 w0.062: JUSB1.2 288.03,68 287.8,68.23 287.8,68.73 287.71,68.82 286.11,68.82 283.16,71.77 283.16,71.87 v2(282.91,72.12)
USB20_N10: length 77.4
  IN4 w0.062: v2(153.03,66.49) 152.88,66.49 152.77,66.38 152.77,66.19 152.91,66.06 154.1,66.06 156.48,63.67 157.38,63.67 157.71,63.35 160.78,63.35 164.14,59.99 164.14,56.58 165.96,54.77 166.54,54.77 166.83,54.48 170.05,54.48 172.63,51.91 172.63,48.43 175.2,45.85 175.2,43.94 176.51,42.63 176.51,39.21 176.76,38.96 178.03,38.96 178.75,38.25 180.8,38.25 182.29,36.77 182.29,35.69 181.97,35.37 181.08,35.37 180.78,35.08 180.78,34.56 180.95,34.39 181.84,34.39 182.29,33.95 182.29,33.06 182.98,32.36 191.88,32.36 192.87,33.35 194.61,33.35 195.61,32.36 197.09,32.36 197.29,32.56 197.29,33.25 197.23,33.31 196.93,33.31 196.82,33.42 196.82,33.6 v2(196.91,33.69)
  BOTTOM w0.076: UC1.AH7 v2(153.03,66.49)
  BOTTOM w0.088: JUSH1.8 198.25,33.45 197.65,32.84 197.1,32.84 196.91,33.03 v2(196.91,33.69)
USB20_P1: length 164.1
  IN1 w0.062: v4(45.54,59.84) 45.87,59.84 45.93,59.9 45.93,60.17 46.08,60.32 46.08,61.77 45.22,62.63 45.22,70.64 53.46,78.88 58.07,78.88 59.1,79.91 68.22,79.91 69.98,81.68 94.15,81.68 95.69,83.22 109.01,83.22 111.55,80.68 111.55,80.17 112.62,79.1 115.08,79.1 115.99,78.19 117.09,78.19 117.49,78.6 119.22,78.6 119.4,78.42 119.4,78.01 120.34,77.07 140.81,77.07 142.11,75.78 142.11,75.22 143.17,74.15 143.17,72.58 142.84,72.25 142.84,71.13 143.1,70.87 143.91,70.87 144.14,70.65 146.07,70.65 146.88,69.83 148.73,69.83 148.99,70.09 151.3,70.09 151.36,70.03 151.36,69.92 v2(151.12,69.69)
  IN2 w0.083: v4(28.47,48.31) 28.47,48.36 28.61,48.5 28.8,48.5 29.31,47.99 31.91,47.99 32.65,47.25 33.85,47.25 36.21,44.89 38.73,44.89 41.86,48.01 42.38,48.01 42.98,48.62 42.98,53.55 44.19,54.76 44.19,59.14 45.06,60.02 45.37,60.02 v4(45.54,59.84)
  GND5 w0.088: v5(27.93,48.09) 28.14,48.29 28.45,48.29 v4(28.47,48.31)
  BOTTOM w0.086: UC1.AB10 v2(151.12,69.69)
USB20_P2: length 202.6
  TOP w0.088: LI3.4 27.5,26.75 27.67,26.59 28.02,26.59 v7(28.28,26.85) 28.98,27.55 29.41,27.55 v2(29.62,27.76)
  IN1 w0.062: v2(153,68.64) 153.03,68.64 153.33,68.34 153.33,68.21 153.23,68.11 147.63,68.11 147.05,68.69 147.05,69.08 145.98,70.15 144.55,70.15 144.29,69.89 142.48,69.89 141.47,70.9 141.47,74.79 140.75,75.5 140.75,76.39 140.45,76.69 120,76.69 119.25,77.44 116.21,77.44 114.95,78.7 112.04,78.7 111.72,79.02 111.39,79.02 111.33,79.08 111.33,79.21 111.27,79.28 v4(111.01,79.28) ; v4(43.21,42.83) 43.36,42.68 43.4,42.68 43.55,42.83 43.8,42.83 44.05,42.58 44.05,41.84 42.25,40.04 42.25,37.41 41.08,36.25 41.08,34.22 40.67,33.81 40.42,33.81 40.01,34.22 v4(39.91,34.22)
  IN4 w0.062: v4(39.91,34.22) 40.26,34.22 40.33,34.14 40.33,34.02 39.74,33.44 39.03,33.44 35.17,29.57 32.25,29.57 30.31,27.64 30.31,27.36 30.28,27.32 30.04,27.32 29.98,27.38 29.98,27.7 29.92,27.76 v2(29.62,27.76) ; v4(43.21,42.83) 42.92,42.83 42.85,42.77 42.85,42.5 42.79,42.44 42.7,42.44 42.54,42.6 40.29,42.6 39.32,43.57 39.32,45.81 40.97,47.45 42.67,47.45 43.13,47.91 43.13,53.77 44.74,55.39 44.74,60.91 44.6,61.05 44.6,71.31 50.92,77.63 55.8,77.63 62.08,83.91 64.44,83.91 65.81,85.27 72.13,85.27 72.25,85.27 74.04,87.06 77,87.06 78.42,85.63 78.42,85.01 79.17,84.26 92.88,84.26 94.64,86.02 111.87,86.02 113.03,84.87 113.03,82.58 111.81,81.36 111.81,78.96 111.66,78.82 111.51,78.82 111.42,78.91 111.42,79.39 111.33,79.47 111.21,79.47 v4(111.01,79.28)
  BOTTOM w0.076: v2(153,68.64) 152.75,68.88 UC1.AD7
USB20_P2_R: length 18.1
  TOP w0.088: LI3.3 25.57,26.75 25.4,26.59 25.15,26.59 24.38,25.82 24.3,25.82 23.32,24.83 22.89,24.83 22.8,24.92 DI2.2 22.16,25.07 21.06,25.07 21.02,25.11 20.42,25.11 20.38,25.07 19.72,25.07 19.53,24.88 19.53,24.57 v2(19.32,24.36)
  IN2 w0.083: v2(19.32,24.36) 19.52,24.56 19.52,24.68 19.4,24.8 15.59,24.8 15.43,24.64 13.46,24.64 13.38,24.56 13.38,23.83 13.14,23.6 JUSB2.3
USB20_P3: length 167.7
  GND1 w0.088: v3(24.99,72.98) 25,72.98 25.23,72.75 25.34,72.75 v4(25.57,72.98)
  IN3 w0.083: v4(154.81,66.53) 154.57,66.77 154.57,67 154.25,67.32 154.25,67.78 154.45,67.97 155.42,67.97 155.95,68.51 155.95,72.5 158.13,74.68 158.13,75.12 159.34,76.33 159.75,76.33 160.57,77.15 160.57,80.16 157.48,83.25 150.59,83.25 149.77,84.06 146.79,84.06 146.11,84.75 142.35,84.75 141.83,84.23 139.76,84.23 139.48,84.51 130.34,84.51 128.76,86.09 124.9,86.09 124.73,86.26 105.47,86.26 103.74,84.53 78.86,84.53 77.15,86.24 66.94,86.24 65.57,84.88 61.43,84.88 61.13,84.57 61.12,84.57 59.25,82.7 44.67,82.7 42.15,80.18 41.64,80.18 v4(41.44,80.38)
  IN4 w0.062: v4(25.57,72.98) 25.73,72.83 25.91,72.83 25.98,72.89 25.98,73.49 25.34,74.13 25.34,77.39 27.15,79.2 31.66,79.2 33.01,80.55 39.24,80.55 39.59,80.2 41.27,80.2 v4(41.44,80.38)
  GND5 w0.086: v5(154.83,65.88) 154.83,66.43 154.81,66.46 v4(154.81,66.53)
USB20_P4: length 169
  TOP w0.088: v3(225.61,87.3) 225.75,87.16 225.88,87.16 226.1,87.38 LI8.1 226.39,87.53 RI47.1
  GND1 w0.088: v3(225.61,87.3) 225.74,87.17 225.92,87.17 v4(226.1,87.35)
  IN1 w0.062: v4(226.1,87.35) 226.32,87.12 226.62,87.12 226.79,86.96 226.79,81.04 227.84,79.99 228.9,79.99 229.63,79.26 229.63,77.61 230.08,77.16 230.08,72.87 228.03,70.82 228.03,68.77 231.45,65.35 231.45,64.74 231.72,64.48 235.25,64.48 235.91,63.81 236.64,63.81 237.17,64.34 238.7,64.34 238.9,64.14 238.9,63.5 v4(238.98,63.42)
  IN4 w0.062: v2(151.12,68.62) 151.21,68.53 151.21,68.12 151.36,67.97 155.2,67.97 156.92,69.68 160.8,69.68 161.35,69.12 163.28,69.12 164.03,68.37 167.69,68.37 171.48,64.58 171.48,64.17 172.97,62.68 172.97,62.08 173.61,61.44 173.61,56.29 176.12,53.77 176.12,49.6 181.23,44.49 182.3,44.49 183.72,43.07 183.72,39.71 184.86,38.56 185.45,38.56 188.24,35.77 195.09,35.77 196.52,37.2 202.75,37.2 205.93,34.03 209.15,34.03 209.68,34.56 217.22,34.56 217.84,35.18 219.06,35.18 230.52,46.64 231.12,46.64 237.03,52.54 237.03,58.13 239.03,60.13 239.03,62.62 238.9,62.75 238.9,63.34 v4(238.98,63.42)
  BOTTOM w0.076: UC1.AD10 150.97,68.84 v2(151.12,68.62)
USB20_P4_L: length 3.3
  TOP w0.088: RI47.2 227.31,87.56 LI8.2 227.61,87.38 227.83,87.15 228.39,87.15 v2(228.61,87.37)
  BOTTOM w0.088: v2(228.61,87.37) 228.8,87.19 229.02,87.19 229.21,87 229.35,87 229.51,87.15 JNGFF2.7
USB20_P5: length 97.8
  IN4 w0.062: v2(157.73,65.3) 157.69,65.3 157.39,65.6 157.39,66.04 158.31,66.96 160.82,66.96 161.28,66.51 161.89,66.51 162.08,66.32 162.08,64.54 164.66,61.96 168.88,61.96 171.2,59.64 171.2,54.66 173.51,52.35 173.51,48.88 177.06,45.33 177.06,43.72 179.5,41.29 179.5,39.69 180.06,39.13 181.17,39.13 186.07,34.23 195.89,34.23 196.38,34.73 197.76,34.73 198.89,33.59 203.97,33.59 205.14,32.43 209.78,32.43 210.31,32.96 218.06,32.96 218.62,33.52 221.8,33.52 224.05,35.77 225.17,35.77 225.27,35.66 225.27,35.47 225.22,35.42 224.92,35.42 224.84,35.34 v4(224.84,35.02)
  GND5 w0.076: v4(224.84,35.02) 225.04,34.82 225.04,34.69 v5(224.84,34.48)
  BOTTOM w0.076: v2(157.73,65.3) 157.56,65.47 157.56,65.76 157.37,65.95 156.52,65.95 156.33,66.15 155.75,66.15 UC1.AJ2
USB20_P5_R: length 3
  BOTTOM w0.088: JEDP1.8 224.75,37.8 224.94,37.61 224.94,37.34 225.06,37.22 v7(225.06,36.69) 225.06,36.05 224.84,35.83 LZ1.3
USB20_P6: length 190.7
  TOP w0.088: RR20.1 275.8,52.23 275.8,51.91 275.72,51.82 275.41,51.82 274.59,52.64 274.15,52.64 273.96,52.45 273.96,52.25 v2(273.73,52.01)
  IN4 w0.062: v2(273.73,52.01) 273.98,52.26 273.98,52.48 273.85,52.61 273.2,52.61 272.96,52.37 272.2,52.37 271.23,53.33 271.23,54.4 270.17,55.46 270.17,56.97 268.93,58.21 268.93,61.03 269.92,62.01 269.92,66.68 268.33,68.27 267.5,68.27 263.75,72.02 260.6,72.02 259.37,70.79 253.92,70.79 253.14,70.02 251.49,70.02 250.12,68.66 250.12,67.49 247.59,64.95 246.76,64.95 239.64,57.83 239.64,54.12 240.55,53.21 240.55,49.72 229.68,38.85 228.4,38.85 227.58,38.04 226.42,38.04 226.17,37.79 226.17,34.82 224.27,32.92 218.78,32.92 218.29,32.43 210.54,32.43 209.87,31.75 208.83,31.75 208.54,31.46 207.34,31.46 207.07,31.73 205.84,31.73 205.74,31.64 200.12,31.64 197.63,34.13 196.52,34.13 196.11,33.72 185.85,33.72 180.96,38.62 179.83,38.62 178.94,39.5 178.94,41 175.63,44.3 175.63,45.94 173,48.58 173,52.1 170.69,54.41 170.69,59.28 168.79,61.18 164.01,61.18 161.43,63.76 157.88,63.76 157.58,64.06 156.81,64.06 155.93,64.94 155.93,65.99 154.93,66.99 152.76,66.99 152.58,67.17 152.58,67.35 152.38,67.55 v2(152.38,67.55)
  BOTTOM w0.076: v2(152.38,67.55) 152.38,67.69 152.7,68.01 UC1.AF7
USB20_P6_R: length 3.9
  TOP w0.088: RR20.2 275.79,53.84 275.79,54.17 276.34,54.73 277.41,54.73 277.42,54.73 277.71,54.73 277.88,54.9 277.88,55.01 277.78,55.12 UR1.9
USB20_P7: length 121.2
  IN4 w0.062: v2(157.36,67.67) 157.56,67.87 157.56,68.05 157.74,68.23 160.53,68.23 161.05,67.71 162.03,67.71 164.41,65.33 164.41,64.84 166.53,62.71 169.74,62.71 171.86,60.6 171.86,54.94 174.22,52.58 174.22,49.11 177.79,45.53 177.79,43.93 181.8,39.92 181.8,39.42 186.34,34.89 195.58,34.89 196.11,35.42 203.12,35.42 205.43,33.11 209.52,33.11 210.05,33.64 217.7,33.64 218.25,34.2 221.53,34.2 227.22,39.89 229.69,39.89 239.82,50.02 239.82,52.71 239.61,52.92 239.29,52.92 239.17,52.8 239.17,52.59 239.1,52.51 238.85,52.51 v2(238.84,52.52)
  BOTTOM w0.076: v2(157.36,67.67) 157.57,67.46 157.57,67.22 157.14,66.8 155.63,66.8 155.37,66.54 UC1.AH2
  BOTTOM w0.088: RI50.1 237.31,53.32 LI9.4 237.31,53.14 237.52,52.93 237.52,52.72 237.72,52.52 238.84,52.52 v2(238.84,52.52)
USB20_P7_L: length 4.8
  BOTTOM w0.088: RI50.2 237.17,54.39 LI9.3 237.31,55.07 237.3,55.07 237.3,55.45 237.49,55.63 v7(238.12,55.63) 239.47,55.63 239.61,55.48 240.05,55.48 240.22,55.65 JNGFF1.3
USB20_P8: length 51.3
  GND1 w0.088: v4(175.05,38.78) 175.41,38.42 v3(175.64,38.42)
  IN4 w0.062: v2(151.11,67.55) 151.3,67.36 151.3,66.96 151.03,66.69 151.03,66.27 151.39,65.9 152.13,65.9 152.63,65.4 153.83,65.4 156.23,63 157.01,63 157.37,62.65 160.49,62.65 163.3,59.84 163.3,56.46 165.69,54.07 166.28,54.07 166.56,53.79 169.81,53.79 170.24,53.35 170.24,53.27 169.88,52.91 169.88,52.7 170.28,52.3 170.49,52.3 170.85,52.66 170.94,52.66 171.5,52.09 171.5,51.27 171.44,51.21 170.59,51.21 170.45,51.06 170.45,50.49 170.59,50.35 171.14,50.35 171.2,50.28 171.2,49.85 171.14,49.78 170.75,49.78 170.6,49.64 170.6,49.07 170.75,48.92 171.44,48.92 171.5,48.86 171.5,48.41 173.92,45.99 173.92,42.01 175.61,40.32 175.61,38.49 175.48,38.36 175.3,38.36 175.05,38.61 v4(175.05,38.78)
  BOTTOM w0.076: UC1.AF9 151.45,67.9 v2(151.11,67.55)
USB20_P8_R: length 25.1
  TOP w0.088: LV27.1 177.22,38.42 177.41,38.62 177.66,38.62 177.8,38.48 177.8,37.83 177.99,37.63 178.15,37.63 DV4.3 179.04,37.53 179.13,37.62 179.61,37.62 180.17,38.18 180.17,39.2 179.47,39.9 179.47,40.55 v7(179.72,40.8) 180.43,41.51 181.18,41.51 182.13,42.46 v2(182.45,42.46)
  BOTTOM w0.088: JTS1.9 193.1,40.81 192.8,41.11 192.8,41.44 192.28,41.96 186.64,41.96 186,41.33 184.52,41.33 184.06,41.79 182.55,41.79 182.1,42.23 182.1,42.37 182.19,42.46 v2(182.45,42.46)
USB20_P9: length 162.1
  TOP w0.088: v2(267.84,73.52) 268.04,73.72 268.16,73.72 268.29,73.59 UI3.3
  IN4 w0.062: v4(155.74,67.67) 155.91,67.84 155.91,68.15 156.92,69.17 160.49,69.17 161.39,68.28 162.63,68.28 163.23,67.67 164.69,67.67 169.14,63.23 169.95,63.23 172.37,60.81 172.37,55.8 174.74,53.43 174.74,49.34 179.47,44.61 180.04,44.61 181.48,43.18 181.48,41.13 187.21,35.4 195.33,35.4 195.9,35.98 203.32,35.98 205.66,33.64 209.31,33.64 209.85,34.17 217.44,34.17 218.01,34.74 219.28,34.74 227.99,43.44 229.62,43.44 238.24,52.07 238.24,57.36 247.61,66.73 247.61,68.73 250.51,71.63 250.51,73.65 252.6,75.74 265.22,75.74 266.1,74.86 268.27,74.86 268.67,74.45 268.67,73.71 268.48,73.52 v2(267.84,73.52)
  GND5 w0.086: v4(155.74,67.67) 155.74,67.47 v5(155.48,67.21)
USB20_P9_R: length 19.5
  TOP w0.088: v2(283.49,72.12) 283.29,71.91 283.29,71.66 283.1,71.48 280.26,71.48 280.22,71.43 279.63,71.43 279.59,71.48 279.12,71.48 277.46,73.14 276.98,73.14 276.88,73.04 DI5.3 276.52,72.75 276.52,73.17 276.41,73.28 275.8,73.28 275.68,73.4 275.41,73.4 275.26,73.24 LI7.3
  IN4 w0.062: v2(283.49,72.12) 283.31,71.93 283.31,71.83 286.17,68.96 287.62,68.96 287.77,69.12 287.77,69.91 287.86,70 JUSB1.3
USB20_P10: length 77.4
  IN4 w0.062: v2(152.39,66.49) 152.63,66.25 152.63,66.13 152.85,65.91 154.04,65.91 156.42,63.53 157.32,63.53 157.65,63.2 160.72,63.2 164,59.93 164,56.52 165.9,54.63 166.48,54.63 166.77,54.34 169.99,54.34 172.48,51.85 172.48,48.36 175.06,45.79 175.06,43.88 176.37,42.57 176.37,39.15 176.7,38.82 177.97,38.82 178.69,38.11 180.74,38.11 182.14,36.71 182.14,35.75 181.91,35.52 181.02,35.52 180.64,35.14 180.64,34.5 180.89,34.25 181.78,34.25 182.14,33.88 182.14,33 182.92,32.22 191.94,32.22 192.93,33.21 194.55,33.21 195.54,32.22 197.15,32.22 197.43,32.5 197.43,33.63 v2(197.49,33.69)
  BOTTOM w0.076: UC1.AH8 v2(152.39,66.49)
  BOTTOM w0.088: JUSH1.9 197.75,34.35 197.84,34.26 198.02,34.26 198.08,34.2 198.08,33.52 197.58,33.02 197.17,33.02 197.08,33.1 197.08,33.23 197.17,33.32 197.4,33.32 197.52,33.43 197.52,33.66 v2(197.49,33.69)
USB_OC0#: length 186.3
  TOP w0.086: UI3.13 270.97,75.82 271.82,76.67 271.82,77.73 271.21,78.35 269.96,78.35 269.6,77.99 266.18,77.99 265.07,76.87 265.07,74.94 264.95,74.82 v2(264.95,74.38) ; v2(152.21,83.66) 152.21,83.32 152.34,83.19 153,83.19 153.18,83.37 153.18,83.86 154.12,84.79 159.53,84.79 161.23,86.5 v1(162.02,86.5) 163.59,86.5 v2(163.72,86.62) 164.28,87.19 RPC3.3
  IN2 w0.061: v2(264.95,74.38) 264,74.38 263.21,73.59 259.54,73.59 258.59,74.55 255.16,74.55 253.03,76.68 246.76,76.68 245.48,75.4 245.48,73.09 243.04,70.65 243.04,69.05 242.52,68.52 242.52,67.17 241.88,66.53 237.93,66.53 236.54,65.15 233.59,65.15 229.96,61.53 229.96,61.06 229.36,60.46 228.54,60.46 227.34,59.25 227.34,52.84 227.09,52.59 227.09,51.18 226.26,50.35 224.86,50.35 223.33,48.83 222.59,48.83 219.28,45.52 216.73,45.52 216.05,46.2 216.05,46.71 215.64,47.12 213.45,47.12 211.79,45.46 201.88,45.46 200.9,46.44 200.85,46.44 191.6,46.44 189.75,48.29 188.02,48.29 186.56,49.75 184.92,49.75 179.05,55.62 179.05,58.76 177.55,60.26 177.55,64.15 176.85,64.86 176.85,66.34 176.76,66.43 176.76,77.51 174.01,80.25 174.01,83.34 171.49,85.86 171.49,85.94 v2(171.51,85.95)
  IN4 w0.051: v2(171.51,85.95) 171.49,85.94 171.39,86.04 164.3,86.04 v2(163.72,86.62)
  BOTTOM w0.086: v2(152.21,83.66) 152.21,82.69 151.48,81.96 UC1.A9
USB_OC1#: length 253.6
  TOP w0.086: RPC3.1 163.28,87.35 163.01,87.07 160.51,87.07 v1(159.4,85.96) 158.72,85.28 153.13,85.28 151.63,83.78 v2(151.63,83.66) 151.63,83.5 152.37,82.76 153.81,82.76 154.26,83.2 160.51,83.2 161.52,84.22 165.07,84.22 166.38,85.53 170.52,85.53 171.21,84.85 171.21,83.7 172.22,82.69 172.22,76.68 169.83,74.29 169.83,67.96 169.26,67.39 169.14,67.27 169.14,63.87 167.38,62.12 164.96,62.12 163.22,60.37 163.22,53.92 163.06,53.76 163.06,53.34 163.42,52.98 163.42,49.18 160.68,46.44 160.68,44.55 163.5,41.73 163.5,39.48 156.23,32.22 154.61,32.22 151.31,28.92 148,28.92 145.76,26.69 137.07,26.69 135.58,28.18 134.09,28.18 v2(133.3,27.39)
  IN2 w0.061: v4(66.11,33) 65.45,32.35 59.46,32.35 58.15,31.03 49.49,31.03 48.25,32.27 35.52,32.27 34.53,31.28 27.59,31.28 25.77,33.11 v4(25.77,33.13)
  IN3 w0.061: v4(66.11,33) 67.28,31.83 70.93,31.83 71.63,31.13 92.15,31.13 92.54,30.74 109.07,30.74 111.98,27.84 112.13,27.84 112.13,27.84 115.79,27.84 116.66,28.71 131.98,28.71 v2(133.3,27.39)
  IN4 w0.051: v2(18.86,28.32) 18.96,28.22 23.58,28.22 25.77,30.41 v4(25.77,33.13)
  BOTTOM w0.086: UI1.3 18.39,27.85 v2(18.86,28.32) ; v2(151.63,83.66) 151.63,82.35 151.15,81.87 151.15,81.16 151.22,81.09 151.22,80.32 151.48,80.06 UC1.C9
USB_OC2#: length 18.7
  TOP w0.086: v2(153.59,83.68) 154.47,84.57 159.81,84.57 161.42,86.17 164.19,86.17 v1(164.41,86.4) 164.78,86.77 RPC3.4
  BOTTOM w0.086: UC1.D9 151.48,79.62 151.77,79.91 151.77,80.14 151.76,80.15 151.76,80.6 151.93,80.78 151.93,81.91 153.59,83.56 v2(153.59,83.68)
USB_OC3#: length 16.6
  TOP w0.086: v2(152.8,83.66) 152.8,83.65 152.82,83.68 152.82,83.91 153.97,85.05 159.1,85.05 v1(160.56,86.51) 160.88,86.83 163.16,86.83 163.78,87.45 RPC3.2
  BOTTOM w0.086: UC1.B9 151.48,80.84 151.76,81.11 151.76,81.98 152.8,83.02 v2(152.8,83.66)
USB_POWERSHARE_EN#: length 41.8
  TOP w0.086: v1(269.97,71.21) 269.97,70.78 269.16,69.96 269.16,68.42 v2(268.21,67.48) ; UE1.J3 v2(260.62,57.84)
  TOP w0.117: v1(269.97,71.21) UI3.6
  GND1 w0.086: v4(257.88,45.06) 258.01,45.06 v3(258.28,45.33)
  IN3 w0.061: v2(260.62,57.84) 260.74,57.84 261.16,58.25 261.64,58.25 261.84,58.45 261.84,58.89 261.99,59.04 262.48,59.04 262.63,59.19 262.63,59.65 262.81,59.83 263.26,59.83 263.53,60.1 267.21,60.1 267.48,59.82 268.58,59.82 271.69,62.93 271.69,65.12 269.33,67.48 v2(268.21,67.48)
  IN4 w0.051: v4(257.88,45.06) 257.93,45.06 257.93,45.12 257.27,45.78 257.27,53.45 257.8,53.98 257.8,54.75 259.6,56.54 259.89,56.54 260.24,56.9 260.24,57.46 260.61,57.84 v2(260.62,57.84)
USB_POWERSHARE_VBUS_EN: length 44.5
  TOP w0.086: v2(267.73,67.81) 268.88,68.96 268.88,71.22 269.47,71.81 UI3.5 ; RPE11.4 v3(257.28,46.01) ; UE1.J2 v2(259.82,57.84)
  GND1 w0.086: v3(257.28,46.01) 257.24,45.97 257.24,45.21 v4(257.28,45.17)
  IN3 w0.061: v2(267.73,67.81) 268.03,68.11 269.02,68.11 271.91,65.21 271.91,62.83 268.71,59.64 267.4,59.64 267.17,59.87 263.62,59.87 263.44,59.69 263.44,59.32 263.14,59.01 262.81,59.01 262.63,58.84 262.63,58.4 262.48,58.25 261.99,58.25 261.84,58.1 261.84,57.62 261.66,57.44 260.09,57.44 259.82,57.71 v2(259.82,57.84)
  IN4 w0.051: v2(259.82,57.84) 259.38,57.4 259.38,56.56 257.61,54.8 257.61,54.01 257.12,53.51 257.12,45.33 v4(257.28,45.17)
USB_PWR_EN1#: length 302.1
  TOP w0.086: UE1.K3 v2(260.62,57.04) ; v2(257.78,46.06) RPE11.3
  IN3 w0.061: v2(257.78,46.06) 258.61,46.06 259.8,44.87 259.8,35.49 259.95,35.35 259.95,31.46 258.59,30.11 257.68,30.11 255.53,27.96 243.86,27.96 243.65,28.17 240.65,28.17 240.01,27.54 240.01,27.49 238.78,26.26 231.5,26.26 230.8,26.96 227.31,26.96 226.86,26.51 221.91,26.51 221.87,26.56 181.49,26.56 179.46,28.59 176.26,28.59 175.77,28.1 170.82,28.1 170.15,27.44 168.2,27.44 167.8,27.83 164.05,27.83 162.86,29.03 159.76,29.03 158.18,30.61 144.03,30.61 142.88,29.46 116.35,29.46 115.48,28.59 113.47,28.59 110.38,31.68 95.51,31.68 94.46,32.74 91.89,32.74 89.12,35.5 89.12,42.36 87.61,43.87 85.65,43.87 84.87,44.66 78.96,44.66 78.22,43.93 78.16,43.86 74.92,43.86 74.24,44.54 71.14,44.54 69.84,43.24 67.05,43.24 66.01,42.2 66.01,39.63 66.39,39.25 66.39,36.69 63.67,33.97 60.55,33.97 59.8,33.21 54.6,33.21 54.07,32.68 52.94,32.68 52.62,33.01 36.58,33.01 34.01,30.44 23.01,30.44 19.81,27.24 v2(19.81,25.66)
  IN4 w0.051: v2(257.78,46.06) 257.42,46.42 257.42,53.39 257.99,53.96 257.99,54.7 259.67,56.37 260.14,56.37 260.62,56.85 v2(260.62,57.04)
  BOTTOM w0.086: UI1.4 18.97,25.3 18.97,25.3 19.33,25.66 v2(19.81,25.66)
USB_PWR_EN2#: length 18.5
  TOP w0.086: RPE11.1 258.83,45.33 259.05,45.55 v3(259.2,45.55) ; UE1.G5 v2(262.22,59.44)
  GND1 w0.086: v4(259.22,46.03) 259.15,45.96 259.15,45.6 v3(259.2,45.55)
  IN1 w0.051: v4(259.22,46.03) 258.31,46.95 258.31,48.27 258.56,48.52 259.58,48.52 261.67,50.61 261.67,51.46 261.78,51.57 261.78,53.69 261.06,54.4 261.06,58.92 261.21,59.06 261.84,59.06 v2(262.22,59.44)
USBCOMP: length 1.3
  TOP w0.086: v2(153.51,70.7) 153.25,70.44 RC44.1
  BOTTOM w0.076: UC1.AB6 153.4,70.6 v2(153.51,70.7)
USH_DET#: length 110.1
  TOP w0.086: v3(198.95,34.2) 198.52,34.63 194.53,34.63 RE526.1 193.71,34.82 v1(192.56,34.82) 191.76,34.82 RZ87.1 190.11,36.05 DZ7.2 ; UE1.C13 269.02,63.01 v2(269.39,63.38)
  GND1 w0.086: v3(198.95,34.2) 198.96,34.18 199.39,34.18 v4(199.89,34.68)
  IN2 w0.061: v2(269.39,63.38) 270.5,62.27 270.5,58.48 271.11,57.87 271.11,57.24 270.6,56.72 270.6,55.08 270.03,54.5 270.03,53.5 266.96,50.44 266.73,50.44 266.21,49.92 266.21,49.5 264.08,47.38 263,47.38 261.67,46.05 261.67,43.94 258.21,40.47 258.21,39.93 256.29,38.01 256.29,33.65 252.5,29.86 237.27,29.86 235.95,31.18 227.28,31.18 224.96,33.5 217.41,33.5 216.37,34.54 210.25,34.54 209.67,35.12 200.33,35.12 v4(199.89,34.68)
USH_DET#_R: length 7.8
  TOP w0.086: RZ87.2 189.52,36.96 DZ7.1 188.92,36.35 188.92,33.35 v1(188.99,33.27) 188.99,32.8 v2(188.96,32.76)
  BOTTOM w0.086: JUSH1.26 189.25,33.59 188.89,33.23 188.89,32.83 v2(188.96,32.76)
USH_EXPANDER_SMBCLK: length 120.2
  TOP w0.086: CZ62.1 196.97,37 v3(196.97,37.75) RZ8.2 ; v2(259.52,78.3) 259.14,78.68 UE2.19 ; UE1.B3 v2(260.62,64.18) ; QZ14.6 226.85,51.04 v1(226.99,51.18) 227.39,51.57 228.62,51.57 229.5,50.69 QZ13.3 v3(229.5,49.59)
  GND1 w0.086: v3(229.5,49.59) 229.77,49.85 229.77,50.02 v4(229.76,50.02) ; v3(196.97,37.75) 196.97,38.01 v4(197.35,38.39)
  IN1 w0.051: v4(235.27,59.85) 235.61,59.85 236.27,59.18 244.79,59.18 245.53,59.92 246.34,59.92 250.06,63.64 250.06,64.86 250.82,65.62 251.45,65.62 251.91,66.07 253.87,66.07 255.06,64.88 257.8,64.88 258.34,64.34 260.46,64.34 v2(260.62,64.18) 260.79,64.18 261.17,64.56 262.52,64.56 263.37,65.41 265.46,65.41 266.78,66.73 266.78,70.33 264.41,72.7 264.41,76.87 262.43,78.85 260.06,78.85 v2(259.52,78.3) ; v4(221.51,42.4) 221.51,41.84 218.56,38.9 212.03,38.9 211.57,39.36 198.32,39.36 v4(197.35,38.39)
  IN2 w0.061: v4(235.27,59.85) 235.23,59.8 232.96,59.8 231.82,58.66 231.82,55.89 229.3,53.37 229.3,52.16 229.76,51.7 v4(229.76,50.02) 229.76,48.83 223.28,42.35 221.56,42.35 v4(221.51,42.4)
  GND5 w0.086: v4(197.35,38.39) 197.2,38.24 v5(197.2,37.65)
  BOTTOM w0.086: JUSH1.11 196.75,35.43 197.3,35.98 197.3,37.55 v5(197.2,37.65)
USH_EXPANDER_SMBDAT: length 122.4
  TOP w0.086: v3(229.53,48.95) 229,48.95 228.33,48.28 QZ14.3 ; UE1.E5 v2(262.22,61.78) ; CZ63.1 196.08,37.05 v3(196.08,38.31) ; QZ13.6 230.8,48.85 v3(230.83,48.88) ; UE2.20 259.24,79.18 v2(259.33,79.27)
  GND1 w0.086: v4(196.66,38.34) 196.54,38.34 196.51,38.31 v3(196.08,38.31) ; v3(230.83,48.88) 230.8,48.88 230.68,49.01 v4(230.27,49.01) 229.58,49.01 v3(229.53,48.95)
  IN1 w0.051: v4(196.66,38.34) 197.83,39.51 211.63,39.51 212.09,39.05 218.48,39.05 220.67,41.23 220.67,42.22 v4(220.86,42.41) ; v4(235.24,59.04) 235.54,58.73 244.98,58.73 245.71,59.47 246.11,59.47 250.51,63.88 250.51,64.68 250.92,65.08 252.09,65.08 252.26,65.26 253.98,65.26 254.59,64.65 256.25,64.65 257.14,63.76 261.65,63.76 261.85,63.56 261.85,62.14 v2(262.22,61.78) 262.41,61.78 262.6,61.97 262.6,64.45 263.43,65.27 265.54,65.27 266.93,66.67 266.93,70.39 264.56,72.77 264.56,76.93 262.49,79 259.59,79 v2(259.33,79.27)
  IN2 w0.061: v4(220.86,42.41) 221.28,42 223.19,42 230.2,49.01 v4(230.27,49.01) 230.27,50.21 229.95,50.53 229.95,52.11 230.4,52.56 230.4,53.82 232.01,55.43 232.01,58.52 232.78,59.29 234.99,59.29 v4(235.24,59.04)
  GND5 w0.086: v4(196.66,38.34) 196.79,38.21 v5(196.79,37.63)
  BOTTOM w0.086: JUSH1.12 196.25,35.64 196.79,36.18 v1(196.79,36.65) v5(196.79,37.63)
USH_PWR_STATE#: length 102.2
  TOP w0.086: v2(259.81,58.63) 260.19,59.01 UE1.H2 ; v1(190.37,37.88) 190.63,37.88 191.52,36.99 v3(191.55,36.99)
  GND1 w0.086: v4(191.84,36.51) 191.55,36.8 v3(191.55,36.99)
  IN2 w0.061: v4(254.8,41.13) 254.75,41.13 254.3,40.68 254.3,35.87 251.92,33.49 251.33,33.49 249.74,31.91 241.73,31.91 238.9,34.74 230.35,34.74 228.89,36.2 218.75,36.2 217.38,37.58 204.11,37.58 202.83,38.85 199.51,38.85 199.23,38.57 199.23,37.81 198.25,36.83 197.19,36.83 196.66,36.31 194.9,36.31 194.24,36.96 192.29,36.96 v4(191.84,36.51)
  IN3 w0.061: v2(259.81,58.63) 259.4,58.63 258.1,57.33 258.1,55.74 257.27,54.91 256.55,54.91 255.71,54.06 254.5,54.06 253.25,52.81 253.25,47.68 252.83,47.27 252.83,41.97 253.66,41.13 v4(254.8,41.13)
  GND5 w0.086: v4(191.84,36.51) 191.84,36.36 v5(191.51,36.03)
  BOTTOM w0.086: v5(191.51,36.03) 191.25,35.77 JUSH1.22
USH_RST#_R: length 5.7
  TOP w0.086: v3(192.02,37.4) 191.85,37.56 191.85,38.23 191.53,38.55 v1(191.47,38.55) 191.01,38.55 RZ114.2
  GND1 w0.086: v3(192.02,37.4) 192.02,36.97 v4(192.45,36.53)
  GND5 w0.086: v5(192.19,36.05) 192.2,36.28 v4(192.45,36.53)
  BOTTOM w0.086: JUSH1.21 191.75,35.61 v5(192.19,36.05)
VCI_IN1#: length 3.8
  TOP w0.086: UE1.B5 262.17,64.23 262.17,64.83 261.92,65.08 261.92,65.31 260.72,66.51 RE507.1
VCI_IN2#: length 5.9
  TOP w0.086: UE1.D4 v2(261.42,62.58)
  GND1 w0.117: v4(260.02,66.23) 260.02,66.65 v3(259.83,66.84)
  IN2 w0.061: v4(260.02,66.23) 260.22,66.04 260.22,65.64 261.26,64.6 261.52,64.6 261.82,64.3 261.82,62.98 v2(261.42,62.58)
VGA_IDENTIFY: length 15.3
  TOP w0.086: UE1.L9 v2(266.16,56.24) ; v2(269.54,66.13) v1(270.15,66.13) 271.01,66.13 RE84.1 RE85.1
  BOTTOM w0.086: v2(266.16,56.24) 266.53,56.6 267.17,56.6 267.38,56.8 267.38,59.05 270,61.67 270,65.66 v2(269.54,66.13)
VID0_PRIM_CORE: length 12.3
  TOP w0.086: PR418.2 166.16,41.08 166.16,40.22 166.44,39.94 PR408.2 166.36,39.07 PR420.1 165.85,38.62 163.9,38.62 162.88,37.6 162.88,34.56 v6(163.06,34.38) v2(163.53,33.91)
  BOTTOM w0.086: v2(163.53,33.91) 163.49,33.91 163.49,33.92 163.52,33.92 163.8,34.2 PU402.9
VID0_VCCIO: length 2.4
  TOP w0.254: PU401.9 174.9,29.27 PR414.2 PR416.1
VID1_PRIM_CORE: length 11.6
  TOP w0.086: v2(162.45,33.89) 162.5,33.94 v6(162.5,36.18) 162.5,37.52 163.84,38.86 164.17,38.86 PR419.1 165.45,39.2 ; 165.45,39.2 164.97,39.68 164.97,41.77 PR411.2 ; 165.45,39.2 PR417.2
  BOTTOM w0.086: PU402.8 162.89,33.4 162.45,33.84 v2(162.45,33.89)
VID1_VCCIO: length 2.4
  TOP w0.117: PU401.8 176.56,31.28 PR415.1 PR413.2
VIDALERT_N: length 56.3
  IN4 w0.203: v4(111.3,85.01) 110.13,83.83 106.07,83.83 104.91,82.67 75.23,82.67 74.91,82.36 71.81,82.36 71.65,82.51 69.9,82.51 68.01,80.62 68.01,78.03 67.44,77.45 66.84,77.45 v4(66.79,77.5)
  GND5 w0.203: v5(111.67,85.32) 111.61,85.32 v4(111.3,85.01) ; v4(66.79,77.5) 66.53,77.77 v5(66.37,77.77)
  BOTTOM w0.086: v5(111.67,85.32) 111.67,85.2 112.01,84.87 112.49,84.87 113.17,85.56 RC152.1 114.06,86.68 RC153.2 114.06,87.55 v1(113.67,87.94)
  BOTTOM w0.203: v5(66.37,77.77) 66.75,77.38 PR625.1
VIDALERT_N_B: length 2
  BOTTOM w0.203: PU602.36 68.92,76.73 68.34,77.3 68.19,77.3 PR625.2
VIDSCLK: length 65.6
  IN4 w0.203: v4(112.2,84.1) 112.2,84.88 111.5,85.58 111.04,85.58 109.8,84.34 108.58,84.34 108.37,84.54 108.37,84.97 108.17,85.18 107.76,85.18 107.56,84.97 107.56,84.54 107.36,84.34 105.86,84.34 104.74,83.22 74.89,83.22 74.54,82.86 72.02,82.86 71.86,83.02 70.11,83.02 69.69,83.02 67.51,80.83 67.51,78.24 67.28,78.01 67,78.01 66.79,78.22 v4(66.79,78.32)
  GND5 w0.203: v4(112.2,84.1) 112.26,84.16 112.84,84.16 v5(112.9,84.1) ; v4(66.79,78.32) 66.46,78.65 v5(66.37,78.65)
  BOTTOM w0.076: 119.55,82.97 119.67,82.84 119.67,82.67 120.24,82.11 120.24,82 120.36,81.87 120.36,81.69 120.24,81.57 120.24,81.46 UC1.A63
  BOTTOM w0.086: v5(112.9,84.1) 113.27,84.1 CC321.1 115.84,84.95 117.61,84.95 119.13,83.44 119.13,83.38 119.55,82.97
  BOTTOM w0.203: v5(66.37,78.65) 66.75,78.26 PR618.1
VIDSCLK_B: length 3.2
  BOTTOM w0.086: v1(67.98,79.21) 68.11,79.07 PR618.2
  BOTTOM w0.203: PR618.2 68.11,78.26 69.23,77.13 PU602.37
VIDSOUT: length 68.3
  IN4 w0.203: v4(66.87,76.92) 66.87,76.89 66.92,76.84 67.56,76.84 68.52,77.81 68.52,80.41 70.11,82 71.44,82 71.6,81.85 75.12,81.85 75.44,82.16 105.12,82.16 106.28,83.32 110.46,83.32 v4(111.72,84.59)
  GND5 w0.203: v4(66.87,76.92) 66.82,76.92 66.79,76.89 v5(66.37,76.89) ; v5(111.72,84.1) v4(111.72,84.59) 112.16,85.02 v5(112.16,85.18)
  BOTTOM w0.076: 118.9,82.97 119.88,81.99 119.88,80.71 120.12,80.47 120.12,80.22 120.03,80.12 120.03,79.96 120.12,79.87 120.12,79.58 120.08,79.54 120.08,79.18 120.23,79.02 120.23,78.75 120.13,78.65 119.93,78.65 119.57,79 119.57,79.44 UC1.D64
  BOTTOM w0.086: v5(112.16,85.18) 112.16,85.25 112.29,85.38 RC157.1 ; v5(111.72,84.1) 112.33,83.5 113.4,83.5 114.39,84.48 117.59,84.48 118.78,83.29 118.78,83.09 118.9,82.97
  BOTTOM w0.203: v5(66.37,76.89) 66.75,76.51 PR626.1
VIDSOUT_B: length 1.8
  BOTTOM w0.203: PR626.2 68.61,76.51 68.78,76.33 PU602.35
VOL_DOWN#: length 74.4
  TOP w0.086: UE1.J6 v2(263.02,57.84) ; v3(261.84,46.19) 262.6,46.19 263.06,45.73 RE520.1
  GND1 w0.086: v3(262.38,47.88) 262.38,47.82 262.08,47.53 v4(262.04,47.53) ; v4(261.74,46.74) 261.84,46.65 v3(261.84,46.19)
  IN1 w0.051: v2(263.02,57.84) 263.02,57.8 262.58,57.36 262.58,54.62 262.12,54.16 262.12,51.46 262.04,51.38 262.04,48.27 262.04,48.27 v4(262.04,47.53) 262.04,47.04 v4(261.74,46.74)
  IN4 w0.051: v4(261.74,46.74) 261.79,46.7 261.79,45.13 263.94,42.99 264.52,42.99 265.49,43.96 266.53,43.96 267,43.49 267,42.25 263.49,38.74 263.49,29.7 266.27,26.93 283.45,26.93 284.96,25.42 292.03,25.42 292.42,25.03 294.91,25.03 v2(295.7,25.82)
  BOTTOM w0.086: JPWR1.4 295.1,25.47 295.45,25.82 v2(295.7,25.82)
VOL_UP#: length 87
  TOP w0.086: UE1.D1 258.68,62.21 v2(258.46,62.43)
  GND1 w0.086: v3(257.27,50.49) 257.94,50.49 v4(258.06,50.61)
  IN1 w0.051: v2(258.46,62.43) 258.49,62.4 258.49,61.05 258.54,61 258.54,60.33 258.34,60.13 258.24,60.13 256.68,58.58 256.68,55.38 258.01,54.06 258.98,54.06 259.36,53.67 259.36,53.24 259.73,52.87 259.73,52.38 259.43,52.08 258.28,52.08 257.65,51.44 257.65,51.01 v4(258.06,50.61)
  IN3 w0.061: v4(262.46,50.49) 262.34,50.38 258.28,50.38 v4(258.06,50.61)
  IN4 w0.051: v4(262.46,50.49) 261.6,49.63 261.6,47.43 262.17,46.86 262.17,44.97 263.97,43.16 264.46,43.16 265.42,44.13 266.62,44.13 267.25,43.49 267.25,42.25 263.75,38.74 263.75,29.8 266.41,27.14 283.51,27.14 285.06,25.59 292.1,25.59 292.49,25.2 294.53,25.2 295.54,26.21 296.28,26.21 296.6,25.88 v2(296.6,25.88)
  BOTTOM w0.086: v2(296.6,25.88) 296.33,25.88 295.9,25.45 JPWR1.3
VRALERT#: length 13.5
  TOP w0.086: RC73.1 155.82,54.87 v1(153.1,57.59) 150,60.69 150,63.46 149.91,63.55 149.91,64.34 v2(150.31,64.73)
  BOTTOM w0.086: UC1.AM11 149.97,65.06 v2(150.31,64.73)
VSA_SEN+: length 102.8
  TOP w0.254: RC168.2 145.25,77.33 v3(145.25,77.3)
  GND1 w0.203: v4(144.79,76.97) 145.12,77.3 v3(145.25,77.3)
  IN3 w0.203: v4(144.79,76.97) 144.78,76.97 144.26,77.48 144.26,78.37 143.98,78.65 143.63,78.65 143.3,78.32 143.3,77.96 142.41,77.07 139.83,77.07 139.23,77.67 139.23,79.31 137.59,80.96 132.6,80.96 132.14,80.5 118.68,80.5 117.2,81.98 112,81.98 110.34,83.63 105.79,83.63 104.57,82.41 78.22,82.41 76.38,84.26 73.74,84.26 73.25,83.76 73.25,82.98 72.29,82.03 70.1,82.03 69.26,81.19 69.26,79.41 69.73,78.94 69.73,74.52 70.91,73.34 70.91,72.91 72.31,71.51 72.31,70.44 v2(72.03,70.16)
  GND5 w0.203: v5(145.24,76.65) 145.1,76.65 v4(144.79,76.97)
  BOTTOM w0.254: 72.37,71.45 PC650.1 ; 72.37,71.45 72.37,70.97 72.62,70.72 PC652.1 72.18,70.16 v2(72.03,70.16) ; 72.37,71.45 PR649.2 73.48,71.21 73.48,70.84 73.49,70.83 PC640.2
VSA_SEN-: length 96.1
  TOP w0.086: v2(72.1,72.98) v1(72.1,72.46)
  TOP w0.203: PC649.1 71.54,73.75 72.1,73.19 v2(72.1,72.98)
  GND1 w0.254: v3(144.74,77.76) 144.7,77.76 143.91,76.97 v4(143.85,76.97)
  IN3 w0.203: v2(72.1,72.98) 72.1,73.08 71.65,73.54 71.17,73.54 70.06,74.65 70.06,79.07 69.59,79.55 69.59,81.05 70.23,81.7 72.43,81.7 73.58,82.84 73.58,83.63 73.88,83.93 76.24,83.93 78.09,82.08 104.71,82.08 105.93,83.3 110.21,83.3 111.86,81.65 117.06,81.65 118.54,80.17 132.28,80.17 132.74,80.63 137.45,80.63 138.9,79.18 138.9,77.53 139.69,76.74 142.54,76.74 142.99,77.18 143.63,77.18 v4(143.85,76.97)
  GND5 w0.203: v4(143.85,76.97) 144.16,76.65 v5(144.33,76.65)
  BOTTOM w0.203: PU602.26 72.09,73.08 72.1,73.06 v2(72.1,72.98) 72.1,72.64 PC650.2
VSET_5105: length 11.4
  TOP w0.086: UE1.C9 v2(266.16,63.38) ; v2(268.75,65.74) 268.8,65.69 269.69,65.69 271.03,64.35 RE77.1 CE38.1 273.64,63.46 v1(274.06,63.04)
  IN2 w0.061: v2(266.16,63.38) 266.16,64.05 267.73,65.62 268.34,65.62 268.42,65.69 268.7,65.69 v2(268.75,65.74)
WIGIG_32KHZ: length 4.2
  TOP w0.076: 242.27,43.9 JNGFF1.50
  TOP w0.086: 242.27,43.9 241.42,44.75 v1(240.42,44.75) RZ56.2
WLAN_COEX1: length 41.2
  TOP w0.086: RZ130.2 228.11,65.16 228.11,64.7 v2(228.06,64.65) ; JNGFF1.48 241.18,45.75 v1(241.18,45.86)
  IN1 w0.051: JNGFF1.48 242.53,44.44 240.3,46.67 240.3,47.15 237.35,50.1 230.59,50.1 229.98,49.49 229.54,49.49 228.95,50.07 226.18,50.07 225.36,50.89 225.36,51.77 226.83,53.24 226.83,60.02 225.64,61.2 225.64,64.47 226.54,65.37 227.44,65.37 228.06,64.75 v2(228.06,64.65)
WLAN_COEX2: length 39.1
  TOP w0.086: v1(227.47,64.08) 227.44,64.12 v2(227.44,64.66) RZ129.2
  IN1 w0.051: v2(227.44,64.66) 227.44,64.9 227.14,65.2 226.61,65.2 225.81,64.4 225.81,61.27 227,60.09 227,53.17 225.53,51.7 225.53,50.96 226.27,50.23 229.02,50.23 229.6,49.64 229.92,49.64 230.53,50.25 237.42,50.25 240.45,47.21 240.45,46.73 242.29,44.9 JNGFF1.46
WLAN_COEX3: length 37
  TOP w0.086: v1(225.91,64.12) 226.34,64.54 226.39,64.54 226.86,65.02 v3(226.86,65.26)
  GND1 w0.086: v4(226.78,64.74) 226.86,64.83 v3(226.86,65.26)
  IN1 w0.051: JNGFF1.44 242,45.4 240.6,46.8 240.6,47.28 237.48,50.4 227.5,50.4 227.48,50.38 226.36,50.38 225.7,51.03 225.7,51.06 225.68,51.08 225.68,51.48 225.7,51.5 225.7,51.63 227.17,53.1 227.17,60.16 225.98,61.35 225.98,64.35 226.37,64.74 v4(226.78,64.74)
WLAN_PWR_EN: length 9.4
  TOP w0.086: v3(233.75,29.89) 233.75,29.91 234.08,30.24 RZ70.2 234.08,30.92 234.54,31.38 234.54,32.09 RZ38.1 RZ71.2 233.83,32.69 UZ2.3
  GND1 w0.086: v4(234.15,30.32) 233.75,29.92 v3(233.75,29.89)
  GND5 w0.086: v4(234.15,30.32) v5(234.15,29.84)
  BOTTOM w0.086: v5(234.15,29.84) 234.17,29.84 234.71,29.3 v1(235.29,29.3) DZ9.1
WLAN_WIGIG60GHZ_DIS#: length 65.6
  TOP w0.086: v1(235.75,43) 236.5,42.25 DZ1.1 236.99,42.72 237.2,42.93 238.65,42.93 v3(238.74,43.02)
  GND1 w0.086: v4(239.21,43.14) 238.85,43.14 v3(238.74,43.02)
  GND1 w0.117: v3(268.99,56.61) 269.04,56.61 v4(269.47,57.04) ; v4(258.28,66.48) 258.28,66.53 v3(257.97,66.84)
  IN2 w0.061: v4(254.27,64.41) 253.48,64.41 252.96,63.89 251.55,63.89 251.33,64.12 250.13,64.12 249.93,63.92 249.93,62.85 247.17,60.09 241.17,60.09 239.18,58.1 239.18,56.69 241.34,54.53 241.34,48.93 238.96,46.54 238.96,44.71 239.16,44.51 239.16,43.19 v4(239.21,43.14) ; v4(258.28,66.48) 258.55,66.75 258.97,66.75 259.34,67.12 261.16,67.12 261.51,66.77 263.61,66.77 264.24,66.14 264.24,65.29 264.98,64.55 264.98,60.83 265.19,60.61 267.48,60.61 267.5,60.59 268.29,60.59 268.67,60.21 268.67,57.82 269.45,57.04 v4(269.47,57.04)
  IN4 w0.051: v4(258.28,66.48) 258.13,66.48 257.36,65.71 255.57,65.71 v4(254.27,64.41)
