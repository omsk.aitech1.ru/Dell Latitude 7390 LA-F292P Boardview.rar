# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AR_DET#: length 9.4
  TOP w0.086: v1(159.28,72.92) 159.87,72.92 RC401.1 v3(160.22,71.78)
  GND1 w0.086: v4(159.78,72.27) 159.78,72.22 v3(160.22,71.78)
  GND5 w0.086: v5(159.78,72.75) v4(159.78,72.27)
  BOTTOM w0.076: UC1.P4 154.6,73.52 155,73.52 155.72,73.46 156.02,73.42 156.6,73.42 156.93,73.75 158.95,73.75
  BOTTOM w0.086: v5(159.78,72.75) 159.78,72.91 158.95,73.75
AR_DP1_CTRL_CLK: length 56.5
  IN3 w0.061: v4(15.89,55.56) 16.63,56.3 16.63,68.65 20.33,72.35 22.66,72.35 24.33,74.02 28.14,74.02 30.84,71.32 37.5,71.32 38.62,70.2 39.62,70.2 39.81,70.01 39.81,68.91 39.49,68.59 v4(39.36,68.59)
  GND5 w0.086: v5(39.41,67.83) 39.41,68.54 v4(39.36,68.59) ; v4(15.89,55.56) 15.99,55.46 v5(16.45,55.46)
  BOTTOM w0.076: 37.13,64.5 36.93,64.3 36.93,63.42 UT1.Y2
  BOTTOM w0.086: QV3.1 17.88,50.98 17.39,51.47 17.39,52.64 17.92,53.17 17.92,54.85 17.31,55.46 v5(16.45,55.46) ; v5(39.41,67.83) 39.92,67.32 RT13.1 RT125.1 39.92,66.3 39.34,65.72 39.34,65.38 38.97,65.01 37.64,65.01 37.13,64.5
AR_DP1_CTRL_DATA: length 55.2
  IN3 w0.061: v4(21.35,53.65) 16.98,58.03 16.98,68.71 20.36,72.09 22.67,72.09 24.4,73.82 28.07,73.82 30.76,71.13 37.43,71.13 38.75,69.81 v4(39.36,69.81)
  GND5 w0.086: v4(39.36,69.81) 39.26,69.81 v5(38.85,69.4) ; v5(20.64,53.5) 20.77,53.63 21.33,53.63 v4(21.35,53.65)
  BOTTOM w0.076: 36.88,64.68 36.71,64.51 UT1.Y1
  BOTTOM w0.086: v1(38.44,69.4) v5(38.85,69.4) 39.07,69.4 RT12.1 39.92,68.55 RT124.1 39.27,68.16 38.93,67.82 38.93,65.58 38.65,65.3 37.5,65.3 36.88,64.68 ; v5(20.64,53.5) 20.62,53.48 20.62,53.43 20.29,53.09 20.29,52.78 QV3.4
AR_DP1_HPD: length 40.5
  TOP w0.086: v2(27.51,84.16) 27.34,84.34 27.34,85.16 v1(27.91,85.74) 29.13,86.95 RV20.1
  IN4 w0.051: v2(27.51,84.16) 27.51,83.59 22.39,78.47 22.39,69.71 25.91,66.2 28.49,66.2 29.91,64.78 v4(29.91,64.78)
  GND5 w0.086: v4(29.91,64.78) 30.5,64.19 v5(30.73,64.19)
  BOTTOM w0.076: UT1.G1 v5(30.73,64.19)
  BOTTOM w0.086: QV5.3 32.47,90.07 31.92,89.52 31.92,87.97 31.54,87.59 29.94,87.59 27.53,85.18 27.53,84.17 v2(27.51,84.16)
AR_DP1_N0: length 39.4
  TOP w0.077: v2(22.68,42.45) 22.47,42.24 22.18,42.24 CV32.1
  IN2 w0.073: v2(22.68,42.45) 22.91,42.45 23,42.36 23,42.17 23.07,42.1 23.28,42.1 23.89,42.71 23.89,43.54 24.45,44.1 24.45,45.55 25.66,46.76 25.66,47.47 26.11,47.92 26.11,48.99 25.97,49.13 25.97,54.63 28.47,57.13 28.47,59.6 28.16,59.91 28.16,62.17 29.29,63.29 30.92,63.29 31.78,64.15 33.07,64.15 34.74,65.82 34.74,67.3 v2(34.46,67.57)
  BOTTOM w0.077: v2(34.46,67.57) 34.76,67.28 34.76,67.17 CT201.2 34.78,66.78 34.78,64.87 34.32,64.41 34.32,63.99 34.17,63.84 34.17,63.53 34.23,63.48 34.35,63.48 34.41,63.54 UT1.R1
AR_DP1_N1: length 34.8
  TOP w0.077: CV34.1 22.19,44.26 22.46,44.26 v2(22.68,44.49)
  IN2 w0.073: v2(33.62,66.43) 33.83,66.22 33.83,66.06 32.91,65.13 31.68,65.13 30.86,64.31 28.5,64.31 27.41,63.22 27.41,59.78 27.41,59.77 27.41,59.6 27.72,59.29 27.72,57.93 25.15,55.35 25.15,51.34 24.92,51.11 24.92,47.85 23.7,46.63 23.7,44.59 23.18,44.07 23.06,44.07 22.97,44.17 22.97,44.32 22.8,44.49 v2(22.68,44.49)
  BOTTOM w0.077: UT1.N1 33.49,63.53 33.42,63.47 33.31,63.47 33.25,63.52 33.25,63.84 33.41,64 33.41,64.72 33.82,65.13 33.82,65.68 CT202.2 v2(33.62,66.43)
AR_DP1_N2: length 40.1
  GND1 w0.077: v3(21.14,46.54) 21.34,46.34 21.65,46.34 v4(21.9,46.59)
  IN2 w0.073: v4(32.71,67.57) 32.73,67.57 33.06,67.89 33.06,68 32.99,68.07 31.58,68.07 31.36,68.28 29.86,68.28 28.72,67.14 24.17,67.14 22.02,64.98 22.02,59.11 20.67,57.76 20.67,49.43 21.03,49.07 21.03,46.25 21.11,46.18 21.36,46.18 21.43,46.25 21.43,46.73 21.5,46.81 21.83,46.81 21.9,46.73 v4(21.9,46.59)
  GND5 w0.077: v4(32.71,67.57) 32.89,67.39 32.89,67.18 v5(32.69,66.99)
  BOTTOM w0.077: v5(32.69,66.99) 32.96,66.72 32.96,65.36 32.49,64.89 32.49,64 32.33,63.84 32.33,63.52 32.4,63.45 32.5,63.45 32.57,63.53 UT1.L1
AR_DP1_N3: length 30.2
  GND1 w0.077: v3(21.16,48.6) 21.21,48.55 21.75,48.55 v4(21.79,48.59)
  IN2 w0.073: v2(31.96,66.34) 32.11,66.34 32.21,66.24 32.21,66.09 32.01,65.89 31.37,65.89 30.99,65.52 28.63,65.52 25.29,62.17 25.29,58.49 23.5,56.7 23.5,53.51 24.13,52.87 24.13,49.17 23.78,48.82 22.85,48.82 22.38,48.35 22.19,48.35 22.12,48.42 22.12,48.51 22.04,48.59 v4(21.79,48.59)
  BOTTOM w0.077: UT1.J1 31.65,63.54 31.59,63.48 31.47,63.48 31.41,63.53 31.41,63.84 31.57,63.99 31.57,64.7 32.23,65.37 32.23,65.59 CT204.2 32.02,66.28 v2(31.96,66.34)
AR_DP1_P0: length 39.5
  TOP w0.077: v2(22.68,41.86) 22.46,42.08 22.19,42.08 CV31.1
  IN2 w0.073: v2(35.1,67.57) 34.91,67.39 34.91,65.75 33.14,63.98 31.85,63.98 30.99,63.12 29.36,63.12 28.33,62.1 28.33,59.98 28.64,59.67 28.64,57.06 26.14,54.56 26.14,49.2 26.28,49.06 26.28,47.85 25.83,47.4 25.83,46.69 24.62,45.48 24.62,44.03 24.06,43.47 24.06,42.64 23.36,41.93 22.74,41.93 v2(22.68,41.86)
  BOTTOM w0.077: v2(35.1,67.57) 35.06,67.57 34.92,67.43 34.92,67.23 CT201.1 34.94,66.77 34.94,64.8 34.49,64.35 34.49,64.01 34.63,63.86 34.63,63.43 UT1.R2
AR_DP1_P1: length 34.8
  TOP w0.077: CV33.1 22.18,44.1 22.48,44.1 v2(22.68,43.9)
  IN2 w0.073: v2(22.68,43.9) 23.25,43.9 23.87,44.52 23.87,46.56 25.09,47.78 25.09,51.04 25.32,51.27 25.32,55.28 27.89,57.86 27.89,59.36 27.58,59.67 27.58,59.84 27.58,59.85 27.58,63.15 28.57,64.14 30.93,64.14 31.75,64.97 32.98,64.97 34,65.99 34,66.23 v2(34.21,66.43)
  BOTTOM w0.077: UT1.N2 33.71,63.43 33.71,63.86 33.57,64 33.57,64.65 33.98,65.06 33.98,65.64 CT202.1 v2(34.21,66.43)
AR_DP1_P2: length 40.1
  GND1 w0.077: v3(21.14,45.91) 21.41,46.18 21.73,46.18 v4(21.9,46.01)
  IN2 w0.073: v4(21.9,46.01) 21.03,46.01 20.86,46.18 20.86,49 20.5,49.36 20.5,57.84 21.85,59.18 21.85,65.05 24.1,67.31 28.65,67.31 29.79,68.45 31.43,68.45 31.65,68.24 33.06,68.24 33.23,68.07 33.23,67.64 v4(33.29,67.57)
  GND5 w0.077: v5(33.28,66.99) 33.05,67.22 33.05,67.33 v4(33.29,67.57)
  BOTTOM w0.077: UT1.L2 32.79,63.43 32.79,63.86 32.65,64 32.65,64.83 33.12,65.29 33.12,66.83 v5(33.28,66.99)
AR_DP1_P3: length 30.2
  GND1 w0.077: v4(21.79,48) 21.75,47.96 v3(21.16,47.96)
  IN2 w0.073: v2(32.59,66.34) 32.38,66.13 32.38,66.02 32.08,65.72 31.44,65.72 31.06,65.35 28.7,65.35 25.46,62.1 25.46,58.42 23.66,56.63 23.66,53.58 24.3,52.94 24.3,49.1 23.85,48.65 22.92,48.65 22.45,48.18 21.96,48.18 v4(21.79,48)
  BOTTOM w0.077: v2(32.59,66.34) 32.62,66.32 32.62,65.81 CT204.1 32.39,65.58 32.39,65.3 31.73,64.64 31.73,64.01 31.87,63.86 31.87,63.43 UT1.J2
AUD_HP_NB_SENSE: length 55.2
  TOP w0.254: v2(257,26.9) 257.3,26.6 259.53,26.6 259.89,26.25 262.81,26.25 263.57,25.49 279.95,25.49 281.12,26.65 DA2.3 284.03,28.62 v1(285.19,27.46) 285.83,26.82 289.87,26.82 JHP1.6
  GND1 w0.254: v4(262.17,41.4) 261.66,41.91 v3(261.66,42)
  IN1 w0.254: v2(257,26.9) 256.99,26.91 256.99,28.31 260.65,31.96 260.65,36.36 261.13,36.84 261.13,38.19 262.17,39.23 v4(262.17,41.4)
AUD_HP_OUT_L: length 2.4
  TOP w0.076: RA52.1 274.81,31.61 v1(275.07,31.87)
  TOP w0.381: RA7.2 RA52.1
AUD_HP_OUT_L1: length 15.2
  TOP w0.381: JHP1.1 285.29,37.1 v1(284.23,36.04) 284.23,35.51 284.06,35.35 284.06,35.07 283.48,34.49 DA1.3 279.76,34.49 CA3.1 279.37,34.17 276.14,30.94 RA52.2
AUD_HP_OUT_R: length 3
  TOP w0.076: RA53.1 274.81,29.85 275.48,29.18 275.71,29.18 v1(275.89,29)
  TOP w0.381: RA8.2 RA53.1
AUD_HP_OUT_R1: length 24.7
  TOP w0.381: RA53.2 277.42,29.99 v1(277.75,30.32) CA2.1 279.87,32.01 280.42,32.55 DA1.2 283.23,32.23 282.7,31.71 v2(282.11,31.71)
  IN1 w0.381: v2(282.11,31.71) 282.11,30.77 286.11,26.77 293.04,26.77 293.4,27.12 JHP1.2
AUD_PC_BEEP: length 3.2
  TOP w0.117: CA27.2 CA28.2 272.14,35.52 UA1.32
AUD_PWR_EN: length 135
  TOP w0.086: v2(249.6,34.81) 249.6,34.36 250.1,33.86 v3(252.42,33.86) UZ5.3 ; v2(172.79,68.74) 172.79,67.06 RC279.1 175.02,65.11 178.17,61.96 178.17,60.58 179.76,58.99 v6(179.76,57.26) 179.76,55.84 177.39,53.47 177.39,45.75 v2(176.46,44.83)
  TOP w0.117: v3(252.42,33.08) 252.47,33.08 252.49,33.06 UZ5.5
  GND1 w0.117: v3(252.42,33.86) v3(252.42,33.08)
  IN2 w0.061: v2(249.6,34.81) 249.4,34.61 240.78,34.61 239.47,35.92 236.75,35.92 233.21,39.46 222.75,39.46 222.57,39.64 211.94,39.64 210.17,41.42 191.73,41.42 191.01,40.69 189.44,40.69 188.5,41.63 186.86,41.63 186.53,41.96 179.32,41.96 v2(176.46,44.83)
  BOTTOM w0.076: 159.36,70.68 159.3,70.75 157.47,70.75 157.33,70.89 156.67,70.89 156.53,70.75 156.12,70.75 155.76,70.8 155.18,70.9 154.65,70.9 154.52,71.03 154.52,71.26 154.27,71.51 152.36,71.51 152.1,71.25 UC1.W8
  BOTTOM w0.086: 159.36,70.68 165.32,70.68 165.92,71.28 170.25,71.28 v2(172.79,68.74)
AUD_SENSE_A: length 6.1
  TOP w0.254: UA1.1 263.77,37.12 263.09,37.8 v1(263.09,38.12) 263.09,38.59 261.88,39.8 CA41.1 261.88,40.86 RA60.1 RA59.2
AUD_SENSE_B: length 5.3
  TOP w0.254: RA61.2 262.9,40.71 v1(262.9,40.15) 262.9,39.5 263.72,38.67 263.72,37.96 264.11,37.56 264.72,37.56 264.97,37.82 UA1.48
AUX_EN_WOWL: length 69.1
  TOP w0.086: UE1.D3 v2(260.62,62.58) ; RZ70.1 235.53,30.69 237.53,28.69 237.53,27.95 v2(238.04,27.44)
  IN1 w0.051: v4(258.02,42.41) 258.02,43.53 257.93,43.62 257.93,44.31 258.39,44.76 258.39,46.41 258.01,46.8 258.01,49.34 258.46,49.79 259.02,49.79 260.27,51.04 260.27,51.47 259.89,51.85 259.89,52.93 259.52,53.3 259.52,54.89 259.33,55.08 257.98,55.08 256.84,56.22 256.84,58.51 257.87,59.55 259.49,59.55 260.58,60.63 260.76,60.63 261.03,60.89 261.03,61.99 260.62,62.4 v2(260.62,62.58)
  IN4 w0.051: v2(238.04,27.44) 238.26,27.22 241.99,27.22 242.51,27.74 254.15,27.74 254.73,28.32 255.8,28.32 256.81,29.33 256.81,40.46 258.02,41.66 v4(258.02,42.41)
  BOTTOM w0.086: DZ9.2 239.13,29.29 239.13,28.18 238.4,27.44 v2(238.04,27.44)
BAT1_LED#: length 266.8
  TOP w0.254: UE1.D10 v2(266.96,62.58)
  IN1 w0.254: v2(266.96,62.58) 267.14,62.58 267.53,62.19 268.06,62.19 269.11,61.15 269.11,58.98 270.09,57.99 270.09,56.17 270.52,55.75 270.52,54.81 267.43,51.72 267.43,49.71 267.04,49.32 266.86,49.32 263.58,46.03 263.45,46.03 262.72,45.3 262,45.3 261.37,44.67 261.37,41.88 259.94,40.45 259.94,32.47 256.19,28.73 255.85,28.73 253.68,26.56 250.7,26.56 250.2,27.06 242.88,27.06 242.11,26.29 231.67,26.29 230.93,27.03 229.79,27.03 228.97,26.22 195.49,26.22 194.86,26.84 180.96,26.84 180.64,26.53 178.79,26.53 178.79,26.53 178.18,26.53 177.34,27.36 173.73,27.36 v4(173.6,27.49)
  IN4 w0.254: v2(42.38,30.37) 43.46,30.37 44.42,29.42 91.56,29.42 92.35,28.63 105.35,28.63 107.99,25.99 145.91,25.99 148.28,28.36 157.59,28.36 160.51,25.43 172.05,25.43 173.63,27.01 173.63,27.47 v4(173.6,27.49)
  BOTTOM w0.254: RZ28.1 41.44,31.87 v1(42.41,30.9) 42.38,30.87 42.38,30.37 v2(42.38,30.37)
BAT2_LED#: length 51.2
  TOP w0.254: v2(267.78,62.65) 267.78,62.6 UE1.D11 ; RZ25.1 253.71,86.19 v1(253.87,86.34) 255.21,86.34 v3(256.33,87.46)
  GND1 w0.254: v3(256.33,87.46) 256.76,87.46 v4(256.98,87.68)
  IN2 w0.152: v2(267.78,62.65) 267.39,63.04 267.39,64.51
  IN2 w0.254: 267.39,64.51 267.61,64.73 268.04,64.73 268.09,64.68 272.38,64.68 v4(274.06,63)
  IN3 w0.254: v4(274.06,63) 274.43,63.37 274.43,69.57 273.2,70.8 270.51,70.8 268.93,72.38 268.93,74.36 268.09,75.19 267.09,75.19 265.36,76.92 263.09,76.92 262.65,77.36 262.65,83.42 258.61,87.46 257.19,87.46 v4(256.98,87.68)
BAT2_LED#_R: length 5.7
  TOP w0.086: QZ3.2 254.41,87.45 QZ2.6 254.6,87.46 254.98,87.84 254.98,88.27 255.47,88.76 QZ2.3 256.87,88.76 257.03,88.92 v1(257.03,89.94)
BATT_WHITE#: length 325.9
  TOP w0.086: v2(251.81,87.1) 251.81,86.37 RZ25.2 252.37,86.57 252.37,87.92 QZ3.3
  IN1 w0.051: v4(271.09,55.85) 271.09,54.88 267.68,51.47 267.68,49.6 267.15,49.06 266.97,49.06 263.68,45.78 263.55,45.78 262.82,45.05 262.11,45.05 261.63,44.56 261.63,41.63 260.24,40.25 260.24,32.28 256.33,28.36 255.84,28.36 253.79,26.3 250.6,26.3 250.09,26.81 242.99,26.81 242.19,26.01 231.45,26.01 230.82,26.64 229.94,26.64 229.21,25.92 195.43,25.92 194.76,26.59 181.07,26.59 180.75,26.27 178.69,26.27 178.69,26.27 178.07,26.27 177.34,27.01 173.48,27.01 v4(173,27.49)
  IN3 w0.061: v2(251.81,87.1) 251.82,87.08 258.42,87.08 262.27,83.23 262.27,77.2 262.93,76.54 265.2,76.54 266.93,74.81 267.94,74.81 268.55,74.2 268.55,72.22 270.35,70.42 273.04,70.42 273.96,69.5 273.96,65.72 272.97,64.73 272.97,63.41 273.47,62.9 273.47,59.94 272.08,58.54 272.08,58 272.08,58 272.08,57.6 272.08,57.6 272.08,57.18 271.09,56.2 v4(271.09,55.85)
  IN4 w0.051: v4(173,27.49) 173,27.25 171.54,25.78 160.52,25.78 157.41,28.89 148.45,28.89 145.94,26.37 107.97,26.37 105.46,28.89 92.45,28.89 91.66,29.68 45.1,29.68 44.01,30.77 41,30.77 v2(40.66,30.43)
  BOTTOM w0.254: JLED1.3 31.12,24.95 32,24.08 34.13,24.08 36.19,26.13 36.19,27.14 39.31,30.26 39.31,30.53 39.72,30.93 40.33,30.93 40.66,30.6 v2(40.66,30.43)
BATT_YELLOW#: length 14.2
  BOTTOM w0.254: JLED1.2 30.83,25.45 30.91,25.38 31.23,25.38 32.15,24.46 33.97,24.46 35.81,26.29 35.81,27.29 38.88,30.37 38.88,30.71 v1(39.39,31.23) 39.77,31.61 40.01,31.61 RZ28.2
BC_CLK_ECE1117: length 123.9
  TOP w0.086: v2(269.51,62.32) 269.41,62.21 UE1.D13
  IN2 w0.061: v4(177.28,36.61) 178.33,35.57 183.99,35.57 184.83,34.73 197.1,34.73 197.81,35.44 216.53,35.44 218.15,33.81 226.03,33.81 227.04,32.8 227.04,32.52 228.06,31.5 236.08,31.5 237.4,30.18 251.52,30.18 255.97,34.63 255.97,38.14 257.89,40.06 257.89,40.6 261.36,44.07 261.36,47.39 262.41,48.45 264.56,48.45 264.89,48.78 264.89,49.46 266.18,50.76 266.83,50.76 269.36,53.28 269.36,54.05 270.32,55.01 270.32,57.26 269.63,57.95 269.63,62.19 v2(269.51,62.32)
  GND5 w0.086: v5(176.7,37.3) 176.7,37.19 v4(177.28,36.61)
  BOTTOM w0.117: JKBTP1.10 177.75,36.12 v1(177.65,36.22) 176.7,37.17 v5(176.7,37.3)
BC_DAT_ECE1117: length 125.6
  TOP w0.086: UE1.D12 268.57,62.59 v2(268.57,62.62) 268.6,62.65 269.21,62.65 269.6,63.04 270.35,63.04 v1(270.36,63.03) 270.95,62.44 RE365.1
  IN2 w0.061: v4(177.87,36.62) 177.87,36.61 178.55,35.93 184.13,35.93 185.01,35.04 196.92,35.04 197.63,35.75 216.73,35.75 218.35,34.13 226.16,34.13 227.41,32.88 230.45,32.88 231.51,31.81 236.21,31.81 237.53,30.49 251.39,30.49 255.66,34.76 255.66,38.27 257.58,40.19 257.58,40.73 261.04,44.2 261.04,47.52 262.76,49.24 263.35,49.24 265.89,51.78 265.89,51.9 266.58,52.59 268.22,52.59 269,53.37 269,55.08 269.89,55.97 269.89,57.18 269.16,57.92 269.16,60.89 268.57,61.48 v2(268.57,62.62)
  GND5 w0.086: v4(177.87,36.62) 177.59,36.9 v5(177.59,37.3)
  BOTTOM w0.117: v5(177.59,37.3) 178.75,36.14 JKBTP1.8
BC_INT#_ECE1117: length 122.9
  TOP w0.086: UE1.E2 v2(259.82,61.78)
  IN2 w0.061: v4(178.45,36.64) 178.94,36.15 184.22,36.15 185.11,35.26 196.83,35.26 197.54,35.98 198.82,35.98 200.24,37.39 217.3,37.39 218.67,36.02 228.81,36.02 230.28,34.55 238.77,34.55 241.64,31.68 249.79,31.68 251.41,33.3 252,33.3 254.49,35.79 254.49,38.91 254.94,39.37 254.94,40.08 255.81,40.94 255.81,41.5 256.46,42.15 256.46,45.5 258.37,47.41 258.37,49.27 258.59,49.49 260.01,49.49 261.56,51.04 261.56,51.55 262.97,52.97 263.82,52.97 264.21,53.36 264.21,53.54 265.75,55.08 265.75,56.47 265.57,56.65 265.22,56.65 264.99,56.88 264.99,59.11 264.64,59.46 264.64,59.88 264.24,60.29 260.46,60.29 259.82,60.94 v2(259.82,61.78)
  GND5 w0.086: v4(178.45,36.64) 178.45,37.27 v5(178.48,37.3)
  BOTTOM w0.117: v5(178.48,37.3) 178.48,36.81 179.21,36.08 v1(179.66,36.08) 179.66,35.96 179.25,35.55 JKBTP1.7
BCM5882_ALERT#: length 101.9
  TOP w0.086: UE1.G10 266.23,59.44 v2(266.17,59.44)
  IN2 w0.061: v4(200.19,36.76) 200.63,37.2 216.38,37.2 217.94,35.64 225.71,35.64 227.72,33.64 231.46,33.64 231.73,33.9 233.45,33.9 233.79,33.56 235.52,33.56 237.83,31.25 251.09,31.25 254.9,35.07 254.9,38.7 255.39,39.18 255.39,39.84 256.25,40.7 256.25,41.32 256.83,41.9 256.83,43.75 257.22,44.14 257.72,44.14 258.41,44.83 258.41,46.92 261.48,49.99 262.81,49.99 263.27,50.46 263.27,51.84 264.44,53 264.44,53.44 265.66,54.67 266.24,54.67 266.59,55.03 266.59,56.45 266.39,56.65 266.01,56.65 265.75,56.9 265.75,58.76 266.17,59.18 v2(266.17,59.44)
  GND5 w0.086: v4(200.19,36.76) 199.89,36.46 v5(199.89,36.1)
  BOTTOM w0.086: v5(199.89,36.1) 198.95,36.1 v1(198.4,36.65) 198.4,36.9 196.18,39.12 195.97,39.12 RE532.1 196.28,38.35 196.28,36.02 195.75,35.48 JUSH1.13
BEEP: length 33.3
  TOP w0.086: v2(267,59.44) 267.39,59.05 UE1.H11
  TOP w0.117: v2(272.79,42.96) 273.31,42.96 274.61,41.65 275,41.65 275.3,41.35 275.68,41.35 277.29,39.75 277.29,36.9 v1(277.03,36.65) 276.15,35.77 RA13.2
  IN1 w0.051: v4(271.76,46.71) 269.78,46.71 v4(269.4,46.33)
  IN2 w0.061: v4(271.76,46.71) 272.42,46.04 272.42,43.33 v2(272.79,42.96)
  IN4 w0.051: v2(267,59.44) 267.12,59.32 267.96,59.32 268.4,58.88 268.4,57.94 269.08,57.26 269.08,53.2 267.94,52.05 267.94,47.79 v4(269.4,46.33)
BEEP_R: length 5
  TOP w0.117: CA28.1 275.06,35.81 RA13.1 275.1,35.44 274.92,35.26 RA45.1 CA62.1 275.95,34.91 276.22,35.18 v1(277.07,35.18)
BGATE_ISL9538: length 21.6
  TOP w0.203: v2(57.85,39.18) 58.03,39 58.03,38.05 57.91,37.94 PU901.32
  TOP w0.381: PQ906.4 59.48,52.61 59.02,52.16
  TOP w0.508: v3(58.49,52.16) 59.02,52.16
  GND1 w0.117: v3(58.49,52.16) v4(58.49,52.71)
  IN2 w0.254: v2(57.85,39.18) 57.85,40.67 55.13,43.4 55.13,51.79 56.41,53.07 58.13,53.07 v4(58.49,52.71)
BIA_PWM: length 4.3
  BOTTOM w0.086: DV1.1 220.45,32.7 RV1.1 220.45,33.85 221.21,34.61 v1(221.21,34.66) 221.33,34.78 LV1.2
BIA_PWM_EC: length 71.2
  TOP w0.086: UE1.N1 v2(259.02,54.64)
  IN4 w0.051: v2(259.02,54.64) 259.46,54.64 261.36,52.74 261.36,51.18 260.69,50.5 260.69,47.42 260.44,47.18 260.44,46.8 259.95,46.3 259.95,42.87 257.85,40.78 257.85,38.55 258.46,37.94 258.46,35.16 257.29,33.99 257.29,29.09 256.01,27.81 254.94,27.81 254.42,27.28 242.7,27.28 242.13,26.71 232.73,26.71 v4(232.25,27.19)
  GND5 w0.086: v5(232.25,27.67) v4(232.25,27.19)
  BOTTOM w0.086: v5(232.25,27.67) 232.22,27.7 232.22,27.77 231.84,28.15 231.84,29.28 230.51,30.62 229.05,30.62 228.5,30.07 227.94,30.07 226.99,29.12 224.5,29.12 224.35,28.96 221.35,28.96 v1(221.19,29.13) 220.33,29.99 DV1.2
BL_PWR_SRC_ON: length 6.3
  BOTTOM w0.086: QV1.3 225.17,30.79 225.4,31.02 225.4,31.42 225.61,31.62 CV13.1 225.94,30.8 225.95,30.79 CV14.1 RV5.1 225.63,29.46 v1(224.81,29.46) RV4.1
BOARD_ID: length 3.9
  TOP w0.086: UE1.J13 269.35,58.21 270.71,56.85 CE40.1 271.29,57.03 RE79.2
BOOT1_ISL9538: length 2.2
  TOP w0.203: PR914.1 51.8,36.9 52.33,36.37 52.67,36.37 53.04,36.74 PU901.12
BOOT2_ISL9538: length 2.3
  TOP w0.203: PU901.4 55.74,39.94 55.34,40.34
  TOP w0.508: PC934.2 55.1,40.58 55.34,40.34
BREATH_LED#: length 27.9
  TOP w0.086: v1(247.82,73.43) 248.52,74.13 RZ32.1 250.13,74.13 250.79,73.47 250.79,72.88 v2(251.17,72.5) ; UE1.C11 267.78,63.4 v2(267.78,63.45)
  BOTTOM w0.086: v2(267.78,63.45) 263.71,67.52 262.83,67.52 261.46,68.89 261.46,69.94 261.72,70.2 261.72,71.3 261.14,71.88 259.03,71.88 257.75,73.16 251.83,73.16 v2(251.17,72.5)
BREATH_WHITE_LED_SNIFF#: length 105.9
  TOP w0.086: v3(251.35,74.02) 250.54,74.02 250.16,74.41 249.47,74.41 RZ32.2 248.84,75.43 v1(247.97,76.3)
  GND1 w0.086: v4(252.09,73.9) 251.96,74.02 v3(251.35,74.02)
  IN4 w0.051: v4(252.09,73.9) 260.04,73.9 260.39,73.54 263.74,73.54 267.83,69.45 268.81,69.45 271.58,66.69 271.58,61.98 271.4,61.81 271.4,60.49 273.24,58.65 273.24,58.11 275.73,55.62 275.73,51.64 275.58,51.48 274.47,51.48 271.03,48.04 270.23,48.04 269.92,47.73 269.92,47.29 269.94,47.27 269.94,46.07 268.17,44.29 268.17,42.92 263.99,38.74 263.99,29.92 266.6,27.31 283.58,27.31 285.13,25.76 292.17,25.76 292.56,25.37 293.93,25.37 v2(294.43,25.87)
  BOTTOM w0.086: JPWR1.5 294.3,25.74 v2(294.43,25.87)
BST_3V:
  vias: v1(72,42.85) v2(71.85,42.35) v2(72.46,42.35)
BST_5V: length 0.9
  TOP w0.086: v1(51.1,70.13) 50.65,69.68 v2(50.36,69.68)
  vias: v2(49.78,69.68)
BST_+1VALWP_C: length 1.1
  BOTTOM w0.086: PR304.2 57.96,71.45 v1(57.69,71.71)
BT_RADIO_DIS#: length 44.3
  TOP w0.086: DZ2.1 238.37,43.45 v3(238.78,43.45) ; RE11.1 253.17,66.03 v2(253.53,65.67) 253.81,65.39 255.74,65.39 v1(256.09,65.04) 256.86,64.27 258.41,64.27 259.3,63.38 259.82,63.38 UE1.C2
  GND1 w0.086: v4(238.68,43.93) 238.78,43.82 v3(238.78,43.45)
  IN2 w0.061: v4(238.68,43.93) 238.77,44.02 238.77,46.62 241.11,48.97 241.11,54.44 238.96,56.6 238.96,58.19 241.08,60.32 247.08,60.32 249.7,62.94 249.7,64.01 250.73,65.03 252.9,65.03 v2(253.53,65.67)
BT_RADIO_DIS#_R: length 6.7
  TOP w0.076: JNGFF1.54 243.33,42.9 242.28,42.9
  TOP w0.086: 242.28,42.9 241.53,43.65 DZ2.2 239.32,43.65 238.67,44.3 v1(237.23,44.3)
CAM_MIC_CBL_DET#: length 144.5
  TOP w0.086: v3(160.4,51.15) 160.4,52.5 161.16,53.26 161.16,57.62 161.26,57.72 161.26,61.17 162.67,62.59 v1(162.67,62.99) 162.67,64.17 163.25,64.74 RPC5.3
  GND1 w0.086: v3(160.4,51.15) 160.61,50.94 160.61,50.29 v4(160.57,50.24)
  IN2 w0.061: v4(232.38,30.3) 232.33,30.3 232.18,30.45 226.97,30.45 224.66,32.77 217.11,32.77 216.07,33.81 200.7,33.81 200.15,33.26 195.56,33.26 194.84,33.98 182.08,33.98 181.64,34.42 177.66,34.42 174.9,37.18 172.4,37.18 168.95,40.63 168.95,42.09 168.42,42.61 168.1,42.61 166.81,43.91 165.9,43.91 161.55,48.25 161.55,48.72 160.57,49.71 v4(160.57,50.24) 160.05,50.24 158.91,51.37 158.91,52.93 150.68,61.17 150.68,62.63 150.72,62.67 150.72,65.59 150.53,65.77 149.29,65.77 148.87,66.19 148.87,68.02 150.49,69.64 v2(150.49,69.69)
  GND5 w0.086: v4(232.38,30.3) 232.38,30.49 v5(232.71,30.82)
  BOTTOM w0.086: JEDP1.9 224.25,39.43 225.19,40.37 228.4,40.37 229.25,39.52 229.25,39.13 229.25,39.13 229.25,37.88 229.4,37.73 232.07,37.73 233.28,36.52 233.28,34.36 232.01,33.09 232.01,31.55 232.71,30.84 v5(232.71,30.82) ; UC1.AB11 v2(150.49,69.69)
CFG0: length 70
  TOP w0.086: v3(114.41,83.55) 114.41,83.94 110.94,87.41 95.02,87.41 92.53,84.92 87.33,84.92 v1(86.6,84.19) 86.14,83.72 79.16,83.72 77.69,85.2 77.69,89.38 76.63,90.44 74.74,90.44 v2(74.39,90.8) 74.07,91.12 JXDP1.9
  GND1 w0.086: v3(114.41,83.55) v4(114.75,83.21)
  GND5 w0.086: v4(114.75,83.21) 114.75,83.21 114.75,82.58 v5(114.55,82.38)
  BOTTOM w0.076: 115.54,82.03 115.77,82.26 116.17,82.26 116.4,82.03 117.9,82.03 118.35,81.57 118.35,81.55 118.35,81.55 118.35,81.19 118.35,81.18 118.32,81.09 118.32,80.95 118.33,80.86 118.35,80.78 118.35,80.72 118.35,80.61 118.35,80.6 118.35,80.56 118.33,80.5 118.3,80.41 118.25,80.23 118.21,79.97 118.14,79.7 UC1.E68
  BOTTOM w0.086: 115.54,82.03 115.51,82 114.98,82 114.6,82.38 v5(114.55,82.38) 114.5,82.43 111.32,82.43 109.5,84.26 107.61,84.26 106.61,85.26 105.36,85.26 RC113.1 ; v2(74.39,90.8) 74.02,90.8 RC126.1
CFG1: length 68.8
  TOP w0.086: v3(117.46,81.89) 115.53,81.89 113.85,83.57 113.85,83.99 110.79,87.05 v1(102.47,87.05) 95.19,87.05 92.71,84.58 87.47,84.58 86.28,83.38 79.02,83.38 77.27,85.14 77.27,89.32 76.48,90.1 74.13,90.1 73.47,90.77 JXDP1.11
  GND1 w0.086: v3(117.46,81.89) v4(117.94,81.89)
  GND5 w0.086: v4(117.94,81.89) 117.94,81.89 117.86,81.81 117.81,81.81 v5(117.57,81.57)
  BOTTOM w0.076: 115.71,81.63 117.51,81.63 v5(117.57,81.57) 117.6,81.54 117.6,80.99 UC1.B67
  BOTTOM w0.086: RC112.1 106.69,83.7 109.14,83.7 111.03,81.81 114.05,81.81 114.24,81.63 115.71,81.63
CFG2: length 64.8
  TOP w0.086: JXDP1.15 72.27,91.05 71.7,90.48 70.78,90.48 v3(69.51,89.21)
  GND1 w0.086: v4(69.44,88.48) 69.48,88.48 69.48,88.59 69.51,88.63 v3(69.51,89.21)
  IN4 w0.051: v4(115.46,83.04) 115.97,83.55 115.97,85.75 115.27,86.45 113.17,86.45 112.46,87.16 94.2,87.16 92.91,85.87 81.18,85.87 80.56,86.49 80.56,86.76 78.53,88.78 71.31,88.78 70.61,88.09 69.82,88.09 v4(69.44,88.48)
  GND5 w0.086: v5(115.38,82.28) 115.46,82.36 v4(115.46,83.04)
  BOTTOM w0.076: v5(115.38,82.28) 115.53,82.42 116.26,82.42 116.47,82.21 118.72,82.21 119.01,81.93 119.01,81.72 118.84,81.55 118.84,81.19 118.87,81.09 118.87,80.9 118.84,80.81 118.84,80.56 118.85,80.52 118.9,80.36 118.98,80.08 118.98,79.97 119.05,79.7 UC1.D65
CFG3: length 79.1
  TOP w0.086: v2(72.28,92.85) 72.28,92.72 71.67,92.1 JXDP1.17
  IN4 w0.051: v4(116.04,83.02) 116.12,83.09 116.12,85.81 115.33,86.6 113.24,86.6 112.53,87.31 94.13,87.31 92.85,86.02 81.25,86.02 80.71,86.55 80.71,86.82 78.6,88.94 70.48,88.94 v4(70.02,88.48)
  GND5 w0.086: v4(70.02,88.48) v5(70.02,89.42) ; v5(116.04,82.01) v4(116.04,83.02)
  BOTTOM w0.076: v5(116.04,82.01) 116.2,81.85 117.82,81.85 118.18,81.48 118.18,81.22 118.13,81.1 118.13,80.95 118.18,80.76 118.18,80.59 118.1,80.33 UC1.D67
  BOTTOM w0.086: v5(70.02,89.42) 71.72,91.12 RC121.2 71.87,91.17 72.23,91.53 72.23,92.74 72.28,92.8 v2(72.28,92.85) ; v5(116.04,82.01) 115.84,81.8 114.31,81.8 113.99,82.13 111.14,82.13 v1(109.75,83.52) 109.35,83.92 107.47,83.92 106.47,84.92 105.18,84.92 104.61,85.49 103.19,85.49 102.77,85.91 RC110.1
CFG4: length 71.4
  TOP w0.086: v3(68.57,89.19) 68.67,89.28 JXDP1.27
  GND1 w0.086: v3(68.57,89.19) 68.85,88.91 68.85,88.48 v4(68.85,88.47)
  IN4 w0.051: v4(114.29,80.99) 114.31,80.99 114.06,81.24 114.06,85.2 112.25,87 94.26,87 92.97,85.72 81.12,85.72 80.41,86.43 80.41,86.69 78.47,88.63 71.4,88.63 70.68,87.92 69.41,87.92 v4(68.85,88.47)
  GND5 w0.086: v5(114.25,80.39) 114.25,80.87 114.32,80.93 114.32,80.99 v4(114.29,80.99)
  BOTTOM w0.076: UC1.E70 115.88,79.02 115.64,79.26 115.38,79.26 115.34,79.29
  BOTTOM w0.086: RC109.1 103.81,82.17 v1(104.75,82.17) 104.95,82.17 106.02,83.24 109,83.24 111.85,80.39 v5(114.25,80.39) 115.34,79.29
CFG5: length 61.6
  TOP w0.086: v1(117.04,80.7) 117.04,80.23 v2(116.82,80.01) ; v3(68.07,89.09) JXDP1.29
  GND1 w0.086: v3(68.07,89.09) 68.27,88.89 v4(68.27,88.45)
  IN4 w0.051: v4(68.27,88.45) 68.97,87.75 70.75,87.75 71.49,88.48 78.41,88.48 80.26,86.63 80.26,86.37 81.06,85.56 93.03,85.56 94.32,86.85 112.19,86.85 113.91,85.13 113.91,81.05 113.81,80.95 113.81,80.32 114.27,79.87 116.68,79.87 v2(116.82,80.01)
  BOTTOM w0.076: UC1.C68 v2(116.82,80.01)
CFG6: length 64.5
  TOP w0.086: v3(66.79,89.16) 66.87,89.24 JXDP1.33
  GND1 w0.086: v3(66.79,89.16) 67.08,88.87 v4(67.08,88.43)
  IN4 w0.051: v4(67.08,88.43) 67.08,88.43 67.94,87.58 70.82,87.58 71.57,88.33 78.35,88.33 80.1,86.57 80.1,86.3 81,85.41 93.1,85.41 94.39,86.7 112.12,86.7 113.75,85.07 113.75,82.17 112.72,81.14 v4(112.72,80.78)
  GND5 w0.086: v5(112.39,81.24) 112.39,81.21 112.72,80.88 v4(112.72,80.78)
  BOTTOM w0.076: UC1.D68 116,79.55 115.68,79.87 115.38,79.87
  BOTTOM w0.086: v1(111.41,81.24) v5(112.39,81.24) 112.9,80.73 114.39,80.73 115.26,79.87 115.38,79.87
CFG7: length 65.1
  TOP w0.086: JXDP1.35 66.27,91.15 65.98,90.86 65.98,89.43 v3(66.27,89.14)
  GND1 w0.086: v3(66.27,89.14) 66.27,88.58 66.41,88.43 v4(66.49,88.43)
  IN4 w0.051: v4(66.49,88.43) 67.52,87.41 70.9,87.41 71.66,88.17 78.28,88.17 79.95,86.5 79.95,86.24 80.93,85.26 93.16,85.26 94.45,86.55 112.06,86.55 113.59,85.02 113.59,82.34 112.33,81.08 112.33,80.58 112.53,80.38 113.06,80.38 v4(113.4,80.73)
  GND5 w0.086: v4(113.4,80.73) 113.4,81.17 v5(113.5,81.26)
  BOTTOM w0.076: UC1.C67 117.27,80.37 116.04,80.37 115.89,80.53 115.28,80.53
  BOTTOM w0.086: v5(113.5,81.26) 114.11,81.26 114.84,80.53 115.28,80.53
CFG8: length 51.4
  TOP w0.086: v3(115.74,79.26) 115.74,80.8 113.08,83.46 113.08,83.85 110.74,86.19 v1(100.93,86.19) 95.32,86.19 93.06,83.94 87.74,83.94 86.51,82.71 78.79,82.71 73.77,87.73 JXDP1.10
  GND1 w0.086: v4(116.12,78.9) 115.77,79.26 v3(115.74,79.26)
  GND5 w0.086: v5(115.96,78.39) 115.96,78.74 v4(116.12,78.9)
CFG9: length 53.8
  TOP w0.086: JXDP1.12 73.17,88.03 78.7,82.5 86.6,82.5 87.83,83.72 93.2,83.72 95.34,85.87 v1(99.22,85.87) 109.61,85.87 113.61,81.87 114.26,81.87 115.35,80.78 115.35,78.81 v3(115.18,78.65)
  GND1 w0.086: v4(114.75,78.14) 114.75,78.16 115.18,78.6 v3(115.18,78.65)
  GND5 w0.086: v5(115.08,77.68) 114.75,78.01 v4(114.75,78.14)
  BOTTOM w0.076: v5(115.08,77.68) 115.13,77.63 115.22,77.63 115.35,77.5 115.61,77.5 115.73,77.56 115.87,77.56 116.1,77.49 116.23,77.49 116.45,77.57 116.7,77.57 UC1.G69
CFG10: length 53.5
  TOP w0.086: v3(114.68,80.66) 114.69,80.68 114.69,81.17 114.26,81.6 113.41,81.6 109.46,85.55 v1(102.34,85.55) 95.37,85.55 93.33,83.51 87.92,83.51 86.69,82.28 78.59,82.28 74.33,86.54 73.35,86.54 71.97,87.93 JXDP1.16
  GND1 w0.086: v4(114.93,80.25) 114.68,80.5 v3(114.68,80.66)
  GND5 w0.086: v5(114.7,79.49) 114.93,79.71 v4(114.93,80.25)
  BOTTOM w0.076: v5(114.7,79.49) 114.7,78.77 114.87,78.6 115.61,78.6 115.69,78.67 116.21,78.63 116.39,78.45 UC1.F70
CFG11: length 55.5
  TOP w0.086: JXDP1.18 71.37,87.64 72.68,86.33 74.24,86.33 78.5,82.07 86.78,82.07 88,83.3 93.46,83.3 95.37,85.21 109.45,85.21 113.81,80.86 v1(113.81,80.48) 113.81,78.83 v3(114.01,78.62)
  GND1 w0.086: v3(114.01,78.62) 114.04,78.6 114.04,78.27 v4(114.17,78.14)
  GND5 w0.086: v5(114.39,78.6) 114.39,78.36 v4(114.17,78.14)
  BOTTOM w0.076: v5(114.39,78.6) 114.7,78.28 115.49,78.28 116.05,78.04 116.93,78.04 UC1.G68
CFG12: length 58.3
  TOP w0.086: v2(112.81,77.73) 112.51,78.04 112.51,81 109.26,84.24 95.44,84.24 93.85,82.66 88.27,82.66 86.96,81.34 78.19,81.34 73.94,85.6 71.69,85.6 69.63,87.65 68.68,87.65 68.37,87.97 JXDP1.28
  BOTTOM w0.076: UC1.H70 116.25,76.87 116.01,76.87 115.88,76.82 115.78,76.82 115.71,76.85 115.33,76.85
  BOTTOM w0.086: 115.33,76.85 112.74,76.85 112.56,77.02 112.56,77.61 112.69,77.73 v2(112.81,77.73)
CFG13: length 58.2
  TOP w0.086: v2(113.17,77.25) 112.97,77.05 112.28,77.05 111.91,77.42 v1(111.91,79.97) 111.91,81.25 109.13,84.03 95.57,84.03 93.98,82.44 88.36,82.44 87.05,81.13 78.06,81.13 73.83,85.35 71.59,85.35 69.53,87.41 68.19,87.41 67.77,87.83 JXDP1.30
  BOTTOM w0.076: UC1.G71 115.33,77.95 114.37,77.95
  BOTTOM w0.086: v2(113.17,77.25) 113.17,77.53 113.68,78.04 114.28,78.04 114.37,77.95
CFG14: length 61.1
  TOP w0.086: JXDP1.34 66.57,88.07 67.47,87.17 69.43,87.17 71.49,85.11 73.73,85.11 77.93,80.92 87.14,80.92 88.45,82.23 94.12,82.23 95.7,83.82 108.95,83.82 111.57,81.2 v1(111.57,77.87) 111.57,77.3 112.08,76.79 113.37,76.79 113.73,77.15 v2(113.73,77.53)
  BOTTOM w0.076: UC1.H69 116.86,77.38 116.4,77.38 116.24,77.32 116.09,77.32 115.88,77.38 115.76,77.38 115.65,77.34 114.88,77.34
  BOTTOM w0.086: v2(113.73,77.53) 114.68,77.53 114.88,77.34
CFG15: length 61.7
  TOP w0.086: v2(111.65,76.62) 111.11,77.15 111.11,81.31 108.82,83.6 95.84,83.6 94.25,82.02 88.54,82.02 87.22,80.7 77.79,80.7 73.63,84.87 71.39,84.87 69.33,86.92 66.98,86.92 65.97,87.93 JXDP1.36
  BOTTOM w0.076: UC1.G70 116.01,77.77 115.86,77.91 115.86,77.91 115.86,77.92 115.45,78.11 114.5,78.11 114.34,78.27
  BOTTOM w0.086: 114.34,78.27 114.29,78.32 112.36,78.32 111.65,77.6 v2(111.65,76.62)
CFG16: length 54.4
  TOP w0.086: v3(119.96,78.75) 119.96,78.82 v1(119.71,79.07) 117.68,81.1 115.75,81.1 113.36,83.49 113.36,83.88 110.72,86.52 95.3,86.52 92.93,84.15 87.65,84.15 86.43,82.92 78.88,82.92 74.97,86.83 JXDP1.6
  GND1 w0.086: v3(119.96,78.75) 119.96,78.47 120.06,78.37 v4(120.06,78.27)
  GND5 w0.086: v5(120.5,78.67) 120.5,78.66 120.13,78.29 120.08,78.29 v4(120.06,78.27)
CFG17: length 55
  TOP w0.086: v3(120.32,78.96) 119.08,80.21 v1(119.08,80.71) 118.54,80.71 117.89,81.36 115.8,81.36 113.58,83.58 113.58,83.96 110.81,86.73 95.21,86.73 92.84,84.36 87.56,84.36 86.34,83.14 78.96,83.14 75.57,86.53 JXDP1.4
  GND1 w0.086: v3(120.32,78.96) 120.35,78.96 v4(121.02,78.29)
  GND5 w0.086: v5(120.5,78.01) 120.54,78.01 120.86,78.33 120.98,78.33 v4(121.02,78.29)
CFG18: length 58.8
  TOP w0.086: JXDP1.24 69.57,88.07 71.79,85.84 74.04,85.84 78.32,81.56 86.87,81.56 88.18,82.87 93.72,82.87 95.42,84.57 v1(99.27,84.57) 109.29,84.57 112.99,80.86 112.99,78.96 113.86,78.09 116.12,78.09 116.78,77.43 118.18,77.43 v3(118.48,77.73)
  GND1 w0.086: v4(118,78.19) 118.03,78.19 v3(118.48,77.73)
  GND5 w0.086: v4(118,78.19) 118.03,78.22 118.08,78.22 118.47,78.61 v5(118.47,78.67)
CFG19: length 56.8
  TOP w0.086: v3(117.04,77.83) 116.57,78.3 113.95,78.3 113.45,78.8 113.45,80.86 109.42,84.89 v1(97.68,84.89) 95.4,84.89 93.59,83.08 88.09,83.08 86.81,81.8 78.42,81.8 74.14,86.08 72.16,86.08 70.17,88.08 JXDP1.22
  GND1 w0.086: v4(117.52,77.83) v3(117.04,77.83)
  GND5 w0.086: v4(117.52,77.83) 117.62,77.83 117.7,77.76 118.22,77.76 v5(118.47,78.01)
CFG_RCOMP: length 1.7
  TOP w0.102: v1(121.47,79.17) 121.82,78.83 v2(121.89,78.83)
  TOP w0.381: RC114.1 121.89,78.82 v2(121.89,78.83)
  BOTTOM w0.086: UC1.E60 121.91,78.83 v2(121.89,78.83)
CLK_ITPXDP_N: length 21.9
  TOP w0.088: RC297.1 115.3,88.39 115.3,87.41 116.05,86.65 123.4,86.65 126.15,83.91 126.15,83.57 v7(128.43,81.3) 129.4,80.32 129.4,80.31 129.8,79.91 129.81,79.91 130.53,79.19 130.53,78.64 130.94,78.24 v2(131.08,78.24)
  BOTTOM w0.076: UC1.F43 131.47,77.94 131.15,78.18 v2(131.08,78.24)
CLK_ITPXDP_N_R: length 70.6
  TOP w0.088: JXDP1.42 64.17,88.9 64.38,89.11 64.38,90.73 v3(64.25,90.86) ; v3(77.65,92.5) 77.77,92.38 77.77,92.07 78.67,91.17 78.67,84.8 79.32,84.15 86.01,84.15 87.17,85.31 92.26,85.31 94.76,87.8 105.19,87.8 108.44,91.04 108.44,92.02 109.03,92.61 112.91,92.61 112.96,92.56 113.55,92.56 113.6,92.61 114.14,92.61 v7(114.96,91.8) 115.51,91.25 115.51,89.82 RC297.2
  GND1 w0.088: v3(77.65,92.5) 77.79,92.64 77.79,92.77 v4(77.57,92.99) ; v3(64.25,90.86) 64.39,90.99 64.39,91.54 64.37,91.55 64.37,91.56 v4(64.2,91.73)
  IN1 w0.062: v4(64.2,91.73) 64.41,91.93 64.41,92.11 64.66,92.36 77.69,92.36 77.79,92.47 77.79,92.77 v4(77.57,92.99)
CLK_ITPXDP_P: length 21.8
  TOP w0.088: v2(131.09,78.83) 131.09,78.83 130.91,78.65 130.77,78.65 130.71,78.72 130.71,79.26 v7(129.73,80.24) 128.76,81.21 128.76,81.23 128.36,81.62 128.34,81.62 126.33,83.64 126.33,83.98 123.48,86.83 116.12,86.83 115.47,87.48 115.47,88.09 115.58,88.2 115.75,88.2 RC298.1
  BOTTOM w0.076: UC1.E43 131.5,78.59 131.11,78.83 v2(131.09,78.83)
CLK_ITPXDP_P_R: length 70.7
  TOP w0.088: JXDP1.40 64.77,88.88 64.55,89.09 64.55,90.74 v3(64.68,90.87) ; RC298.2 115.68,89.87 115.68,91.32 115.33,91.68 115.33,91.75 114.91,92.16 114.84,92.16 114.22,92.79 v7(113.26,92.79) 108.96,92.79 108.26,92.09 108.26,91.12 105.12,87.97 94.69,87.97 92.19,85.48 87.1,85.48 85.94,84.32 79.4,84.32 78.84,84.87 78.84,91.24 77.94,92.14 77.94,92.38 v3(78.06,92.5)
  GND1 w0.088: v4(78.16,92.99) 77.97,92.79 77.97,92.6 v3(78.06,92.5) ; v3(64.68,90.87) 64.56,90.99 64.56,91.5 v4(64.79,91.73)
  IN1 w0.062: v4(64.79,91.73) 64.55,91.96 64.55,92.05 64.72,92.22 77.75,92.22 77.94,92.41 77.94,92.76 v4(78.16,92.99)
CLK_PCIE_N0: length 163.1
  IN1 w0.062: v4(131.41,88.1) 131.41,88.91 131.67,89.17 142.29,89.17 142.48,89.36 154.4,89.36 157.89,85.87 168.74,85.87 171.4,83.21 172.81,83.21 174.4,81.62 174.4,80.08 176.82,77.67 176.82,65.17 178.17,63.81 178.17,62.71 180.15,60.74 180.15,57.93 188.52,49.56 190.07,49.56 192.85,46.77 198.81,46.77 199.39,46.19 210.89,46.19 214.73,50.03 222.02,50.03 225.73,53.74 225.73,59.75 224.68,60.8 224.68,64.87 225.22,65.41 225.22,73.22 226.42,74.42 227.16,74.42 v4(227.46,74.72)
  GND5 w0.088: v5(228.05,74.58) 227.95,74.48 227.7,74.48 v4(227.46,74.72) ; v5(131.49,87.48) 131.49,88.02 v4(131.41,88.1)
  BOTTOM w0.076: 131.6,85.09 131.6,85.07 131.6,85.07 131.6,84.71 132.21,84.2 132.21,83.15 arc(132.2,83.06) 132.15,82.99 131.86,82.7 arc(131.64,82.42) 131.51,82.08 arc(131.45,81.88) 131.34,81.69 arc(131.24,81.44) 131.25,81.17 arc(131.26,81.04) 131.25,80.91 131.23,80.84 arc(131.22,80.64) 131.28,80.46 arc(131.3,80.35) 131.27,80.25 arc(131.2,80.07) 131.21,79.87 arc(131.23,79.82) 131.26,79.77 arc(131.29,79.72) 131.32,79.69 arc(131.34,79.67) 131.36,79.65 arc(131.43,79.62) 131.51,79.6 arc(131.52,79.59) 131.53,79.59 arc(131.63,79.5) UC1.D42
  BOTTOM w0.088: JNGFF2.53 229.38,75.65 229.22,75.49 229,75.49 228.52,75.01 228.52,74.6 228.37,74.45 228.18,74.45 v5(228.05,74.58) ; 131.6,85.09 131.6,87.22 arc(131.57,87.36) v5(131.49,87.48)
CLK_PCIE_N1: length 151
  IN1 w0.062: v4(133.48,87.31) 133.2,87.59 133.2,87.88 133.58,88.26 138.11,88.26 138.21,88.15 154.64,88.15 157.61,85.18 168.45,85.18 171.11,82.51 172.35,82.51 173.63,81.22 173.63,79.58 176.02,77.19 176.02,65.04 177.52,63.54 177.52,62.44 179.49,60.47 179.49,57.65 188.26,48.88 189.7,48.88 192.47,46.11 198.54,46.11 199.14,45.51 211.26,45.51 215.12,49.37 225.51,49.37 226.63,48.25 231.5,48.25 232.13,48.89 236.36,48.89 237.18,48.06 237.18,45.4 238.26,44.31 239.05,44.31 239.18,44.18 239.91,44.18 v4(240.13,43.96)
  GND5 w0.076: v4(240.13,43.96) 239.91,44.19 v5(239.6,44.19)
  GND5 w0.088: v4(133.48,87.31) 133.27,87.1 133.27,86.9 v5(133.37,86.8)
  BOTTOM w0.076: v5(133.37,86.8) 133.34,86.78 arc(133.28,86.68) 133.26,86.56 133.26,83.5 arc(133.23,83.36) 133.15,83.24 132.45,82.54 arc(132.27,82.3) 132.18,82.01 arc(132.16,81.93) 132.16,81.86 arc(132.14,81.66) 132.14,81.46 arc(132.07,81.17) 131.87,80.95 131.71,80.79 arc(131.67,80.74) UC1.B42
  BOTTOM w0.088: JNGFF1.49 240.11,44.15 239.95,44.31 239.72,44.31 v5(239.6,44.19)
CLK_PCIE_N3: length 175.8
  IN1 w0.062: v4(40.06,37.99) 39.92,38.13 39.83,38.13 39.63,37.93 39.5,37.93 38.86,38.57 38.86,39.49 39.93,40.56 39.93,43.08 42.12,45.27 42.12,46.84 43.15,47.87 43.15,56.41 42.87,56.7 42.87,61.79 42.4,62.26 42.4,66.38 42.96,66.94 42.96,71.2 49.9,78.14 49.9,80.3 51.77,82.16 57.77,82.16 59.18,83.56 65.32,83.56 66.29,84.54 74.67,84.54 75.28,83.93 93.22,83.93 95.28,85.99 109.57,85.99 112.87,82.68 114.94,82.68 115.31,82.31 119.29,82.31 120.57,81.03 133.04,81.03 133.46,81.46 133.46,81.8 v2(133.59,81.92)
  IN4 w0.062: v4(40.06,37.99) 40.06,37.73 40.29,37.5 40.29,36.18 34.65,30.55 29.25,30.55 21.18,22.47 21.18,16.42 v4(21.39,16.2)
  GND5 w0.088: v4(21.39,16.2) 21.19,16 21.19,15.8 21.29,15.69 v5(21.29,15.58)
  BOTTOM w0.076: v2(133.59,81.92) 133.39,81.72 133.39,81.58 arc(133.36,81.41) 133.29,81.26 arc(133.23,81.15) 133.19,81.03 arc(133.17,80.94) 133.19,80.84 arc(133.23,80.65) 133.19,80.46 arc(133.17,80.34) 133.19,80.23 arc(133.24,79.99) 133.16,79.77 arc(133.09,79.68) 133.01,79.61 arc(132.88,79.51) UC1.D40
  BOTTOM w0.088: JNGFF3.53 21.35,14.95 21.19,15.11 21.19,15.41 21.29,15.52 v5(21.29,15.58)
CLK_PCIE_N5: length 145.8
  IN1 w0.062: v4(133.9,80.1) 133.9,80.1 133.9,80.39 133.96,80.46 134.3,80.46 134.34,80.5 134.34,80.73 134.2,80.87 133.66,80.87 133.29,80.5 117.92,80.5 117.26,81.16 115.74,81.16 114.79,82.11 112.61,82.11 109.25,85.46 95.47,85.46 93.43,83.42 75.06,83.42 74.46,84.02 69.2,84.02 68.23,83.05 59.39,83.05 57.91,81.58 52.15,81.58 52.05,81.47 52.05,81.19 52.28,80.96 52.33,80.96 52.33,80.96 v4(52.3,80.96)
  IN4 w0.062: v4(52.3,80.96) 52.15,81.11 52.15,81.2 52.19,81.24 52.19,81.68 51.39,82.47 49.89,82.47 48.01,84.35 48.01,86.67 47.21,87.48 43.47,87.48 43.45,87.47 43.21,87.47 42.79,87.05 42.79,82.61 43.76,81.64 43.76,76.16 43.23,75.63 40.14,75.63 37.76,73.25 37.76,55.41 36.49,54.14 35.99,54.14 35.84,54.29 35.84,55.31 35.69,55.46 35.48,55.46 35.31,55.62 v4(35.31,55.72)
  GND5 w0.076: v4(133.9,80.1) 133.9,80.1 134.08,79.92 134.08,79.63 133.78,79.33 133.78,79.15 133.65,79.02 v5(133.65,78.99)
  GND5 w0.088: v4(35.31,55.72) 35.31,55.65 35.02,55.35 v5(34.98,55.35)
  BOTTOM w0.076: UC1.E40 133.66,78.6 133.74,78.68 133.74,78.91 v5(133.65,78.99)
CLK_PCIE_P0: length 163.1
  IN1 w0.062: v4(227.46,74.11) 227.29,74.27 226.48,74.27 225.37,73.16 225.37,65.35 224.82,64.81 224.82,60.86 225.88,59.81 225.88,53.68 222.08,49.88 214.79,49.88 210.95,46.04 199.33,46.04 198.75,46.63 192.79,46.63 190.01,49.41 188.46,49.41 180,57.87 180,60.68 178.03,62.65 178.03,63.75 176.67,65.11 176.67,77.61 174.26,80.02 174.26,81.56 172.75,83.07 171.34,83.07 168.68,85.73 157.83,85.73 154.34,89.21 142.54,89.21 142.35,89.02 131.73,89.02 131.56,88.85 131.56,88.5 131.64,88.42 131.82,88.42 132,88.24 v4(132,88.1)
  GND5 w0.088: v4(132,88.1) 131.87,87.97 v5(131.87,87.48) ; v5(228.05,74.18) 227.93,74.3 227.65,74.3 v4(227.46,74.11)
  BOTTOM w0.076: 131.77,85.09 131.77,85.07 131.76,85.07 131.76,84.79 132.37,84.27 132.37,83.15 arc(132.34,83) 132.26,82.88 131.97,82.59 arc(131.78,82.34) 131.67,82.05 arc(131.59,81.82) 131.48,81.6 arc(131.4,81.41) 131.41,81.2 arc(131.42,81.04) 131.4,80.87 131.39,80.8 arc(131.38,80.66) 131.42,80.53 arc(131.46,80.34) 131.41,80.16 arc(131.36,80.04) 131.37,79.92 arc(131.38,79.88) 131.4,79.85 arc(131.45,79.81) 131.51,79.8 131.53,79.8 arc(131.56,79.82) 131.59,79.84 131.63,79.88 arc(131.65,79.95) UC1.C42
  BOTTOM w0.088: JNGFF2.55 229.4,75.15 229.23,75.32 229.07,75.32 228.69,74.94 228.69,74.53 228.44,74.28 228.16,74.28 v5(228.05,74.18) ; 131.77,85.09 131.77,87.09 arc(131.77,87.12) 131.79,87.15 131.8,87.16 arc(131.84,87.18) 131.88,87.19 arc(131.96,87.21) 132.02,87.25 132.02,87.25 arc(132.06,87.33) 132.02,87.41 132.02,87.41 arc(131.95,87.46) v5(131.87,87.48)
CLK_PCIE_P1: length 151.1
  IN1 w0.062: v4(240.13,44.55) 239.91,44.33 239.24,44.33 239.11,44.46 238.32,44.46 237.32,45.46 237.32,48.12 236.42,49.03 232.07,49.03 231.44,48.4 226.69,48.4 225.57,49.51 215.06,49.51 211.2,45.65 199.2,45.65 198.6,46.26 192.53,46.26 189.76,49.02 188.32,49.02 179.64,57.71 179.64,60.53 177.66,62.5 177.66,63.6 176.17,65.1 176.17,77.25 173.78,79.64 173.78,81.28 172.41,82.66 171.17,82.66 168.51,85.32 157.68,85.32 154.7,88.3 138.27,88.3 138.17,88.4 133.52,88.4 133.06,87.94 133.06,87.48 v4(132.89,87.31)
  GND5 w0.076: v5(239.59,44.58) 239.7,44.47 240.06,44.47 v4(240.13,44.55)
  GND5 w0.088: v5(132.99,86.8) 133.09,86.91 133.09,87.11 v4(132.89,87.31)
  BOTTOM w0.076: UC1.A42 131.64,81.31 arc(131.58,81.23) 131.6,81.13 arc(131.68,81.07) 131.78,81.09 arc(131.93,81.25) 131.98,81.46 arc(131.98,81.67) 132,81.87 arc(132.01,81.95) 132.02,82.03 arc(132.13,82.37) 132.34,82.65 133.03,83.35 arc(133.08,83.42) 133.1,83.5 133.1,86.62 arc(133.08,86.69) 133.05,86.74 v5(132.99,86.8)
  BOTTOM w0.088: v5(239.59,44.58) 239.69,44.48 239.95,44.48 240.11,44.65 JNGFF1.47
CLK_PCIE_P3: length 175.9
  IN1 w0.062: v2(133,81.92) 133,81.7 133.06,81.64 133.29,81.64 133.32,81.62 133.32,81.52 132.98,81.18 120.63,81.18 119.35,82.46 115.37,82.46 115,82.83 112.94,82.83 109.63,86.13 95.22,86.13 93.16,84.07 75.34,84.07 74.73,84.68 66.23,84.68 65.26,83.71 59.12,83.71 57.71,82.3 51.71,82.3 49.76,80.36 49.76,78.2 42.81,71.26 42.81,67 42.26,66.44 42.26,62.2 42.72,61.73 42.72,56.64 43.01,56.35 43.01,47.93 41.98,46.9 41.98,45.33 39.79,43.14 39.79,40.62 38.71,39.55 38.71,38.51 39.44,37.78 39.55,37.78 39.61,37.72 v4(39.61,37.54)
  IN4 w0.062: v4(39.61,37.54) 39.67,37.6 39.98,37.6 40.14,37.44 40.14,36.24 34.59,30.69 29.19,30.69 21.03,22.53 21.03,16.43 v4(20.81,16.2)
  GND5 w0.088: v4(20.81,16.2) 21.01,16 21.01,15.8 20.91,15.69 v5(20.91,15.58)
  BOTTOM w0.076: v2(133,81.92) 133.16,81.77 133.16,81.77 133.22,81.7 133.22,81.58 arc(133.21,81.46) 133.15,81.35 arc(133.08,81.22) 133.03,81.08 arc(133.01,80.93) 133.04,80.78 arc(133.06,80.65) 133.04,80.52 arc(133,80.34) 133.04,80.16 arc(133.07,80) 133.02,79.86 arc(132.98,79.8) 132.92,79.75 arc(132.81,79.73) 132.71,79.8 arc(132.69,79.91) 132.76,80.01 UC1.C40
  BOTTOM w0.088: v5(20.91,15.58) 20.91,15.52 21.01,15.41 21.01,15.09 20.85,14.92 JNGFF3.55
CLK_PCIE_P5: length 145.8
  IN1 w0.062: v4(51.71,80.96) 51.71,80.97 51.91,81.16 51.91,81.53 52.09,81.72 57.85,81.72 59.33,83.2 68.17,83.2 69.14,84.17 74.52,84.17 75.12,83.56 93.37,83.56 95.41,85.61 109.31,85.61 112.67,82.25 114.85,82.25 115.8,81.31 117.32,81.31 117.98,80.65 133.23,80.65 133.6,81.02 134.26,81.02 134.49,80.79 v4(134.49,80.1)
  IN4 w0.062: v4(35.3,54.97) 35.3,55.25 35.36,55.31 35.63,55.31 35.69,55.25 35.69,54.23 35.93,53.99 36.55,53.99 37.91,55.35 37.91,73.19 40.2,75.48 43.29,75.48 43.9,76.1 43.9,81.7 42.93,82.67 42.93,86.99 43.27,87.32 43.51,87.32 43.53,87.33 47.15,87.33 47.87,86.61 47.87,84.29 49.83,82.33 51.33,82.33 52.04,81.62 52.04,81.3 51.71,80.97 v4(51.71,80.96)
  GND5 w0.076: v4(134.49,80.1) 134.24,79.86 134.24,79.57 133.94,79.26 133.94,79.08 v5(134.03,78.99)
  GND5 w0.088: v5(35.63,55.35) 35.63,55.3 v4(35.3,54.97)
  BOTTOM w0.076: UC1.E38 134,78.6 133.9,78.7 133.9,78.87 v5(134.03,78.99)
CLK_TP_SIO_I2C_DAT: length 140.7
  TOP w0.086: v3(175.66,34.63) 175.63,34.63 RZ23.2 RZ348.2 CZ81.1 ; UE1.E10 266.23,61.76 v2(266.23,61.81)
  GND1 w0.086: v3(175.66,34.63) 175.81,34.48 v4(175.81,33.99)
  IN2 w0.061: v4(175.81,33.99) 177.53,32.27 180.02,32.27 181.05,31.24 191.92,31.24 192.4,30.77 194.67,30.77 194.97,31.07 195.74,31.07 196.27,30.54 200.75,30.54 201.21,30.08 207.73,30.08 209.98,32.33 215.53,32.33 216.52,31.35 224.07,31.35 227.19,28.23 233.68,28.23 233.85,28.05 235.17,28.05 235.68,28.56 251.38,28.56 252.21,27.73 253.11,27.73 257.4,32.01 257.4,34.22 258.69,35.52 258.69,39.34 260.91,41.56 260.91,42.26 262.56,43.92 262.56,45.27 263.66,46.37 264.38,46.37 268.45,50.43 269.84,50.43 270.35,50.94 270.35,52.91 270.74,53.3 270.74,54.3 272.33,55.89 272.33,58.32 271.4,59.25 271.4,63.45 270.73,64.12 268.62,64.12 268.19,63.69 268.19,62.47 267.91,62.19 266.79,62.19 266.41,61.81 v2(266.23,61.81)
  BOTTOM w0.086: v2(266.23,61.81) 266.45,61.81 266.84,62.2 267.2,62.2 267.38,62.38 267.38,62.94 v1(267.34,62.98)
CLK_TP_SIO_R: length 7.4
  TOP w0.086: RZ19.2 RZ23.1 175.18,33.56 v2(175.09,33.47) 174.77,33.47 v1(174.55,33.26)
  BOTTOM w0.086: v2(175.09,33.47) 175.75,34.13 JKBTP1.14 175.75,35.47 175.49,35.72 174.56,35.72 174.09,36.2 173.8,36.2 CZ89.1
CLKREQ_PCIE#0: length 2.4
  TOP w0.086: RC373.2 230.07,75.35 v1(230.61,75.9) JNGFF2.52
CLKREQ_PCIE#0_R: length 142.7
  TOP w0.086: RC373.1 230.07,73.47 229.38,72.78 229.2,72.78 228.92,72.5 228.92,71.61 228.01,70.7 228.01,68.79 v2(227.5,68.28) ; RC189.1 156.99,54.67 v3(156.99,55.56) v1(155.95,55.56) 155.76,55.56 154.93,56.38 154.93,56.93 151.83,60.03 151.83,62.24 151.32,62.75 v2(151.19,62.75)
  GND1 w0.086: v4(157.6,56.07) 157.09,55.56 v3(156.99,55.56)
  IN2 w0.061: v4(229.81,37.42) 229.35,37.88 222.57,37.88 221.46,36.77 218.98,36.77 217.61,38.14 208.3,38.14 206.9,39.53 196.2,39.53 194.24,37.58 191.99,37.58 191.83,37.41 186.8,37.41 186.7,37.51 177.66,37.51 175.43,39.74 174.67,39.74 169.69,44.73 167.57,44.73 165.59,46.71 165.59,47.84 164.09,49.34 163.19,49.34 160.31,52.22 160.31,53.14 158.73,54.72 158.73,55.14 157.8,56.07 v4(157.6,56.07)
  GND5 w0.086: v4(229.81,37.42) 229.81,38.01 v5(229.76,38.06)
  BOTTOM w0.086: UC1.AR10 151.09,62.75 v2(151.19,62.75) ; v2(227.5,68.28) 228.73,68.28 229.75,67.27 229.75,65.85 230.75,64.84 230.75,62.09 227.11,58.45 227.11,52.56 224.78,50.23 224.78,46.87 227.17,44.48 229.12,44.48 229.71,43.9 229.71,38.11 v5(229.76,38.06)
CLKREQ_PCIE#1: length 118.4
  TOP w0.086: RC374.2 157.53,51.17 157.28,51.17 v1(157.05,50.95) 157.01,50.91 157.01,50.26 157.23,50.05 157.23,47.36 157.04,47.18 v3(157.04,46.19) ; v3(223.77,27.44) 224.44,28.11 228.02,28.11 228.58,28.67 v2(228.58,32.27)
  GND1 w0.076: v3(223.77,27.44) 223.74,27.47 v4(223.21,27.47)
  GND1 w0.086: v4(157.49,45.63) 157.39,45.63 157.39,45.74 157.04,46.08 v3(157.04,46.19)
  IN2 w0.061: v4(223.21,27.47) 222.8,27.87 222.27,27.87 221.42,27.03 200.96,27.03 199.5,28.48 188.27,28.48 187.2,29.55 180.61,29.55 179.57,30.59 174.39,30.59 172.81,32.18 170.21,32.18 168.75,30.72 164.11,30.72 159.47,35.36 159.47,40.75 157.39,42.83 157.39,45.63 v4(157.49,45.63)
  IN4 w0.051: v2(228.58,32.27) 232.15,35.85 234.65,35.85 235.44,36.63 239.23,36.63 240.59,37.99 240.59,38.75 241.48,39.64 241.48,42.88 v4(241.42,42.93)
  GND5 w0.086: v5(241.9,42.68) 241.67,42.68 v4(241.42,42.93)
  BOTTOM w0.086: v5(241.9,42.68) 241.9,42.81 241.56,43.15 JNGFF1.53
CLKREQ_PCIE#1_R: length 15.6
  TOP w0.086: RC374.1 RC47.1 159.25,52.56 159.94,53.25 159.94,55.01 v1(158.25,56.7) 157,57.95 156.43,57.95 152.72,61.65 152.72,62.4 v2(153.02,62.7)
  BOTTOM w0.086: v2(153.02,62.7) 152.79,62.7 UC1.AT7
CLKREQ_PCIE#2_R: length 252.3
  TOP w0.086: RC50.1 150.7,65.01 150.7,62.98 150.51,62.78 150.51,62.09 v1(150.74,61.86) 151.35,61.86 v3(151.55,62.06)
  GND1 w0.086: v4(152.11,62.09) 152.09,62.06 v3(151.55,62.06) ; v3(19.77,14.31) v4(19.77,14.83)
  IN1 w0.051: v4(19.77,14.83) 14.2,14.83 12.34,12.96 v2(11.85,12.96)
  IN2 w0.061: v4(159.3,51.63) 159.3,52.81 151.64,60.47 151.64,61.62 v4(152.11,62.09)
  IN3 w0.061: v4(19.77,14.83) 27.55,14.83 30.46,17.74 30.46,23.11 31.66,24.31 31.66,25.27 32.21,25.83 32.77,25.83 33.12,26.17 33.94,26.17 38.82,31.05 45,31.05 45.75,30.3 50.68,30.3 50.85,30.13 58.82,30.13 58.96,29.99 91.55,29.99 91.96,29.58 105.31,29.58 108.59,26.3 142.19,26.3 144.58,28.7 155.33,28.7 158.08,25.94 170.62,25.94 171.02,26.35 173.94,26.35 174.37,26.77 176.46,26.77 176.68,27 178.74,27 178.97,27.24 v4(178.97,27.99)
  IN4 w0.051: v4(178.97,27.99) 178.97,29.12 178.63,29.46 176.27,29.46 175.4,30.32 172.75,30.32 172,31.07 170.67,31.07 170.52,31.23 170.52,31.87 169.45,32.94 168.91,32.94 163.42,38.43 163.42,42.88 160.92,45.38 159.39,45.38 158.57,46.2 158.47,46.2 155.97,48.7 155.49,48.7 154.72,49.48 154.72,50.34 154.14,50.91 154.14,52.07 154.73,52.65 158.28,52.65 v4(159.3,51.63)
  GND5 w0.086: v4(152.11,62.09) 152.09,62.09 151.71,62.46 v5(151.64,62.46)
  BOTTOM w0.086: v2(11.85,12.96) 11.21,12.33 RT456.1
CLKREQ_PCIE#3: length 172.3
  TOP w0.086: v2(145.15,27.62) 145.53,27.62 147.66,29.74 150.98,29.74 154.27,33.03 155.89,33.03 162.68,39.82 162.68,41.39 159.86,44.21 159.86,47.61 v6(161.03,48.78) 162.01,49.77 RC376.2
  IN3 w0.061: v2(145.15,27.62) 142.84,25.31 108.18,25.31 104.9,28.58 91.55,28.58 91.2,28.93 58.62,28.93 58.41,29.14 50.44,29.14 50.27,29.31 38.49,29.31 33.27,24.09 32.86,24.09 31.46,22.69 31.46,17.26 28.01,13.8 23.2,13.8 JNGFF3.52
CLKREQ_PCIE#3_R: length 18.7
  TOP w0.086: v1(161.9,52.98) 161.74,53.15 v3(161.43,53.15) 161.38,53.09 161.38,53.04 161,52.66 RC59.1 RC376.1
  GND1 w0.086: v3(161.43,53.15) v4(161.43,53.68)
  IN4 w0.051: v4(161.43,53.68) 161.38,53.73 160.94,53.73 158.05,56.63 155.62,56.63 151.05,61.19 151.05,61.88 v4(151.07,61.9)
  GND5 w0.086: v4(151.07,61.9) 150.77,61.9 v5(150.54,62.14)
  BOTTOM w0.086: UC1.AT10 v5(150.54,62.14)
CLKREQ_PCIE#4_R: length 4.8
  TOP w0.086: v3(153.51,61.38) 154.32,62.19 154.68,62.19 RC51.1
  GND1 w0.086: v4(153.13,61.07) 153.2,61.07 v3(153.51,61.38)
  GND5 w0.086: v5(152.8,61.43) 152.8,61.4 v4(153.13,61.07)
  BOTTOM w0.086: v5(152.8,61.43) 152.03,61.43 UC1.AU8
CLKREQ_PCIE#5: length 178.6
  TOP w0.086: v3(172.03,66) 172.03,65.85 v6(172.46,65.41) 173.27,64.6 174.54,64.6 175.68,63.46 RC378.2
  GND1 w0.088: v4(171.43,65.96) 171.48,66 v3(172.03,66)
  IN3 w0.061: v4(171.43,65.96) 171.47,65.99 171.47,67.59 170.07,68.98 170.07,72.1 157.1,85.07 147.21,85.07 146.53,85.75 140,85.75 139.77,85.52 130.76,85.52 129.17,87.11 125.32,87.11 124.51,87.92 106.62,87.92 105.98,87.28 104.89,87.28 103.16,85.55 80.7,85.55 78.37,87.89 78.06,87.89 78.06,87.89 71,87.89 70.48,87.36 70.18,87.36 66.64,87.36 65.72,86.45 64.09,86.45 63.74,86.1 61.01,86.1 58.63,83.72 44.15,83.72 v4(43.35,82.92)
  GND5 w0.086: v5(43.9,82.83) 43.44,82.83 v4(43.35,82.92)
  BOTTOM w0.086: UT1.AC5 38.44,61.48 39.44,61.48 39.62,61.65 41.83,61.65 42.26,62.09 42.26,63.8 42.68,64.22 44.49,64.22 45.13,64.86 45.13,69.68 44.07,70.74 44.07,82.66 v5(43.9,82.83)
CLKREQ_PCIE#5_R: length 37.6
  TOP w0.086: v3(168.98,53.4) 169.14,53.4 172.41,56.66 172.41,58.1 173.87,59.56 176.42,59.56 176.89,60.03 176.89,62.15 v1(176.7,62.34) 175.79,62.34 RC378.1 ; v3(153.51,62.11) 154.27,62.87 RC190.1
  GND1 w0.086: v3(168.98,53.4) v4(168.34,53.4) ; v4(153.03,62.09) 153.48,62.09 v3(153.51,62.11)
  IN4 w0.051: v4(168.34,53.4) 168.28,53.34 166.47,53.34 166.13,53.68 165.17,53.68 162.98,55.86 162.98,55.91 162.93,55.96 162.93,56.78 160.8,58.91 155.82,58.91 153.54,61.2 153.54,61.25 153.03,61.76 v4(153.03,62.09)
  GND5 w0.086: v4(153.03,62.09) 152.75,61.81 v5(152.56,61.81)
