# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_IO1: length 147.8
  TOP w0.086: UE1.L4 v2(261.42,56.24) ; v1(193.93,33.12) 193.93,32.85 194.05,32.74 v2(194.05,32.16) 194.05,32.04 193.98,31.97 JESPI.4
  IN4 w0.051: v2(261.42,56.24) 261.86,56.68 262.4,56.68 262.63,56.9 262.63,58.72 262.36,58.99 261.94,58.99 261.79,59.14 261.79,59.56 261.52,59.83 259.94,59.83 256.14,56.03 255.04,56.03 253.07,54.07 252.05,54.07 251.35,53.36 251.35,45.99 252.32,45.01 252.32,41.91 253.13,41.09 253.13,39.18 253.7,38.61 253.7,33.26 251,30.56 237.71,30.56 236.36,31.91 230.58,31.91 230.12,31.45 226.06,31.45 225.36,32.15 218.95,32.15 218.56,31.76 210.82,31.76 210.14,31.09 209.11,31.09 208.81,30.79 205.78,30.79 205.45,31.12 196.08,31.12 195.68,31.53 194.68,31.53 v2(194.05,32.16) 193.66,32.55 193.21,32.55 192.32,31.66 180.55,31.66 180.08,32.12 178.92,32.12 176.18,34.86 173.11,34.86 172.5,35.47 172.5,36.93 169.03,40.4 169.03,44.02 165.75,47.29 165.75,48.38 164.48,49.65 164.48,49.89 163.82,50.55 v4(163.8,50.55)
  GND5 w0.086: v4(163.8,50.55) 163.77,50.55 163.34,50.12 v5(163.31,50.12)
ESPI_IO1_R: length 18.3
  BOTTOM w0.076: UC1.BA13 148.81,59.14 149.08,58.88 149.08,57.53 151.1,55.52
  BOTTOM w0.086: RC367.1 162.07,50.12 158.78,53.42 v1(155.34,53.42) 153.2,53.42 151.1,55.52
ESPI_IO2: length 150.7
  TOP w0.086: UE1.G6 v2(263.02,59.44) ; v1(195.14,32.65) 194.71,32.22 v2(194.71,32.16) 194.71,32.04 194.48,31.81 JESPI.5
  IN4 w0.051: v2(263.02,59.44) 262.71,59.44 262.16,59.99 259.86,59.99 256.77,56.9 255.24,56.9 253.71,55.38 253.71,54.95 253,54.24 251.98,54.24 251.18,53.43 251.18,45.92 252.15,44.94 252.15,41.84 252.96,41.02 252.96,39.1 253.53,38.54 253.53,33.3 250.94,30.71 237.8,30.71 236.43,32.08 230.51,32.08 230.05,31.62 226.11,31.62 225.42,32.3 218.89,32.3 218.5,31.91 210.76,31.91 210.08,31.24 209.04,31.24 208.75,30.95 206.32,30.95 206.32,30.95 205.84,30.95 205.51,31.28 196.15,31.28 195.74,31.68 195.18,31.68 v2(194.71,32.16) 194.17,32.7 193.15,32.7 192.26,31.81 180.61,31.81 180.15,32.28 178.98,32.28 176.25,35.01 173.2,35.01 172.67,35.54 172.67,37 170.1,39.58 170.1,40.58 169.2,41.48 169.2,44.06 165.9,47.35 165.9,48.44 164.63,49.71 164.63,50.29 162.89,52.03 160.66,52.03 v4(159.77,51.14)
  GND5 w0.086: v4(159.77,51.14) v5(159.25,51.14)
  BOTTOM w0.086: v5(159.25,51.14) 159.25,51.24 RC368.2
ESPI_IO2_R: length 12.6
  BOTTOM w0.076: UC1.BB13 148.81,58.51 148.91,58.41 148.91,57.44 150.84,55.51
  BOTTOM w0.086: 150.84,55.51 153.35,53 v1(153.7,53) 158.41,53 RC368.1
ESPI_IO3: length 142.8
  TOP w0.086: UE1.L5 v2(262.22,56.24)
  GND1 w0.086: v4(195.27,30.62) 195.27,30.69 v3(194.96,31)
  IN4 w0.051: v4(162.73,51.01) 163,50.74 163,46.56 166.86,42.7 167.21,42.7 167.69,42.22 167.69,40.12 169.33,38.47 169.33,36.92 170.41,35.84 170.65,35.84 172.1,34.38 176,34.38 178.72,31.67 179.89,31.67 180.36,31.2 192.2,31.2 192.82,30.59 195.24,30.59 v4(195.27,30.62) 195.27,30.59 195.34,30.51 205.2,30.51 205.92,29.79 209.71,29.79 211.07,31.15 218.82,31.15 219.21,31.54 225.06,31.54 225.83,30.76 231.47,30.76 231.94,31.23 236.04,31.23 237.32,29.95 251.25,29.95 254.38,33.07 254.38,38.89 253.81,39.46 253.81,41.38 253,42.19 253,47.15 252.03,48.12 252.03,52.37 252.42,52.76 252.93,52.76 255.06,54.9 256.4,54.9 258.26,56.75 258.26,56.98 258.67,57.39 v2(258.72,57.39)
  GND5 w0.086: v5(163.23,51.01) v4(162.73,51.01)
  BOTTOM w0.086: v2(258.72,57.39) 258.74,57.39 259.5,56.63 261.83,56.63 v2(262.22,56.24)
ESPI_IO3_R: length 18.7
  BOTTOM w0.076: 151.17,55.76 151.09,55.76 149.25,57.6 149.25,59.24 149.08,59.4 149.08,59.83 UC1.AY12
  BOTTOM w0.086: RC369.1 161.49,51.01 158.82,53.68 156.91,53.68 v1(156.84,53.76) 156.69,53.9 153.03,53.9 151.17,55.76
ESPI_RESET#: length 154.9
  TOP w0.086: UE1.K6 v2(263.02,57.04) ; RE560.2 199.13,33.57 199.47,33.91 199.47,34.57 199.46,34.58 v1(199.46,34.93) 199.46,35.09 198.41,36.13 198.41,38.72 v3(198.19,38.95)
  GND1 w0.086: v4(198.19,38.42) 198.19,38.42 v3(198.19,38.95)
  IN2 w0.061: v4(157.7,55.33) 158.27,55.33 158.54,55.06 158.54,54.64 160.12,53.06 160.12,52.15 163.13,49.13 163.13,48.9 167.49,44.54 169.61,44.54 174.95,39.2 175.71,39.2 177.63,37.28 185.05,37.28 185.06,37.28 185.21,37.28 185.77,36.72 186.42,36.72 186.9,37.2 191.88,37.2 192.07,37.38 194.31,37.38 195.8,38.87 197.73,38.87 v4(198.19,38.42) 198.19,38.66 198.75,39.23 206.94,39.23 208.22,37.95 217.53,37.95 218.9,36.58 234.24,36.58 235.71,35.12 239.16,35.12 241.15,33.13 246.88,33.13 246.96,33.21 247.29,33.21 247.49,33.41 250.45,33.41 251.1,34.06 251.69,34.06 253.7,36.07 253.7,41.43 255.89,43.63 255.89,45.73 257.81,47.65 257.81,49.5 258.36,50.05 259.62,50.05 260.26,50.69 260.26,52.28 260.56,52.58 261.28,52.58 263.44,54.74 263.44,56.61 v2(263.02,57.04)
  GND5 w0.086: v4(157.7,55.33) 157.7,54.95 v5(157.48,54.73)
  BOTTOM w0.076: UC1.BA11 149.74,59.08 149.74,57.81 150.76,56.79 151.15,56.79
  BOTTOM w0.086: v5(157.48,54.73) 157.43,54.78 153.16,54.78 151.15,56.79
EXPANDER_ALERT#: length 3.6
  TOP w0.086: UE2.7 253.88,78.68 253.47,78.28 250.89,78.28 T267.1
FB_1.8VALW: length 4.5
  TOP w0.117: v1(210.99,26.88) 210.71,27.16 PR501.2
  TOP w0.254: PR501.2 PC503.2 209.06,27.14 PR506.1 208.2,27.34 PU501.6
FB_+1VALWP: length 3.3
  BOTTOM w0.203: PU301.14 64.63,72.03 65.2,71.45 PR306.2
  BOTTOM w0.254: PR306.2 65.49,71.52 PR308.2 PR311.1
FB_GT: length 4.1
  TOP w0.254: PR650.1 76.76,75.97 PR645.2 76.61,76.12 76.25,76.12 v2(76.14,76.01)
  BOTTOM w0.203: PU602.17 75.94,75.93 76.01,76.01 v2(76.14,76.01)
  BOTTOM w0.254: v2(76.14,76.01) 76.17,76.03 76.8,76.03 PR648.2
FB_VSA: length 3.9
  BOTTOM w0.203: PR649.1 73.2,72.37 72.59,72.98 72.59,73.21 72.49,73.31 PU602.25 ; PR652.1 PR646.1
  BOTTOM w0.254: PR646.1 73.54,72.07 PR649.1
FCCM_GT: length 4.4
  BOTTOM w0.203: PU602.21 74.09,73.65 74.84,72.89 75.52,72.89 76.23,72.19 76.58,72.19 77.06,71.71 PR1299.1
FCCM_IA: length 36.7
  GND1 w0.203: v3(86.23,62.85) v4(85.73,62.85)
  IN1 w0.203: v2(76.19,79.5) 76.17,79.48 76.17,78.86 75.2,77.89 75.2,74.25 75.57,73.88 77.86,73.88 80.07,71.67 85.6,71.67 v2(85.73,71.55) 85.87,71.55 86.31,71.1 86.31,69.91 86.11,69.71 83.03,69.71 81.64,68.32 81.64,64.36 82.84,63.16 85.42,63.16 v4(85.73,62.85)
  BOTTOM w0.203: v2(76.19,79.5) 75.52,79.5 75.25,79.24 75.25,78.53 75.05,78.33 PU602.11 ; PR659.1 v2(85.73,71.55)
FCCM_VSA: length 33.6
  IN1 w0.203: v2(69.97,73.41) 69.97,70.62 73.58,67.01 73.58,58.38 78.03,53.92 78.03,51.74 78.86,50.91 84.01,50.91 v4(84.15,50.77)
  GND5 w0.203: v4(84.15,50.77) 84.37,50.98 v5(84.59,50.98)
  BOTTOM w0.203: v2(69.97,73.41) 70.22,73.41 70.31,73.33 70.65,73.33 70.89,73.57 PU602.29
FIVR_EN: length 2.5
  BOTTOM w0.086: RC219.1 75.18,90.08 73.79,90.08 RC217.1 RC218.1
FIVR_EN_R: length 14.8
  TOP w0.086: v3(63.9,89.52) 63.44,89.98 63.44,90.86 63.27,91.04 JXDP1.45
  GND1 w0.086: v3(63.9,89.52) 63.96,89.52 v4(64.47,89)
  GND5 w0.086: v4(64.47,89) 64.47,89.2 64.71,89.44 65.27,89.44 65.63,89.09 v5(65.63,89.01)
  BOTTOM w0.086: RC132.1 RC126.2 RC217.2 72.62,90.33 71.93,90.33 71.35,89.75 v1(71.35,89.54) 70.83,89.02 68.83,89.02 68.61,88.81 65.83,88.81 v5(65.63,89.01)
GPP_B22: length 1.9
  GND1 w0.086: v4(154.58,64.09) 154.58,64.51 v3(154.49,64.6)
  GND5 w0.086: v4(154.58,64.09) 154.3,64.09 v5(153.81,64.58)
  BOTTOM w0.086: UC1.AN5 v5(153.81,64.58)
GPP_B23: length 6.2
  TOP w0.086: RC317.1 157.82,64.6 v2(157.85,64.63)
  BOTTOM w0.086: v2(157.85,64.63) 156.47,64.63 156.19,64.91 153.76,64.91 153.63,64.78 152.84,64.78 UC1.AM7
GPP_C5: length 2.6
  TOP w0.086: RC25.1 158,71.28 v2(158,71.28)
  BOTTOM w0.076: v2(158,71.28) 156.45,71.28 156.35,71.18 UC1.W1
GPS_DISABLE#: length 76.1
  TOP w0.086: DZ6.1 229.06,80.41 229.02,80.5 v2(229.02,80.5) ; v2(244.49,78.77) 244.05,78.77 v1(243.87,78.95) ; UE1.H5 v2(262.22,58.64)
  TOP w0.117: v2(244.49,78.77) 244.31,78.6 RE12.1
  IN1 w0.051: v2(229.02,80.5) 229.02,80.91 227.15,82.79 227.15,87.38 226.89,87.64 226.89,91.32 228.01,92.44 238.7,92.44 240.28,90.86 240.66,90.86 245.2,86.32 245.2,79.49 v2(244.49,78.77)
  BOTTOM w0.086: v2(244.49,78.77) 243.95,78.23 243.95,71.6 250.29,65.26 251.39,65.26 251.72,64.93 251.72,64.63 252.84,63.51 255.09,63.51 255.49,63.12 255.49,61.58 258.84,58.23 261.81,58.23 v2(262.22,58.64)
GPU_B+:
  vias: v2(77.86,59.22) v2(77.86,58.63) v2(78.44,59.22) v2(78.44,58.63) v2(86.23,58.45) v2(87.39,58.45) v2(89.05,59.18) v2(89.05,58.51) v2(90.26,59.18) v2(90.26,58.51) v6(83.96,58.96)
GT_SNUB: length 1.8
  TOP w0.086: PR669.2 v6(95.7,57.79)
GT_SW: length 1.5
  TOP w0.086: PR669.1 v6(99.84,59.55)
  vias: v2(96.58,61.51) v2(96.58,60.93)
H_CATERR#: length 7.7
  BOTTOM w0.076: UC1.D63 120.61,79.7 120.69,79.97 120.69,80.08 120.77,80.36 120.81,80.52 120.82,80.54 120.83,80.56 120.83,80.81 120.79,80.9 120.79,81.09 120.82,81.15 120.83,81.18 120.83,81.54 120.73,81.64 120.73,82.5 119.7,83.52
  BOTTOM w0.086: RC79.1 118.28,85.49 v1(118.81,84.96) 119.37,84.4 119.37,83.85 119.7,83.52
H_CPU_SVIDALRT#: length 15.9
  BOTTOM w0.076: UC1.B63 120.15,80.67 120.05,80.78 120.05,80.9 120.18,81.03 120.18,81.14 120.05,81.28 120.05,82.06 119.15,82.95 119.15,83.09 118.95,83.3
  BOTTOM w0.086: v1(114.95,87.94) 114.52,87.51 114.52,86.14 114.17,85.79 RC153.1 114.06,85.78 112.64,84.36 112.64,83.96 112.87,83.73 113.3,83.73 114.24,84.67 117.65,84.67 118.95,83.37 118.95,83.3
H_CPUPWRGD: length 15
  BOTTOM w0.086: RC77.2 104.45,84 CC300.1 105.44,83.12 v1(105.54,83.22) 105.8,83.49 109.05,83.49 110.97,81.57 114.05,81.57 114.41,81.21 115.63,81.21 115.84,81.01 116.81,81.01 117.12,81.32 UC1.A68
H_CPUPWRGD_R: length 1.1
  BOTTOM w0.086: T9.1 103.56,84.71 RC77.1
H_THERMTRIP#: length 224.3
  TOP w0.086: v3(242.08,67.37) 242.08,65.57 245,62.65 247.74,62.65 248.83,61.56 248.83,60.05 248.77,59.99 248.77,59.41 249.26,58.92 251.46,58.92 252.12,58.27 252.12,55.57 251.67,55.11 251.67,49.6 v1(251.67,49.6) 252.15,49.12 254.28,49.12 254.54,48.86 254.54,47.16 QE4.3
  GND1 w0.086: v4(241.7,66.99) v3(242.08,67.37)
  IN1 w0.051: v2(116.08,90.26) 116.08,90.3 116.88,91.1 123.07,91.1 v4(123.91,91.94)
  IN2 w0.061: v4(168.9,90.36) 169.08,90.36 172.72,86.71 172.72,86.28 174.41,84.58 174.41,80.42 177.07,77.76 177.07,66.56 177.16,66.47 177.16,64.99 177.87,64.28 177.87,60.39 179.36,58.89 179.36,55.75 185.05,50.06 186.69,50.06 188.15,48.6 189.93,48.6 191.78,46.76 200.56,46.76 200.56,46.76 200.98,46.76 200.98,46.76 201.03,46.76 202.01,45.77 211.49,45.77 213.15,47.44 213.32,47.44 215.84,47.44 216.36,46.91 216.36,46.33 216.86,45.84 219.15,45.84 222.46,49.14 223.12,49.14 227.03,53.05 227.03,59.38 228.41,60.77 229.23,60.77 229.65,61.19 229.65,61.66 233.49,65.5 236.38,65.5 238.13,67.26 241.43,67.26 v4(241.7,66.99)
  IN4 w0.051: v4(123.91,91.94) 123.91,93.32 125.88,95.29 144.9,95.29 149.67,90.51 152.54,90.51 154.12,92.08 156.81,92.08 157.83,91.07 168.19,91.07 v4(168.9,90.36)
  BOTTOM w0.076: UC1.C63 120.61,80.41 120.66,80.56 120.66,80.59 120.66,80.78 120.64,80.83 120.63,80.86 120.63,81.12 120.66,81.22 120.66,81.47 120.56,81.57 120.56,81.87 120.55,81.96 120.49,82.12 120.4,82.27 120.22,82.53 120.01,82.78 119.68,83.14 119.45,83.4 119.3,83.61 119.25,83.71
  BOTTOM w0.086: v2(116.08,90.26) 116.04,90.22 116.04,86.32 RC80.1 CC312.1 117.72,85.53 118.49,84.65 119.07,83.95 119.25,83.71
H_VCCST_PWRGD_XDP: length 4.1
  TOP w0.086: JXDP1.39 65.07,92.21 v2(65.7,92.85)
  BOTTOM w0.086: v2(65.7,92.85) 66.13,92.41 CC307.1 RC124.2 RC123.2
HDA_BIT_CLK: length 10.1
  BOTTOM w0.076: 144.92,53.77 144.92,57.01 144.11,57.82 144.11,58.13 143.71,58.53 143.71,58.8 143.76,58.92 143.76,59.06 143.7,59.29 143.7,59.41 143.77,59.62 143.87,59.73 143.97,59.84 UC1.AY22
  BOTTOM w0.086: RC93.2 145.76,50.96 145.76,52.93 v1(145.01,53.69) 144.92,53.77
HDA_BIT_CLK_R: length 132
  TOP w0.086: UA1.8 262.07,34.32 RA17.1 261.42,33.68 259.61,33.68 v2(259.04,34.25)
  IN1 w0.051: v4(248.33,33.82) 247.51,33 236.62,33 235.86,33.77 235.72,33.77 234.87,34.62 231.66,34.62 229.97,32.92 226.95,32.92 226.1,33.77 225.32,33.77 223.81,32.26 219.28,32.26 218.83,31.81 208.35,31.81 208.16,31.61 207.84,31.61 207.79,31.67 207.72,31.73 202.18,31.73 202.13,31.68 192.83,31.68 192.52,31.38 183.43,31.38 181.25,33.56 175.61,33.56 175.3,33.87 171.63,33.87 169.18,36.32 163.17,36.32 162.49,36.99 161.86,36.99 156.32,42.53 156.32,45.3 v4(152.95,48.68)
  GND5 w0.086: v5(152.6,49.01) 152.65,49.01 152.95,48.7 v4(152.95,48.68) ; v5(248.86,33.82) v4(248.33,33.82)
  BOTTOM w0.086: v5(248.86,33.82) 253.74,33.82 254.42,34.5 258.79,34.5 v2(259.04,34.25) ; v5(152.6,49.01) 152.57,49.03 146.52,49.03 CC27.1 145.71,49.74 RC93.1
HDA_RST#: length 11.9
  BOTTOM w0.076: UC1.AW22 143.8,60.37 143.8,60.37 143.65,59.9 143.58,59.67 143.58,59.59 143.52,59.43 143.52,59.29 143.59,59.07 143.59,58.95 143.54,58.84 143.54,58.46 143.66,58.33 143.94,58.06 143.94,57.53 144.69,56.78 144.69,55.35
  BOTTOM w0.086: CC331.1 143.96,50.91 RC95.2 144.98,50.91 145.46,51.39 v1(145.46,52.48) 144.69,53.25 144.69,55.35
HDA_RST#_R: length 146.8
  GND1 w0.086: v4(259.35,40.55) 259.89,41.08 v3(259.89,41.31)
  IN2 w0.061: v2(144.38,49.15) 149.43,49.15 152.47,46.1 157.65,46.1 158.01,45.75 158.01,45.22 157.83,45.04 157.83,43.03 159.92,40.94 159.92,36.49 161.96,34.45 162.47,34.45 162.96,33.97 162.96,33.21 163.64,32.52 165.63,32.52 165.93,32.22 165.93,31.69 166.27,31.35 166.67,31.35 v4(166.84,31.17)
  IN3 w0.061: v4(166.84,31.17) 167.19,31.17 168.99,29.37 169.72,29.37 169.92,29.17 175.33,29.17 176.35,30.2 179.37,30.2 181.94,27.63 199.39,27.63 200.49,28.73 207.72,28.73 208.47,27.97 211.59,27.97 212.65,29.04 212.65,29.51 213.22,30.08 218.87,30.08 220.53,28.43 231.79,28.43 232.53,29.17 254.71,29.17 256.43,30.9 258.7,30.9 259.5,31.7 259.5,35.11 259.35,35.26 v4(259.35,40.55)
  BOTTOM w0.086: RC95.1 144.82,49.59 v2(144.38,49.15) 143.65,49.15 v1(142.91,49.89)
HDA_SDIN0: length 145
  TOP w0.086: v3(259.07,32.88) 260.75,32.88 260.8,32.93 RA9.1 ; CC332.1 145.81,52.85 v2(145.81,55.06)
  GND1 w0.117: v3(259.07,32.88) v4(258.58,32.88)
  IN2 w0.061: v4(167.23,32.06) 167.23,32.46 164.67,35.02 162.19,35.02 160.48,36.73 160.48,41.17 159.72,41.94 159.72,44.57 157.52,46.77 152.54,46.77 148.38,50.93 148.38,52.01 145.81,54.58 v2(145.81,55.06)
  IN3 w0.061: v4(258.58,32.88) 258.17,32.47 257.37,32.47 254.45,29.55 229.5,29.55 229.24,29.81 227.73,29.81 226.72,28.81 220.68,28.81 219.03,30.46 213.07,30.46 212.28,29.67 212.28,29.2 211.43,28.35 208.63,28.35 207.8,29.17 200.3,29.17 199.2,28.08 182.12,28.08 179.56,30.64 176.23,30.64 175.13,29.55 170.08,29.55 169.87,29.75 169.15,29.75 167.23,31.67 v4(167.23,32.06)
  BOTTOM w0.076: UC1.BA21 144.57,59.64 144.57,58.63 144.91,58.29 144.91,57.88 145.68,57.11 145.68,56.35
  BOTTOM w0.086: v2(145.81,55.06) v1(145.81,56.22) 145.68,56.35
HDA_SDIN0_R: length 2.4
  TOP w0.086: UA1.10 262.53,33.52 261.97,32.95 RA9.2
HDA_SDOUT: length 25
  TOP w0.086: RC187.1 157.65,46.21 RC223.2 157.27,45.83 156.15,45.83 153.52,48.46 153.52,48.65 v1(152.14,50.03) 151.71,50.46 150.82,50.46 150.46,50.82 148.9,50.82 148.35,50.28 RC94.2 146.93,50.25 v3(146.65,50.53)
  GND1 w0.086: v4(146.7,51.32) 146.7,50.58 v3(146.65,50.53)
  GND5 w0.086: v5(146.45,50.86) 146.45,51.06 v4(146.7,51.32)
  BOTTOM w0.076: UC1.BB22 144.4,58.27 144.4,57.92 145.17,57.15 145.17,54.7
  BOTTOM w0.086: 145.17,54.7 146.01,53.86 146.01,51.83 146.6,51.24 CC333.1 146.47,50.89 v5(146.45,50.86)
HDA_SDOUT_R: length 139
  TOP w0.086: RC94.1 151.43,50.25 156.94,44.73 157.24,44.73 v3(157.56,44.41) ; v2(258.59,32.19) 262.07,32.19 v1(263,33.12) UA1.11
  GND1 w0.086: v4(158.39,44.07) 157.9,44.07 v3(157.56,44.41)
  IN2 w0.061: v4(166.44,31.78) 166.24,31.99 166.24,32.18 165.7,32.71 163.72,32.71 163.15,33.28 163.15,34.05 162.55,34.64 162.04,34.64 160.11,36.57 160.11,41.01 158.39,42.74 v4(158.39,44.07)
  IN3 w0.061: v4(166.44,31.78) 166.44,31.78 166.61,31.61 167.02,31.61 169.07,29.56 169.8,29.56 170,29.36 175.21,29.36 176.27,30.42 179.46,30.42 182.03,27.85 199.3,27.85 200.39,28.95 207.76,28.95 208.55,28.16 211.51,28.16 212.47,29.12 212.47,29.59 213.15,30.27 218.95,30.27 220.61,28.62 226.8,28.62 227.8,29.62 229.16,29.62 229.42,29.36 254.58,29.36 256.34,31.12 257.23,31.12 258.3,32.19 v2(258.59,32.19)
  IN4 w0.051: v4(160.8,43.01) 160.78,42.99 159.47,42.99 v4(158.39,44.07)
  GND5 w0.086: v5(161.68,43.58) 161.1,43.01 v4(160.8,43.01)
  BOTTOM w0.086: CC334.1 162.53,44.43 v5(161.68,43.58)
HDA_SYNC: length 7.5
  BOTTOM w0.076: UC1.BA22 143.97,59.14 144.24,58.88 144.24,58.66 144.57,58.34 144.57,57.99 145.39,57.17 145.39,54.94
  BOTTOM w0.086: 145.39,54.94 v1(146.25,54.09) 146.25,53.97 146.6,53.62 RC92.2
HDA_SYNC_R: length 138.5
  TOP w0.086: UA1.9 262.41,33.92 261.83,33.34 259.56,33.34 v3(259.53,33.37)
  GND1 w0.117: v4(259.05,33.37) v3(259.53,33.37)
  IN2 w0.061: v2(147.27,51.95) 147.39,51.95 147.84,51.5 147.84,51.21 152.5,46.55 157.47,46.55 159.02,45 159.02,44.36 158.9,44.24 158.9,42.49 160.3,41.09 160.3,36.65 162.12,34.83 164.59,34.83 166.68,32.74 v4(166.68,32.33)
  IN3 w0.061: v4(166.68,32.33) 166.82,32.47 167.49,32.47 167.61,32.35 167.61,31.55 169.23,29.94 169.95,29.94 170.15,29.73 174.97,29.73 176.1,30.87 179.65,30.87 182.22,28.3 199.11,28.3 200.21,29.4 207.89,29.4 208.76,28.54 211.35,28.54 212.09,29.27 212.09,29.75 212.99,30.65 219.11,30.65 220.76,28.99 226.65,28.99 227.65,30 229.32,30 229.58,29.74 254.32,29.74 257.56,32.98 258.11,32.98 258.5,33.37 v4(259.05,33.37)
  BOTTOM w0.086: v2(147.27,51.95) 147.19,52.03 RC92.1
HDD_FALL_INT: length 18
  BOTTOM w0.076: 151.37,56.98 150.81,56.98 150.01,57.78 UC1.BB11
  BOTTOM w0.086: RC370.1 164.23,52.36 162.53,52.36 162.09,52.79 160.44,52.79 158.23,55 153.34,55 v1(151.78,56.56) 151.37,56.98
HDMI_CEC: length 8.8
  IN3 w0.061: v4(15.91,52.4) 15.78,52.27 13.02,52.27 12.5,51.75 12.5,49.43 11.67,48.6 JHDMI1.13
  GND5 w0.086: v4(15.91,52.4) 16.28,52.77 v5(16.55,52.77)
  BOTTOM w0.086: v5(16.55,52.77) 16.55,52.56 RV19.1
HDMI_CLKN: length 3.4
  TOP w0.077: CV38.2 20.33,48.35 20.18,48.35 v2(19.92,48.61) 19.65,48.33 19.47,48.33 19.27,48.53 LV12.2 18.97,48.69 LV38.1
  BOTTOM w0.077: RV17.1 19.4,48.33 19.64,48.33 v2(19.92,48.61)
HDMI_CLKP: length 3.4
  TOP w0.077: CV37.2 20.35,48.19 20.22,48.19 v2(19.92,47.9) 19.65,48.17 19.45,48.17 19.26,47.98 LV12.1 18.97,47.81 LV37.1
  BOTTOM w0.077: v2(19.92,47.9) 19.65,48.17 19.41,48.17 RV16.1
HDMI_CTRL_CLK: length 13.4
  IN3 w0.061: JHDMI1.15 12.19,50.19 12.19,51.88 13,52.69 14.75,52.69 14.85,52.79 16.55,52.79 18.35,50.98 18.46,50.98 v4(18.8,50.64)
  GND5 w0.086: v5(18.81,51.14) 18.81,50.66 v4(18.8,50.64)
  BOTTOM w0.086: v5(18.81,51.14) 18.97,50.98 QV3.6 19.93,50.84 RV316.1
HDMI_CTRL_DATA: length 8.9
  IN3 w0.061: v2(17.18,48.98) 17.18,49.04 16.11,50.1 JHDMI1.16
  BOTTOM w0.086: QV3.3 18.38,51.79 18.38,50.83 18.15,50.6 17.59,50.6 17.24,50.25 RV315.1 17.18,49.56 v2(17.18,48.98)
HDMI_L_CLKN: length 5.9
  TOP w0.077: LV38.2 18.02,48.66 LV12.3 17.73,48.53 17.53,48.33 16.6,48.33 RV35.1 15.87,48.35 14.71,48.35 14.02,47.66 13.59,47.66 JHDMI1.12
HDMI_L_CLKP: length 5.9
  TOP w0.077: JHDMI1.10 13.55,47.5 14.09,47.5 14.78,48.19 15.82,48.19 RV35.2 16.59,48.17 17.57,48.17 17.76,47.98 LV12.4 18.02,47.84 LV37.2
HDMI_L_TX_N0: length 13.6
  TOP w0.077: LV36.2 18,46.61 LV9.3 17.78,46.49 17.58,46.3 16.6,46.3 RV32.1 15.87,46.32 15.64,46.32 14.92,45.6 14.63,45.6 v2(14.33,45.89)
  IN1 w0.065: v2(14.33,45.89) 14.07,45.63 13.93,45.63 13.75,45.45 13.75,42.85 13.43,42.53 12.88,42.53 12.46,42.95 12.46,45.86 12.16,46.17 12.03,46.17 JHDMI1.9
HDMI_L_TX_N1: length 5.7
  TOP w0.077: JHDMI1.6 13.17,45.1 13.6,44.67 14.08,44.67 14.47,44.28 15.86,44.28 RV29.1 16.61,44.26 17.55,44.26 17.75,44.46 LV6.3 18.04,44.62 LV34.2
HDMI_L_TX_N2: length 7.8
  TOP w0.077: LV32.2 18.04,42.59 LV3.3 17.75,42.43 17.55,42.23 16.6,42.23 RV26.1 15.86,42.25 12.69,42.25 12.49,42.45 12.49,42.91 12.23,43.17 12.03,43.17 JHDMI1.3
HDMI_L_TX_P0: length 13.6
  TOP w0.077: v2(14.33,45.21) 14.56,45.44 14.98,45.44 15.71,46.16 15.82,46.16 RV32.2 16.59,46.14 17.57,46.14 17.76,45.95 LV9.4 18,45.83 LV35.2
  IN1 w0.065: JHDMI1.7 12.01,46.01 12.09,46.01 12.3,45.8 12.3,42.88 12.81,42.37 13.5,42.37 13.91,42.78 13.91,45.38 13.99,45.46 14.08,45.46 v2(14.33,45.21)
HDMI_L_TX_P1: length 5.7
  TOP w0.077: JHDMI1.4 13.56,44.51 14.01,44.51 14.4,44.12 15.83,44.12 RV29.2 16.59,44.1 17.57,44.1 17.76,43.91 LV6.4 17.9,43.91 LV33.2
HDMI_L_TX_P2: length 7.7
  TOP w0.077: LV31.2 17.9,41.88 LV3.4 17.78,41.88 17.6,42.07 16.59,42.07 RV26.2 15.83,42.09 12.63,42.09 12.33,42.39 12.33,42.84 12.16,43.01 12.01,43.01 JHDMI1.1
HDMI_OB: length 14.1
  TOP w0.508: v2(14.91,39.47) v1(15.77,40.33) 16.3,40.86 18.34,40.86 v2(18.48,41)
  BOTTOM w0.508: v2(18.48,41) 18.47,41 18.06,41.4 RV10.2 RV11.2 RV12.2 RV13.2 RV14.2 RV15.2 RV16.2 RV17.2 ; QV4.1 14.33,38.88 v2(14.91,39.47)
HDMI_RD_HPD: length 52.3
  TOP w0.086: v3(15.31,53.83) 15.31,53.79 QV6.2 12.58,52.73 v1(12.55,52.75) 11.82,52.75 11.6,52.54 JHDMI1.19
  GND1 w0.086: v4(15.7,54.94) 15.31,54.54 v3(15.31,53.83)
  IN2 w0.061: v2(27.07,83.75) 27.07,83.16 21.75,77.84 20.95,77.84 19.79,76.69 19.79,75.77 17.29,73.27 v2(17.29,72.96)
  IN3 w0.061: v2(17.29,72.96) 17.24,72.91 17.24,69.52 16.13,68.41 16.13,64.5 15.44,63.81 15.44,61.13 15.23,60.92 15.23,55.38 15.68,54.94 v4(15.7,54.94)
  BOTTOM w0.086: QV5.1 33.32,91.55 32.1,90.34 32.1,90.2 31.41,89.51 RV21.1 31.34,89.24 30.9,88.81 30.9,87.93 30.78,87.8 29.85,87.8 27.07,85.02 v2(27.07,83.75)
HDMI_TX_N0: length 3.3
  TOP w0.077: LV36.1 19.12,46.49 LV9.2 19.27,46.49 19.47,46.3 19.63,46.3 v2(19.92,46.59) 20.2,46.31 20.32,46.31 CV36.2
  BOTTOM w0.077: RV15.1 19.36,46.31 19.65,46.31 v2(19.92,46.59)
HDMI_TX_N1: length 4
  TOP w0.077: LV34.1 18.97,44.63 LV6.2 19.27,44.46 19.47,44.26 19.68,44.26 v2(19.95,44.54) 20.22,44.26 20.74,44.26 CV34.2
  BOTTOM w0.077: v2(19.95,44.54) 19.68,44.26 19.34,44.26 RV13.1
HDMI_TX_N2: length 4
  TOP w0.077: CV32.2 20.77,42.26 20.16,42.26 v2(19.95,42.47) 19.74,42.25 19.44,42.25 19.27,42.43 LV3.2 18.97,42.6 LV32.1
  BOTTOM w0.077: RV11.1 19.39,42.23 19.71,42.23 v2(19.95,42.47)
HDMI_TX_P0: length 3.3
  TOP w0.077: CV35.2 20.31,46.15 20.2,46.15 v2(19.92,45.88) 19.91,45.88 19.65,46.14 19.45,46.14 19.26,45.95 LV9.1 19.06,45.95 LV35.1
  BOTTOM w0.077: v2(19.92,45.88) 19.65,46.15 19.33,46.15 RV14.1
HDMI_TX_P1: length 4
  TOP w0.077: LV33.1 19.11,43.91 LV6.1 19.26,43.91 19.45,44.1 19.67,44.1 v2(19.95,43.82) 20.23,44.1 20.75,44.1 CV33.2
  BOTTOM w0.077: v2(19.95,43.82) 19.67,44.1 19.35,44.1 RV12.1
HDMI_TX_P2: length 3.9
  TOP w0.077: CV31.2 20.72,42.1 20.18,42.1 v2(19.96,41.88) 19.75,42.09 19.47,42.09 19.26,41.88 LV3.1 19.11,41.88 LV31.1
  BOTTOM w0.077: RV10.1 19.3,42.07 19.77,42.07 v2(19.96,41.88)
HOST_DEBUG_TX: length 124.8
  TOP w0.086: RZ132.1 225.9,65.03 225.18,65.76 v1(225.18,66.11) 225.18,66.17 v3(225.65,66.63)
  GND1 w0.086: v4(225.79,67.27) 225.79,66.78 v3(225.65,66.63)
  GND1 w0.117: v4(267.83,60.23) 267.6,60.23 267.39,60.02 v3(267.39,59.81)
  IN3 w0.061: v4(225.79,67.27) 225.8,67.27 225.8,67.34 226.31,67.85 228.82,67.85 230.39,66.28 232.62,66.28 233.05,65.86 237.19,65.86 237.81,66.48 240.07,66.48 242.7,69.11 242.7,69.96 246,73.26 247.87,73.26 248.73,74.12 251.63,74.12 253.2,75.7 264.98,75.7 266.59,74.09 266.59,68.35 267.85,67.09 269.28,67.09 271.46,64.91 271.46,63.02 268.68,60.23 v4(267.83,60.23) 267.74,60.32 263.43,60.32 263.16,60.05 262.27,60.05 261.84,59.62 261.84,59.32 261.59,59.06 261.21,59.06 261.03,58.89 261.03,58.48 260.8,58.25 259.61,58.25 259.28,57.92 259.28,56.65 257.35,54.72 256.63,54.72 255.78,53.87 254.58,53.87 253.6,52.89 253.6,43.93 255.24,42.29 255.24,40.22 254,38.97 254,35.54 251.99,33.54 251.49,33.54 250.11,32.16 247.03,32.16 246,33.18 245.49,33.18 245.23,33.45 245.23,33.87 245.03,34.07 244.37,34.07 243.96,33.66 v4(243.96,32.32)
  GND5 w0.086: v5(243.36,31.98) 243.57,31.98 243.91,32.32 v4(243.96,32.32)
  BOTTOM w0.086: v5(243.36,31.98) RE73.2 241.53,31.03 JDEG1.8
HOST_SD_WP#: length 172.1
  TOP w0.086: v2(278.58,65.41) 278.57,65.4 QR1.2
  IN1 w0.051: v2(278.58,65.41) 278.38,65.62 274.03,65.62 273.83,65.41 271.43,65.41 270.6,64.59 268.66,64.59 267.81,65.44 v4(266.37,65.44)
  IN2 w0.061: v4(162.62,64.8) 162.62,60.93 v4(161.84,60.14)
  IN3 w0.061: v4(161.84,60.14) 161.84,60.14 162.08,60.14 163.55,61.61 169.17,61.61 171.36,59.42 171.36,56.59 173.28,54.67 178.14,49.81 178.14,47.05 181.32,43.87 184.91,43.87 187.44,41.34 190.64,41.34 190.98,41 214.33,41 214.52,41.19 214.92,41.19 215.23,40.88 215.23,40.6 215.44,40.39 216.92,40.39 217.68,41.16 222.12,41.16 223.47,42.51 225.21,42.51 232.83,50.13 232.83,53.71 235.22,56.1 235.34,56.1 239.64,60.41 247.59,60.41 248.23,61.05 249.52,61.05 250.41,60.16 251.68,60.16 252.05,60.52 252.05,65.43 252.68,66.06 256.21,66.06 256.66,65.61 261.34,65.61 261.67,65.94 265.88,65.94 v4(266.37,65.44)
  GND5 w0.086: v5(163.18,65.13) 162.85,64.8 v4(162.62,64.8)
  BOTTOM w0.086: UC1.W10 151.34,70.67 152.06,70.67 152.41,70.32 152.41,69.94 152.92,69.43 153.81,69.43 154.47,68.77 154.47,68.41 154.72,68.16 161.48,68.16 162.64,67 162.64,65.95 v1(162.65,65.93) 162.65,64.9 162.94,64.6 RC292.1 163.08,65.03 v5(163.18,65.13)
HP_OUT_L: length 16.3
  TOP w0.203: UA1.26 270.67,33.12 271.07,32.71 271.07,31.57 v1(271.44,31.21) 271.7,30.94 272.44,30.94
  TOP w0.381: CA43.2 274.31,39.11 274.77,39.57 CA74.1 v2(274.81,40.22) ; RA7.1 272.44,30.94 v2(271.85,31.53)
  BOTTOM w0.381: v2(274.81,40.22) 272.48,37.89 272.48,33.59 271.85,32.97 v2(271.85,31.53)
HP_OUT_R: length 14.9
  TOP w0.203: RA8.1 272,30.48 271.51,30.48 270.69,31.31 270.69,32.51 270.48,32.72 UA1.25
  TOP w0.381: CA44.2 273.91,37.77 274.57,37.77 CA73.1 274.82,37.37 274.38,36.93 v2(274.38,36.81) ; RA8.1 272.5,29.99 v2(272.5,29.35)
  BOTTOM w0.381: v2(272.5,29.35) v1(273.56,30.42) 273.56,33.21 274.38,34.02 v2(274.38,36.81)
HV_GATE1_A: length 3.1
  BOTTOM w0.076: UT5.B9 33.97,74.78 34.49,74.78
  BOTTOM w0.086: RT64.1 36,74.78 34.49,74.78
HV_GATE1_B: length 3.2
  BOTTOM w0.076: 29.99,41.41 29.99,41.88 UT11.B9
  BOTTOM w0.086: RT160.1 28.92,40.04 v1(29.3,40.42) 29.99,41.11 29.99,41.41
HV_GATE2_A: length 2.7
  BOTTOM w0.086: RT65.1 35.36,75.03 UT5.A9
HV_GATE2_B: length 2.3
  BOTTOM w0.086: RT161.1 29.87,40.46 30.23,40.82 UT11.A9
HW_ACAVIN_NB: length 2.6
  TOP w0.086: UE1.N6 263.39,54.19 262.81,53.6 262.81,53.08 T266.1
HW_GPS_DISABLE#_R: length 4.1
  TOP w0.076: JNGFF2.26 231.61,82.4
  TOP w0.086: DZ6.2 v1(230.36,81.34) 230.55,81.34 231.61,82.4
I2C1_SCK_TP: length 59
  TOP w0.086: v1(182.19,35.96) 182.19,38.41 181.21,39.39 180.57,39.39 v3(180.15,39.81)
  TOP w0.117: v1(182.19,35.96) 182.19,35.3 RZ21.2 181.89,34.12 RZ29.1
  GND1 w0.086: v3(180.15,39.81) 180.03,39.94 v4(180.03,40.3)
  IN2 w0.061: v4(180.03,40.3) 179.14,41.19 178.74,41.19 175.1,44.84 175.1,44.84 174.9,45.04 174.9,48.74 173.46,50.18 173.46,50.84 170.2,54.09 165.89,54.09 163.55,56.43 163.55,60.16 163.36,60.35 163.36,66.17 162.04,67.5 161.27,67.5 159.75,69.02 157.65,69.02 157.26,69.41 157.02,69.41 156.22,70.2 156.22,71.37 155.1,72.5 152.13,72.5 v2(151.75,72.88)
  BOTTOM w0.086: v2(151.75,72.88) 151.75,72.58 UC1.U9
I2C1_SCK_TP_R: length 16.3
  TOP w0.086: RZ349.1 181.78,33.16 RZ29.2 RZ117.2 v2(183.46,33.16) 183.46,32.86 v1(182.82,32.23)
  BOTTOM w0.086: JKBTP1.19 173.25,33.46 174.05,32.66 182.96,32.66 v2(183.46,33.16)
I2C1_SDA_TP: length 59.3
  TOP w0.086: v3(176.74,41.5) 176.53,41.29 v1(176.14,41.29) 173.82,41.29 173.04,40.51 173.04,38.39 172.64,37.98 172.64,35.21 RZ20.2
  TOP w0.117: RZ26.1 171.57,35.01 RZ20.2
  GND1 w0.086: v3(176.74,41.5) 177.06,41.82 v4(177.06,41.97)
  IN2 w0.061: v4(151.7,71.84) 151.7,71.92 152.03,72.25 155.03,72.25 156,71.28 156,70.11 156.93,69.18 157.22,69.18 158.32,68.08 159.48,68.08 160.84,66.71 162.53,66.71 163.18,66.07 163.18,60.22 163.36,60.03 163.36,56.35 165.81,53.91 170.13,53.91 173.27,50.76 173.27,50.1 174.71,48.66 174.71,44.58 177.06,42.24 v4(177.06,41.97)
  GND5 w0.086: v4(151.7,71.84) 151.7,71.87 v5(152.1,72.28)
I2C1_SDA_TP_R: length 8.1
  TOP w0.086: RZ348.1 176.13,33.92 175.13,32.93 174.39,32.93 v2(174.01,33.31) 173.69,32.99 v1(173.07,32.99) 173.03,32.99 172.43,33.59 RZ116.2 171.54,34.12 RZ26.2
  BOTTOM w0.086: JKBTP1.18 173.75,33.57 v2(174.01,33.31)
I2C2_ALS_CLK: length 66.3
  IN2 w0.061: v4(182.3,48.57) 182.3,49.4 181.74,49.96 181.74,50.71 177.45,55 177.45,58.14 175.15,60.44 175.15,65.78 175.04,65.89 175.04,67.18 169.22,73.01 v2(167.22,73.01)
  IN3 w0.061: v2(167.22,73.01) 166.87,73.36 166,73.36 165.79,73.15 160.64,73.15 160.34,72.86 157.32,72.86 156.94,72.47 156.94,71.23 157.13,71.04 157.13,69.84 156.43,69.13 156.43,68.25 156.78,67.9 156.78,67.49 156.45,67.16 156.08,67.16 154.95,66.03 154.07,66.03 153.13,66.96 151.09,66.96 150.54,67.51 v4(150.52,67.51)
  GND5 w0.086: v4(182.3,48.57) 182.3,48.48 v5(182.62,48.17) ; v5(150.8,66.94) 150.52,67.23 v4(150.52,67.51)
  BOTTOM w0.086: v5(182.62,48.17) 182.01,47.56 180.64,47.56 180.05,46.97 180.05,44.43 180.46,44.03 v1(180.46,43.89) 180.46,42.34 RC511.2 180.34,41.79 QC4.4
I2C2_ALS_SDA: length 66.5
  IN2 w0.061: v2(166.62,72.96) 166.98,72.6 168.01,72.6 174.96,65.65 174.96,60.36 177.26,58.06 177.26,54.92 181.55,50.63 181.55,49.46 181.75,49.26 v4(181.75,49.13)
  IN3 w0.061: v4(151.6,66.46) 151.6,66.17 151.93,65.84 155.03,65.84 156.16,66.97 156.52,66.97 156.96,67.41 156.96,67.98 156.62,68.32 156.62,69.06 157.32,69.76 157.32,71.46 157.65,71.79 159.86,71.79 160.34,72.27 160.34,72.54 160.73,72.93 166.6,72.93 v2(166.62,72.96)
  GND5 w0.086: v4(181.75,49.13) 181.75,48.65 v5(181.58,48.47) ; v5(151.45,66.94) 151.45,66.82 151.66,66.62 151.66,66.51 v4(151.6,66.46)
  BOTTOM w0.086: QC4.1 181.64,39.31 180.46,40.5 179.28,40.5 RC510.2 178.73,41.04 178.73,42.48 v1(177.77,43.44) 177.77,44.99 181.25,48.47 v5(181.58,48.47)
I2C2_SCL_ALS: length 84.1
  IN4 w0.051: v4(238.09,62.11) 237.96,61.98 237.96,60.41 236.03,58.48 236.03,56.77 233.77,54.51 233.77,51.1 230.81,48.14 229.64,48.14 224.92,43.42 223.74,43.42 216.73,36.41 216.73,35.95 215.87,35.09 205.86,35.09 203.7,37.25 203.7,37.63 201.26,40.06 185.54,40.06 185.23,39.76 185.23,39.63 v4(185.21,39.63)
  GND5 w0.086: v5(238.07,62.62) 238.04,62.59 238.04,62.16 v4(238.09,62.11) ; v4(185.21,39.63) 185.23,39.63 185.18,39.58 185.18,39.53 v5(184.88,39.23)
  BOTTOM w0.086: v5(184.88,39.23) 183.67,38.02 v6(182.47,38.02) 181.29,38.02 180.34,38.96 QC4.3 179.82,39.62 RC513.2 ; JSEN2.12 234.66,64.6 235.2,64.07 237.23,64.07 237.52,63.78 237.52,63.37 238.07,62.82 v5(238.07,62.62)
I2C2_SDA_ALS: length 80.3
  IN4 w0.051: v4(184.58,39.64) 185.18,40.24 201.34,40.24 203.88,37.7 203.88,37.32 205.96,35.24 215.81,35.24 216.58,36.01 216.58,36.47 223.68,43.57 224.86,43.57 229.58,48.29 230.75,48.29 233.62,51.16 233.62,54.57 235.88,56.83 235.88,58.54 237.43,60.09 237.43,60.64 236.82,61.25 236.82,62.21 v4(237.05,62.44)
  GND5 w0.086: v5(184.57,40.14) 184.57,39.64 v4(184.58,39.64) ; v4(237.05,62.44) 237.1,62.49 237.13,62.49 237.51,62.87 v5(237.51,62.95)
  BOTTOM w0.086: QC4.6 182.89,41 RC512.2 182.99,40.92 183.76,40.14 v1(184.1,40.14) v5(184.57,40.14) ; JSEN2.11 237.19,63.8 237.3,63.69 237.3,63.15 v5(237.51,62.95)
I_ADP: length 260.8
  TOP w0.086: v2(267.78,64.25) 267.78,64.2 UE1.B11 ; v2(63.64,42.78) v1(63.14,42.27) 62.2,41.33 PR935.2
  IN1 w0.051: v2(267.78,64.25) 267.46,64.57 263.66,64.57 263.42,64.33 263.42,61.63 263.16,61.38 262.06,61.38 261.82,61.13 261.82,60.83 261.46,60.47 260.64,60.47 259.56,59.39 257.96,59.39 256.99,58.42 256.99,56.29 258.02,55.25 259.35,55.25 259.66,54.95 259.66,53.37 260.04,52.99 260.04,51.91 260.42,51.53 260.42,50.97 259.08,49.64 258.53,49.64 258.16,49.27 258.16,46.86 258.54,46.48 258.54,44.69 258.08,44.23 258.08,43.7 258.17,43.61 258.17,42.82 258.4,42.59 258.4,42.07 257.34,41.01 257.34,39.93 256.05,38.63 256.05,32.16 253.56,29.67 253.56,28.51 252.97,27.91 251.26,27.91 250.76,28.42 236.15,28.42 235.75,28.01 234.55,28.01 233.83,28.73 229.36,28.73 228.78,28.15 220.41,28.15 220.29,28.15 219.7,27.56 207.47,27.56 206.38,28.65 200.82,28.65 200.16,27.99 195.59,27.99 195.41,28.16 182.37,28.16 180.29,30.24 173.43,30.24 171.94,28.75 168.78,28.75 168.24,28.21 v4(168.18,28.21)
  IN4 w0.051: v4(168.18,28.21) 167.73,28.66 165.55,28.66 164.73,29.48 160.86,29.48 157.87,32.47 125.33,32.47 125.02,32.78 95.64,32.78 95.3,33.12 92.52,33.12 90.53,35.11 90.53,40.31 89.96,40.88 89.96,42.38 87.75,44.59 81.07,44.59 80.02,45.64 78.67,45.64 77.64,44.61 75.86,44.61 74.94,45.53 73.8,45.53 73.21,44.94 70.06,44.94 69.29,44.18 68.16,44.18 67.58,43.6 64.46,43.6 v2(63.64,42.78)
I_BATT: length 247.5
  TOP w0.086: PR947.2 63.67,39.9 v2(63.67,39.33) ; v2(255.03,52.59) 255.03,51.29 255.26,51.06 RE64.2
  IN1 w0.051: v4(257.52,44.54) 256.75,43.76 256.75,39.79 255.72,38.77 255.72,32.32 252.79,29.39 v2(252.79,28.53)
  IN3 w0.061: v2(63.67,39.33) 63.86,39.52 63.86,40.69 67.4,44.23 70.53,44.23 71.03,44.73 74.32,44.73 75,44.05 78.08,44.05 78.88,44.85 84.94,44.85 85.73,44.06 87.69,44.06 89.31,42.44 89.31,35.58 91.97,32.93 94.88,32.93 95.93,31.87 110.46,31.87 113.55,28.78 115.4,28.78 116.27,29.65 142.76,29.65 144.7,31.58 158.4,31.58 160.33,29.65 164.86,29.65 165.15,29.94 166.96,29.94 167.1,29.8 167.1,29.22 167.39,28.93 169.54,28.93 169.74,28.73 175.51,28.73 176.54,29.75 179.19,29.75 181.76,27.19 202.91,27.19 203.95,28.23 206.85,28.23 207.64,27.44 218.79,27.44 219.34,27.99 236.35,27.99 236.73,28.36 243.72,28.36 243.94,28.15 254.37,28.15 255.72,29.5 v4(256.08,29.5)
  GND5 w0.086: v4(257.52,44.54) v5(256.96,44.54)
  GND5 w0.254: v5(255.72,29.14) v4(256.08,29.5)
  BOTTOM w0.086: v5(255.72,29.14) 254.07,29.14 253.46,28.53 v2(252.79,28.53)
  BOTTOM w0.254: v5(256.96,44.54) 254.22,47.28 254.22,51.77 v2(255.03,52.59)
I_BATT_R: length 11.5
  TOP w0.086: CE3.1 256.79,52.46 256.24,52.46 v2(256.24,52.47) 255.74,51.98 RE64.1 ; UE1.J4 v2(261.42,57.84)
  IN4 w0.051: v2(261.42,57.84) 261,58.25 259.62,58.25 259.17,57.8 259.17,56.6 257.45,54.87 257.45,54.06 256.71,53.32 256.71,52.94 v2(256.24,52.47)
I_SYS: length 285.5
  TOP w0.086: RE312.2 256.19,44.39 v3(257.01,43.57)
  GND1 w0.086: v4(257.55,43.54) 257.52,43.57 v3(257.01,43.57)
  GND1 w0.117: v3(59.79,38.59) 59.79,38.09 v4(59.78,38.08)
  IN1 w0.051: v4(257.55,43.54) 256.98,42.98 256.98,39.81 255.88,38.7 255.88,32.23 253.39,29.74 253.39,28.58 252.9,28.08 251.42,28.08 250.6,28.9 229.32,28.9 228.72,28.3 220.48,28.3 220.23,28.3 220.22,28.3 220.17,28.3 219.59,27.72 207.56,27.72 206.45,28.82 200.78,28.82 200.1,28.14 195.65,28.14 195.47,28.32 182.48,28.32 180.39,30.41 173.36,30.41 171.87,28.92 165.18,28.92 162.92,31.17 162.92,32.3 162.6,32.62 159.69,32.62 158.81,31.75 142.37,31.75 140.8,30.18 128,30.18 126.51,28.69 110.28,28.69 107.27,31.69 95.84,31.69 95.01,32.52 91.14,32.52 88.61,35.05 88.61,37.49 87.77,38.33 87.77,38.94 87.12,39.59 87.12,41.66 86.61,42.17 86.61,43.62 86.45,43.77 84.91,43.77 84.14,44.54 79.47,44.54 v4(79,44.07) 78.82,44.25 76.58,44.25 75.95,43.62 70.79,43.62 67.62,40.45 61.28,40.45 59.78,38.94 v4(59.78,38.08)
  IN2 w0.061: v4(79,44.07) 77.45,45.61 77.45,47.47 76.81,48.11 76.81,54.25 72.34,58.72 72.34,60.93 70.77,62.51 68.65,62.51 66.31,64.84 66.31,66.34 64,68.66 64,72.98 64.64,73.62 65.3,73.62 65.78,74.1 65.78,76.44 65.55,76.67 v4(65.24,76.67)
  GND5 w0.086: v5(64.74,76.82) 65.09,76.82 v4(65.24,76.67)
  BOTTOM w0.086: v5(64.74,76.82) 64.25,77.3 64.07,77.3 63.67,77.7 63.67,80.6 64.38,81.31 66.31,81.31 67.06,82.07 v1(67.34,82.07) PR620.1
I_SYS_R: length 23.4
  TOP w0.086: RE312.1 RE313.1 CE4.1 v3(254.28,43.48) ; UE1.J5 v2(262.22,57.84)
  GND1 w0.086: v4(254.6,44.03) 254.6,43.8 v3(254.28,43.48)
  IN2 w0.061: v4(254.6,44.03) 254.6,46.87 256.74,49.01 256.74,53.48 256.2,54.01 256.2,56.19 257.04,57.03 257.59,57.03 258.78,58.23 261.83,58.23 v2(262.22,57.84)
IA1N: length 20.8
  TOP w0.086: v1(93.45,72.72) 93.96,72.21 PR677.1
  TOP w0.203: v3(94.8,70.04) 94.8,71.04 94.55,71.29 PR677.1
  GND1 w0.203: v3(99.61,74.82) 99.41,74.82 v4(99.08,74.49) ; v3(94.8,70.04) v4(94.8,69.55)
  IN1 w0.203: v4(99.08,74.49) 99.57,74.99 99.57,78.01 v2(98.93,78.66)
  IN3 w0.203: v4(99.08,74.49) 99.06,74.48 96.4,74.48 95.71,73.79 95.71,70.47 v4(94.8,69.55)
  BOTTOM w0.254: PL610.2 99.34,77.74 98.93,78.15 v2(98.93,78.66)
IA1P: length 7.4
  TOP w0.086: v1(100.87,81.44) 100.9,81.44 100.98,81.35 PR668.1
  TOP w0.254: PR668.1 PR667.2 98.96,79.79 v2(98.93,79.75)
  BOTTOM w0.254: v2(98.93,79.75) 98.42,79.24 98.42,77.99 98.16,77.74 PL610.3
IA2N: length 16.2
  TOP w0.203: v2(95.07,68.26) 95.07,68.55 94.71,68.91 PR673.1
  GND1 w0.203: v3(100.48,76.55) v4(100.48,77.05)
  IN1 w0.203: v4(100.48,77.05) 99.93,76.5 99.93,73.95 95.07,69.09 v2(95.07,68.26)
  BOTTOM w0.203: PL613.2 95.27,67.03 95.07,67.23 v2(95.07,68.26)
IA2P: length 7
  TOP w0.086: PR674.2 v1(91.8,67.75)
  TOP w0.203: v2(94.44,68.26) 93.71,68.26 PR675.1 PR674.2
  BOTTOM w0.203: PL613.3 94.15,67.03 94.44,67.32 v2(94.44,68.26)
IA_SNUB2: length 1.8
  BOTTOM w0.086: 81.99,70.93 v1(80.23,70.93)
IA_SW1:
  vias: v1(96.11,72.28)
IA_SW2:
  vias: v1(88.5,70.24)
ILIM_SEL: length 2.1
  TOP w0.086: RI13.1 267.12,73.28 267.31,73.09 UI3.4
ILMT_+1VALWP: length 5.3
  TOP w0.254: PR310.1 PR307.2 67.43,73.95 67.23,73.75 66.21,73.75 v1(65.39,72.93) 65.07,72.6 v2(64.88,72.6)
  BOTTOM w0.254: PU301.13 64.75,72.48 v2(64.88,72.6)
ILMT_DDR: length 4.9
  TOP w0.086: v2(81.15,46.31) 81.15,46.39 v1(80.78,46.76)
  TOP w0.254: v2(81.15,46.31) 81.15,45.93 80.89,45.68 PR207.2
  BOTTOM w0.254: PU200.17 82.52,44.02 82.03,44.51 82.03,45.24 81.59,45.68 PR205.1 81.45,46.01 v2(81.15,46.31)
IMON_GT: length 3.3
  TOP w0.203: v2(75.99,77.94) 75.69,78.23 PR629.2
  TOP w0.254: PC625.2 75.37,77.39 PR629.2
  BOTTOM w0.203: v2(75.99,77.94) 75.99,77.61 75.51,77.13 PU602.14
IMON_VSA: length 2.8
  TOP w0.203: PC643.1 74.11,73.36 v2(73.71,72.96) 73.71,72.58 PR651.1
  BOTTOM w0.203: PU602.23 73.29,73.51 73.68,73.12 73.68,72.99 v2(73.71,72.96)
IMVP_VR_ON: length 311.8
  TOP w0.086: v2(64.2,77.73) 64.2,77.86 64.86,78.52 65.02,78.52 65.37,78.88 65.37,79.66 66.21,80.5 PR616.1 67.18,81.12 v1(67.59,81.53) ; v2(261.21,73.16) 260.95,73.41 260.95,73.67 260.78,73.84 RE304.1 260.72,73.64 260.72,72.3 261.57,71.45 UE3.4 262.32,71.45 262.93,72.06 UE4.2
  IN2 w0.061: v2(261.21,73.16) 266.57,73.16 269.26,70.47 271.68,70.47 271.95,70.19 273.24,70.19 277.11,66.33 277.11,62.42 275.28,60.59 275.28,51.98 274.95,51.65 274.51,51.65 271.83,48.97 269.52,48.97 265.6,45.04 265.6,44.66 264.93,44 263.54,44 262.72,43.18 262.72,42.19 262.45,41.92 262.07,41.92 261.64,41.49 261.64,41.4 259.32,39.08 259.32,35.68 259.59,35.42 259.59,31.87 256.76,29.04 255.44,29.04 253.46,27.06 251.99,27.06 251.24,27.8 242.53,27.8 241.79,27.06 239,27.06 238.99,27.05 233.96,27.05 233.41,27.6 228.04,27.6 226.9,26.46 200.67,26.46 199.2,27.93 187.95,27.93 186.91,28.97 180.39,28.97 179.33,30.03 174.17,30.03 173.12,31.08 169.63,31.08 168.91,30.36 163.94,30.36 163.42,30.88 159.84,30.88 158.89,31.82 141.78,31.82 140.82,30.86 126.45,30.86 125.99,30.41 106.39,30.41 105.23,31.57 97.01,31.57 95.1,33.48 95.1,39.42 94.2,40.32 92.79,40.32 91.88,41.23 91.88,41.38 91.88,41.38 91.88,41.69 89.57,44 89.56,44 89.55,44.01 89.4,44.01 85.44,44.01 81.93,47.52 81.93,47.52 81.91,47.54 78.68,47.54 78.13,48.1 78.13,48.71 77.38,49.46 77.38,54.48 72.92,58.94 72.92,68.32 72.45,68.8 72.45,71.18 71.49,72.13 69.51,72.13 67.22,74.43 67.22,75.66 65.57,77.3 64.64,77.3 v2(64.2,77.73)
IMVP_VR_ON_EC: length 73
  TOP w0.086: RPE10.2 257.09,42.52 257.38,42.82 v1(258.96,42.82) 259.07,42.82 259.41,43.16 263.44,43.16 v3(263.58,43.3) ; UE1.N7 263.82,54.64 v2(263.82,54.61) ; v2(259.48,73.19) 259.6,73.31 RE304.2 260.08,73.36 260.32,73.36 260.48,73.2 260.48,72.88 260.35,72.75 UE3.1
  GND1 w0.086: v4(264.1,43.61) 263.79,43.3 v3(263.58,43.3)
  IN4 w0.051: v2(263.82,54.61) 264.41,54.01 264.41,50.45 263.73,49.76 263.73,46.24 263.13,45.64 263.13,44.8 264.1,43.82 v4(264.1,43.61) 264.1,43.61 264.52,43.61 265.19,44.28 266.68,44.28 267.3,43.67 267.74,43.67 267.99,43.92 267.99,44.33 269.79,46.13 269.79,47.2 269.77,47.22 269.77,47.79 270.17,48.19 270.96,48.19 274.41,51.64 275.45,51.64 275.58,51.76 275.58,53.96 274.04,55.5 273.29,55.5 270.85,57.95 270.36,57.95 269.64,58.67 269.64,60.73 271.24,62.33 271.24,66.54 268.67,69.11 267.69,69.11 264.07,72.73 259.94,72.73 v2(259.48,73.19)
INT_SPK_L+: length 37.4
  IN1 w1.016: 288.86,24.82 285.84,24.82 283.53,27.14 266.54,27.14 264.33,29.35 264.33,37.51 264.75,37.93 266.97,37.93
  vias: v2(267.99,40.03) v2(267.99,39.44) v2(290.62,24.98) v2(291.24,25.03)
INT_SPK_L-: length 42.3
  IN1 w1.016: 289.74,22.15 286.71,22.15 283,25.87 266.01,25.87 263.06,28.82 263.06,38.03 265.63,40.6
  vias: v1(291,22.61) v2(267.35,39.81) v2(267.38,39.23) v2(291.08,21.94) v2(291.08,21.33)
INT_SPK_R+: length 45.8
  TOP w0.127: v1(298.59,26.11) 298.75,25.95 v2(298.75,24.98)
  IN2 w1.016: 264.59,38.18 264.33,37.91 264.33,28.86 266.06,27.14 283.51,27.14 285.21,25.43 288.43,25.43 289.78,24.09 293.27,24.09 293.79,24.61 297.34,24.61 297.35,24.62
  vias: v2(265.98,39.46) v2(265.98,38.87) v2(298.75,24.34)
INT_SPK_R-: length 48.7
  IN2 w1.016: 263.69,39.07 263.06,38.44 263.06,28.34 265.53,25.87 282.98,25.87 284.68,24.16 287.91,24.16 289.25,22.82 296.46,22.82 297.86,21.42
  vias: v2(266.64,39.7) v2(266.64,39.1) v2(298.84,21.8) v2(298.84,21.17)
INT_SPKR_L+:
  vias: v1(282.24,23.45) v2(282.74,22.95) v2(282.74,22.06)
INT_SPKR_L-:
  vias: v1(287.38,21.8) v2(284.37,21.17) v2(284.37,20.28)
INT_SPKR_R+: length 11
  BOTTOM w1.016: JSPK1.3 283.7,15.62 285.39,15.62 287.01,15.62 291.2,19.82
  vias: v1(291.89,23.9) v2(292.2,21.08) v2(292.78,21.08)
INT_SPKR_R-: length 13.6
  BOTTOM w1.016: 293.23,19.7 292.36,18.83 287.76,14.23 283.84,14.23 283.7,14.37 JSPK1.4
  vias: v1(296.54,21.55) v2(293.86,20.82) v2(294.34,21.21)
INTRUDER#: length 13
  TOP w0.086: v2(146.62,64.09) 147.11,64.09 147.99,63.21 147.99,61.1 148.58,60.51 148.58,59.32 v1(151.82,56.08) 152.44,55.45 RC69.1
  BOTTOM w0.086: v2(146.62,64.09) 146.7,64.02 146.82,64.02 UC1.AP16
IR_CAM_DET#: length 77.5
  TOP w0.086: v2(168.18,86.57) 168.18,87.14 RC345.1
  IN2 w0.061: v2(168.18,86.57) 168.53,86.22 168.77,86.22 169.44,85.56 170.38,85.56 171.2,84.73 171.2,84.32 173.56,81.96 173.56,80 176.31,77.25 176.31,66.33 176.35,66.29 176.35,64.81 177.18,63.97 177.18,60.1 178.67,58.61 178.67,55.47 183.3,50.84 v2(183.3,50.43)
  BOTTOM w0.076: UC1.H5 153.54,76.65 154.52,77.63 154.52,77.94 154.66,78.08 155.03,78.1 155.39,78.26 155.49,78.37 155.49,78.57 155.8,78.88 155.8,79.19 155.98,79.37 156.42,79.37 157.2,80.15
  BOTTOM w0.086: v2(168.18,86.57) 167.51,85.91 165.21,85.91 159.95,80.65 157.71,80.65 157.2,80.15 ; JIR1.1 172.29,50.7 175.1,47.89 177.16,47.89 180.47,51.2 182.53,51.2 v6(182.79,50.94) v2(183.3,50.43)
ISEN1_IA: length 35.2
  TOP w0.086: PR670.1 101.04,77.51 v1(101.41,77.14)
  TOP w0.254: v3(100.98,78.39) 100.98,78.02 PR670.1
  GND1 w0.203: v3(100.98,78.39) v4(100.98,78.87)
  IN3 w0.203: v4(100.98,78.87) 100.98,80.39 100.29,81.08 78,81.08 77.63,80.7 74.79,80.7 v2(73.98,79.9)
  BOTTOM w0.203: PU602.9 73.69,79.6 v2(73.98,79.9) 73.98,81.04 PC635.2 73.86,81.17 PR634.1
ISEN2_IA: length 38.2
  TOP w0.086: PR677.2 92.6,71.73 v1(91.79,71.73)
  TOP w0.203: PC638.2 75.19,80.31 v2(74.72,79.84)
  TOP w0.254: v3(93,70.37) 93,71.24 PR677.2
  GND1 w0.203: v3(93,70.37) v4(93,69.69)
  IN3 w0.203: v4(93,69.69) 93.28,69.69 94.72,71.13 94.72,79.41 93.39,80.74 78.13,80.74 77.67,80.29 75.16,80.29 v2(74.72,79.84)
  BOTTOM w0.203: PU602.10 74.09,79.21 v2(74.72,79.84) 75.63,80.75 PR615.1
ISH_GP0: length 7.8
  TOP w0.086: v2(237.48,62.04) 236.75,62.77 v1(236.75,63.64) 236.75,64.78 236.51,65.02 234.97,65.02 RZ505.1 233.87,66.11 DZ100.1
  BOTTOM w0.086: RZ143.1 237.23,62.29 v2(237.48,62.04)
ISH_GP0_D: length 141.5
  TOP w0.086: v2(162.12,55.61) 161.47,56.26 161.47,60.83 164.55,63.91 165.88,63.91 v2(165.95,63.84) ; DZ100.2 232.41,66.72 234.15,66.72 RZ501.1 234.49,66.39 235.15,67.04 v1(238.73,67.04) 238.98,67.04 240.45,65.57 240.45,65.52 v2(240.48,65.49)
  IN2 w0.061: v2(165.95,63.84) 165.95,63.47 166.3,63.12 170.34,63.12 171.05,62.41 171.05,61.44 172.3,60.19 172.3,56.35 178.89,49.77 178.89,46.53 180.64,44.78 185.74,44.78 187.36,43.16 187.51,43.16 190.87,43.16 191.32,43.62 200.12,43.62 200.79,42.95 201.57,42.95 210.79,42.95 211.84,41.89 218.71,41.89 219.63,42.81 220.59,42.81 221.18,43.39 224.06,43.39 229.35,48.69 229.35,50.16 229.57,50.38 229.57,51.62 229.11,52.08 229.11,53.45 231.63,55.97 231.63,58.91 233.97,61.25 237.9,61.25 240.48,63.83 v2(240.48,65.49)
  BOTTOM w0.076: UC1.AY8 151.52,59.85 151.52,59.55 151.77,59.31 151.77,58.28 152.36,57.69
  BOTTOM w0.086: RC365.1 163.16,55.33 162.4,55.33 v2(162.12,55.61) 161.8,55.93 154.12,55.93 152.36,57.69
ISH_GP1: length 71.3
  TOP w0.086: v3(234.87,62.33) 234.87,63.15 234.48,63.54 RZ506.1 234.48,63.62 234.01,64.09 DZ101.1 ; LGA1.12 273.05,89.39 273.26,89.59 275.12,89.59 v2(275.53,89.19) 275.8,89.19 v1(276.4,89.79)
  GND1 w0.086: v3(234.87,62.33) 234.87,62.02 v4(234.48,61.63)
  IN1 w0.051: v2(275.53,89.19) 275.12,89.59 272.42,89.59 271.47,88.64 271.47,86.7 270.25,85.48 256.71,85.48 254.36,83.13 249.99,83.13 249.19,82.33 249.19,79.94 250.7,78.43 250.7,71.31 247.08,67.69 247.08,67.41 246.07,66.4 246.07,65.02 242.68,61.63 234.49,61.63 v4(234.48,61.63)
ISH_GP1_D: length 127.6
  TOP w0.086: DZ101.2 232.89,63.01 v3(234.38,63.01) ; DZ101.2 232.47,64.76 234.2,64.76 RZ502.1 ; DZ101.2 v1(230.74,64.09) ; v2(166.49,63.6) 166.28,63.4 164.34,63.4 161.68,60.74 161.68,56.68 v2(162.15,56.22)
  GND1 w0.086: v4(234.37,62.22) 234.38,62.24 v3(234.38,63.01)
  IN2 w0.061: v2(166.49,63.6) 166.75,63.34 170.43,63.34 171.27,62.5 171.27,61.54 172.53,60.28 172.53,56.4 179.07,49.85 179.07,46.61 180.72,44.97 185.82,44.97 187.43,43.35 190.79,43.35 191.25,43.81 200.19,43.81 200.87,43.14 201.49,43.14 210.87,43.14 211.92,42.08 218.63,42.08 219.55,43 220.51,43 221.1,43.58 223.98,43.58 229.17,48.77 229.17,50.24 229.38,50.46 229.38,51.55 228.92,52.01 228.92,53.53 231.41,56.01 231.41,59 233.93,61.52 233.93,61.78 v4(234.37,62.22)
  BOTTOM w0.076: 152.79,57.61 151.93,58.47 151.93,59.55 UC1.BA8
  BOTTOM w0.086: RC364.1 162.6,55.76 v2(162.15,56.22) 162.1,56.17 154.23,56.17 152.79,57.61
ISH_GP2: length 1.3
  TOP w0.086: DZ102.1 234.82,56.49 235.03,56.28 RZ507.1
ISH_GP2_D: length 118.1
  TOP w0.086: v3(231.26,57.13) 231.26,56.85 v1(231.39,56.72) 231.63,56.49 DZ102.2 233.01,57.14 RZ503.1 ; v3(162.27,58.35) 162.22,58.35 162.27,58.4 162.27,60.66 164.58,62.97 167.01,62.97 167.52,63.48 167.52,64.09 167.38,64.23 v2(166.58,64.23)
  GND1 w0.086: v4(230.78,56.44) 230.7,56.44 230.7,56.45 230.73,56.45 231.26,56.99 v3(231.26,57.13) ; v3(162.27,58.35) 162.37,58.35 v4(162.88,57.84)
  IN2 w0.061: v4(230.78,56.44) 230.65,56.44 230.65,56.4 230.27,56.02 230.27,55.4 228.55,53.68 228.55,51.85 229.01,51.39 229.01,50.63 226.2,47.82 226.2,46.33 223.83,43.96 219.98,43.96 218.48,42.46 212.08,42.46 211.02,43.51 201.33,43.51 201.02,43.51 200.35,44.18 191.09,44.18 190.63,43.73 187.59,43.73 185.28,46.03 180.18,46.03 179.52,46.69 179.52,50.03 172.97,56.57 172.97,60.47 171.72,61.72 171.72,62.68 170.62,63.78 170.62,64.12 170.32,64.42 169.54,64.42 169.36,64.25 166.59,64.25 v2(166.58,64.23)
  GND5 w0.086: v4(162.88,57.84) 163.03,57.69 v5(163.03,57.18)
  BOTTOM w0.076: 153.61,57.92 153.3,57.92 152.53,58.7 UC1.BB7
  BOTTOM w0.086: 153.61,57.92 154.86,56.67 161.37,56.67 162.44,57.74 RC501.1 v5(163.03,57.18)
ISH_GP3: length 13.7
  TOP w0.086: v2(235.02,53.83) 235.02,54.46 RZ508.1 234.66,54.85 DZ103.1
  BOTTOM w0.086: v2(235.02,53.83) 235.69,54.5 v1(235.69,55.63) 235.69,55.83 238.23,58.36 238.23,59.65 238.14,59.74 238.14,62.06 237.66,62.54 237.46,62.54 236.85,63.15 RZ145.1
ISH_GP3_D: length 120.1
  TOP w0.086: RZ504.1 234.98,55.42 233.27,55.42 232.69,54.85 DZ103.2 ; DZ103.2 231.26,54.85 v3(230.75,55.36) ; DZ103.2 232.19,54.87 232.19,55.34 230.94,56.59 230.94,57.75 v1(231.69,58.51) ; v2(162.15,56.8) 161.9,57.05 161.9,60.65 164.43,63.18 166.71,63.18 167.06,63.53 v2(167.06,63.83)
  GND1 w0.086: v3(230.75,55.36) 230.7,55.41 v4(230.7,55.86)
  IN2 w0.061: v4(230.7,55.86) 230.7,55.57 228.74,53.61 228.74,51.93 229.2,51.47 229.2,50.55 226.39,47.74 226.39,46.25 223.9,43.77 220.05,43.77 218.56,42.27 212,42.27 210.94,43.33 201.41,43.33 200.94,43.33 200.27,44 191.17,44 190.71,43.54 187.51,43.54 185.21,45.85 180.1,45.85 179.3,46.65 179.3,49.98 172.75,56.53 172.75,60.37 171.49,61.63 171.49,62.59 170.52,63.57 167.33,63.57 v2(167.06,63.83)
  BOTTOM w0.076: 153.08,57.87 152.82,57.87 152.13,58.56 152.13,59.01 152.43,59.31 UC1.BA7
  BOTTOM w0.086: RC502.1 162.8,56.8 v2(162.15,56.8) 161.76,56.42 154.53,56.42 153.08,57.87
ISH_I2C0_SCL: length 192.7
  TOP w0.086: LGA1.1 271.54,89.1 v2(271.42,89.22) ; v2(234.36,54.42) 233.85,53.91 229.48,53.91 229,53.43 229,51.87 QZ10.4
  IN1 w0.051: v2(234.36,54.42) 233.88,54.42 v4(230.67,57.62) 232.01,58.95 232.01,61.08 233.93,63 237.05,63 237.56,62.49 243.11,62.49 245.75,65.13 245.75,66.81 250.38,71.44 250.38,76.04 248.09,78.32 248.09,81.69 249.86,83.46 254.23,83.46 256.66,85.89 270.2,85.89 271.09,86.78 271.09,88.89 v2(271.42,89.22)
  IN2 w0.061: v4(230.67,57.62) 229.94,56.88 229.94,55.52 228.03,53.61 228.03,52.55 227.78,52.3 227.78,50.25 224.45,46.92 224.45,45.37 223.66,44.59 219.91,44.59 219.75,44.43 216.51,44.43 215.62,43.54 212.25,43.54 211.4,44.39 201.39,44.39 200.72,45.06 190.73,45.06 190.27,44.61 187.95,44.61 185.27,47.29 182.87,47.29 182.62,47.54 181.9,47.54 180.48,48.96 180.48,50.31 174.27,56.52 174.27,65.22 167.68,71.81 164.11,71.81 162.35,73.57 v4(162.08,73.57)
  GND5 w0.086: v5(162.57,73.75) 162.55,73.72 162.29,73.72 162.14,73.57 v4(162.08,73.57)
  BOTTOM w0.076: UC1.N3 154.87,74.7 155.08,74.77 155.21,74.77 155.22,74.77 155.44,74.71 155.57,74.71 155.72,74.77 155.84,74.77 156.16,74.7 156.56,74.7 156.82,74.44 157.79,74.44 158.23,74.89 158.34,74.89
  BOTTOM w0.086: RZ137.1 236.83,58.04 236.09,57.3 v6(235.83,57.3) 235.01,56.48 235.01,55.22 234.36,54.57 v2(234.36,54.42) ; 158.34,74.89 158.55,75.11 160.44,75.11 161.81,73.75 v5(162.57,73.75)
ISH_I2C0_SDA: length 193.7
  TOP w0.086: QZ10.1 233.82,53.27 v2(234.38,53.83) ; v2(270.68,86.93) 271.62,86.93 272.29,87.6 LGA1.4
  IN1 w0.051: v2(234.38,53.83) 234,53.83 230.8,57.03 v4(230.7,57.03) 230.6,57.03 230.22,57.41 230.22,58.65 231.66,60.1 231.66,61.19 233.78,63.3 237.18,63.3 237.69,62.8 242.98,62.8 244.8,64.61 244.8,66.32 250.06,71.58 250.06,75.9 247.77,78.19 247.77,81.82 249.73,83.78 254.09,83.78 256.57,86.25 270,86.25 v2(270.68,86.93)
  IN2 w0.061: v4(161.66,74.02) 161.77,74.14 162.4,74.14 163.7,72.83 164.37,72.83 165.04,72.16 167.59,72.16 167.63,72.12 167.81,72.12 174.58,65.35 174.58,58.72 176.06,57.24 176.06,56.63 175.68,56.24 175.68,55.55 180.79,50.44 180.79,49.09 182.03,47.85 182.75,47.85 183,47.6 185.4,47.6 188.09,44.92 190.14,44.92 190.6,45.38 200.85,45.38 201.52,44.71 211.53,44.71 212.38,43.86 215.49,43.86 216.38,44.74 219.62,44.74 222.28,47.41 222.88,47.41 225.26,49.79 226.48,49.79 227.46,50.77 227.46,52.43 227.72,52.68 227.72,53.74 229.62,55.65 229.62,57.12 230.52,58.02 230.93,58.02 231.08,57.87 231.08,57.41 v4(230.7,57.03)
  GND5 w0.086: v5(161.63,74.51) 161.66,74.48 v4(161.66,74.02)
  BOTTOM w0.076: UC1.M4 154.55,74.89 154.92,74.89 155.05,74.94 155.24,74.94 155.26,74.93 155.47,74.87 155.54,74.87 155.73,74.95 155.84,74.95 156.03,74.9 156.17,74.87 156.63,74.87 156.88,74.61 157.62,74.61 158.18,75.17
  BOTTOM w0.086: v2(234.38,53.83) 234.52,53.97 234.52,54.02 234.76,54.25 234.76,54.48 235.35,55.08 235.35,56.08 237.85,58.58 v6(237.85,59.16) 237.85,59.76 237.22,60.38 RZ140.1 ; 158.18,75.17 158.46,75.45 161.76,75.45 RC358.1 162.45,74.51 v5(161.63,74.51)
