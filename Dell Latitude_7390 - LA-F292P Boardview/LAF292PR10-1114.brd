# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SBIOS_TX: length 121.8
  IN2 w0.061: v2(225.42,46.87) 224.83,46.29 224.83,45.23 223.75,44.14 219.9,44.14 218.4,42.65 212.16,42.65 211.1,43.7 201.26,43.7 201.1,43.7 200.43,44.37 191.01,44.37 190.56,43.92 187.67,43.92 185.36,46.22 180.26,46.22 179.75,46.74 179.75,50.07 173.58,56.24 173.58,64.5 169.47,68.61 168.32,68.61 v2(168.24,68.69)
  BOTTOM w0.086: v2(168.24,68.69) 168.19,68.74 165.32,68.74 165.07,68.49 164.05,68.49 162.9,69.63 158.44,69.63 158.31,69.5 155.84,69.5 UC1.AB2 ; v2(225.42,46.87) 225.57,46.72 226.94,46.72 228.39,45.27 229.48,45.27 232.03,42.72 232.03,38.29 233.57,36.75 233.57,33.64 233.72,33.49 233.72,32.84 234.08,32.48 234.66,32.48 235.39,33.21 239.57,33.21 240.76,34.4 242.84,34.4 243.36,33.88 RE306.1
SD/MMCCD#: length 27.5
  TOP w0.086: v2(277.06,61.5) 277.37,61.19 278.49,61.19 278.59,61.09 v1(278.59,60.91) 278.18,60.49 UR1.31 ; v2(285.35,44.15) 285.93,43.57 JSD1.9
  IN4 w0.051: v2(285.35,44.15) 283.79,44.15 283.18,44.76 283.18,47.09 282.87,47.39 282.87,50.53 283.06,50.72 283.06,57.28 281.01,59.34 279.69,59.34 277.53,61.5 v2(277.06,61.5)
SD/MMCCLK: length 2.9
  TOP w0.086: RR5.1 283.35,54.8 283.09,54.8 281.7,56.19 UR1.17
SD/MMCCLK_R: length 11.3
  TOP w0.086: v1(283.87,51.79) 283.61,52.05 v2(283.61,52.39) 284.4,53.17 CR21.1 RR5.2 ; JSD1.5 284.99,47.87 v2(284.55,47.43)
  IN1 w0.051: v2(284.55,47.43) 284.14,47.43 283.04,48.53 283.04,51.05 283.61,51.63 v2(283.61,52.39)
SD/MMCCMD: length 2.7
  TOP w0.086: UR1.18 282.02,56.59 v1(282.49,56.12) 282.99,55.62 RR6.1
SD/MMCCMD_R: length 10.5
  TOP w0.086: JSD1.3 v2(285.34,49.67) ; RR6.2 v3(284.4,55.58)
  GND1 w0.086: v3(284.4,55.58) 284.12,55.58 v4(283.74,55.2)
  IN1 w0.051: v2(285.34,49.67) 285.17,49.51 283.99,49.51 283.86,49.64 283.86,49.95 283.94,50.02 284.14,50.02 284.24,50.12 284.24,50.56 284.14,50.65 283.89,50.65 283.84,50.71 283.84,51.16 283.89,51.21 284.19,51.21 284.24,51.26 284.24,51.67 284.65,52.08 284.65,54.29 v4(283.74,55.2)
SD/MMCDAT0/RCLK+: length 3.5
  TOP w0.067: UR1.16 280.58,55.19 280.48,55.1 280.48,54.97 280.71,54.74 281.74,54.74 282.25,54.23 282.25,53.92 RR10.1
SD/MMCDAT0/RCLK+_R: length 11.2
  TOP w0.067: JSD1.7 285.56,46.07 285.49,46.01 285.49,45.81 285.43,45.74 284.39,45.74 v2(284.19,45.94) ; RR10.2 282.26,52.28 282.26,51.87 v2(282.47,51.67)
  IN1 w0.051: v2(284.19,45.94) 283.92,45.94 283.85,45.87 283.85,45.67 283.8,45.62 283.6,45.62 283.28,45.94 283.28,47.01 282.26,48.03 282.26,51.46 v2(282.47,51.67)
SD/MMCDAT1/RCLK-: length 3.5
  TOP w0.067: RR9.1 282.07,53.9 282.07,54.15 281.66,54.56 v7(281.35,54.56) 280.64,54.56 280.3,54.9 280.3,55.08 280.18,55.2 UR1.15
SD/MMCDAT1/RCLK-_R: length 11.3
  TOP w0.067: RR9.2 282.08,52.28 282.08,51.88 v2(281.88,51.67) ; JSD1.8 285.56,45.17 285.49,45.24 285.49,45.47 285.4,45.56 284.39,45.56 v2(284.19,45.36)
  IN1 w0.051: v2(284.19,45.36) 284.1,45.45 283.53,45.45 283.11,45.87 283.11,46.94 282.09,47.96 282.09,51.46 v2(281.88,51.67)
SD/MMCDAT2: length 2.5
  TOP w0.086: UR1.20 281.58,57.39 281.81,57.16 283.12,57.16 RR8.1
SD/MMCDAT2_R: length 10.5
  TOP w0.086: v2(285.01,51.62) 285.01,51.56 285.09,51.47 JSD1.1 ; RR8.2 284.76,57.16 v1(285.31,57.16) 285.69,57.16 v2(285.82,57.29)
  IN1 w0.051: v2(285.01,51.62) 285.01,57.82 285.06,57.87 285.46,57.87 285.51,57.82 285.51,57.59 v2(285.82,57.29)
SD/MMCDAT3: length 2.4
  TOP w0.086: UR1.19 282.36,56.99 282.77,56.57 RR7.1
SD/MMCDAT3_R: length 10.5
  TOP w0.086: RR7.2 285.79,56.57 v2(285.84,56.63) ; JSD1.2 285.53,50.57 284.85,49.89 v2(284.75,49.89)
  IN1 w0.051: v2(285.84,56.63) 285.39,56.17 285.39,51.29 285.03,50.94 285.03,50.17 v2(284.75,49.89)
SD_GPIO0: length 3
  TOP w0.086: UR1.32 277.78,60.56 277.68,60.66 v1(277.32,60.66) 277.26,60.66 276.63,61.29 276.63,61.34 276.26,61.72 RR3.2
SD_GPIO1: length 3.7
  TOP w0.086: RR22.2 275.38,61.72 275.75,61.34 275.75,60.92 v1(276.05,60.63) 276.68,60 276.68,59.07 276.77,58.99 UR1.1
SD_RCOMP: length 1.3
  TOP w0.381: v2(152.73,70.68) 152.58,70.82 RC96.1
  BOTTOM w0.254: v2(152.73,70.68) 152.75,70.66 152.8,70.44 152.84,70.27 152.82,70.24 UC1.AB7
SD_UHS2_D0N: length 29.5
  TOP w0.067: v2(297.47,47.36) 297.77,47.66 298.41,47.66 298.49,47.57 298.49,47.37 298.57,47.29 JSD1.19 ; UR1.25 280.58,60.12 280.48,60.21 280.48,60.54 v2(280.69,60.75)
  IN2 w0.058: v2(280.69,60.75) 280.76,60.82 280.76,61.09 280.7,61.15 280.43,61.15 280.37,61.21 280.37,61.51 280.47,61.62 282.23,61.62 282.3,61.62 283.94,59.98 283.94,56.74 286.03,54.65 289.94,54.65 296.96,47.63 297.21,47.63 v2(297.47,47.36)
SD_UHS2_D0P: length 29.5
  TOP w0.067: v2(297.46,48.13) 297.74,47.85 298.39,47.85 298.48,47.94 298.48,48.13 298.56,48.2 JSD1.18 ; UR1.26 280.18,60.1 280.3,60.23 280.3,60.56 v2(280.11,60.75)
  IN2 w0.058: v2(297.46,48.13) 297.11,47.79 297.03,47.79 290.01,54.81 286.09,54.81 284.1,56.81 284.1,59.91 284.1,59.91 284.1,60.04 282.37,61.78 282.17,61.78 280.4,61.78 280.21,61.58 280.21,60.85 v2(280.11,60.75)
SD_UHS2_D1N: length 31.3
  TOP w0.067: UR1.23 281.73,58.59 281.81,58.51 281.81,58.43 281.87,58.37 282.05,58.37 282.18,58.5 282.18,59.09 281.91,59.37 281.91,59.85 282.08,60.02 v2(282.08,60.34) ; JSD1.21 298.56,45.47 298.49,45.41 298.49,45.18 298.43,45.11 297.57,45.11 297.41,44.95 297.41,44.63 v2(297.16,44.38)
  IN2 w0.058: v2(297.16,44.38) 297.34,44.56 297.34,46.22 290.59,52.98 286.45,52.98 285.73,53.69 285.73,53.92 281.69,57.96 281.59,58.06 281.59,59.71 281.62,59.74 282.08,60.2 v2(282.08,60.34)
SD_UHS2_D1P: length 31.3
  TOP w0.067: v2(297.95,44.38) 297.59,44.73 297.59,44.88 297.64,44.93 298.43,44.93 298.49,44.86 298.49,44.63 298.56,44.56 JSD1.22 ; UR1.22 282.12,58.19 282.36,58.43 282.36,59.17 282.09,59.44 282.09,59.78 282.24,59.92 v2(282.49,59.92)
  IN2 w0.058: v2(297.95,44.38) 297.77,44.56 297.56,44.56 297.5,44.62 297.5,46.29 290.65,53.14 286.51,53.14 285.89,53.76 285.89,53.98 281.75,58.12 281.75,59.65 281.98,59.88 282.09,59.88 282.22,59.74 282.31,59.74 v2(282.49,59.92)
SDWP: length 5.9
  TOP w0.086: v1(279.76,62.63) 278.12,62.63 277.92,62.43 QR1.1 278.73,61.81 278.99,61.55 278.99,60.61 278.81,60.44 278.64,60.44 278.58,60.37 UR1.30
SIM_DET: length 104
  IN1 w0.051: JNGFF2.66 231.51,72.4 230.05,70.94 230.05,68.62 233,65.67 236.35,65.67 237.22,66.54 241.89,66.54 242.43,67.08 242.43,72.3 243.13,73 243.13,78.66 242.41,79.38 v4(242.41,80.76)
  IN4 w0.051: v4(242.41,80.76) 242.41,84.48 243.59,85.66 269.6,85.66 272.8,82.46 272.8,77.71 276.58,73.93 276.58,72.02 278.53,70.07 278.53,67.44 282.52,63.44 282.52,61.87 284.55,59.85 v4(284.55,57.11)
  GND5 w0.127: v4(284.55,57.11) v5(284.55,56.63)
  BOTTOM w0.117: v5(284.55,56.63) 284.17,56.25 JSIM1.10
SIO_EXT_SCI#: length 1.9
  TOP w0.086: v3(152.62,64.65) 152.18,64.65 RC561.2
  GND1 w0.086: v4(152.14,64.71) 152.19,64.65 v3(152.62,64.65)
  GND5 w0.086: v5(152.56,64.41) 152.27,64.71 v4(152.14,64.71)
SIO_EXT_SMI#: length 18
  TOP w0.086: RC346.1 161.8,87.8 v1(161.09,87.8) 160.76,87.8 158.44,85.48 152.77,85.48 152.38,85.09 152.36,85.09 150.74,83.47 150.74,82.4 151.47,81.67 152.77,81.67 v2(153.03,81.92)
  BOTTOM w0.086: v2(153.03,81.92) 153.03,81.49 153.08,81.44 153.08,81.21 UC1.A6
SIO_EXT_WAKE#: length 160.9
  GND1 w0.117: v3(268.19,55.81) 268.19,55.81 v4(268.6,56.22)
  IN3 w0.061: v2(166.82,67.19) 167.24,67.19 170.52,63.91 170.52,60.53 171.59,59.46 171.59,56.67 178.33,49.93 178.33,47.13 181.4,44.06 184.99,44.06 187.52,41.53 190.72,41.53 191.02,41.22 214.26,41.22 214.41,41.38 216.93,41.38 217.35,41.79 221.86,41.79 223.2,43.14 224.95,43.14 232.2,50.39 232.2,54.06 234.94,56.81 235.05,56.81 239.32,61.08 242.28,61.08 245.04,63.84 248.94,63.84 250.21,65.11 251.42,65.11 252.59,66.28 256.3,66.28 256.75,65.84 260.32,65.84 261.56,67.08 v4(261.56,68.92)
  GND5 w0.127: v5(268.17,56.68) 268.17,56.65 v4(268.6,56.22) ; v5(262.04,68.92) v4(261.56,68.92)
  BOTTOM w0.086: v5(262.04,68.92) 262.88,68.92 263.09,69.12 267.16,69.12 270.18,66.1 270.18,61.56 268.17,59.55 v5(268.17,56.68) ; RC283.1 166.82,66.43 v2(166.82,67.19) 166.6,67.41 v6(164.71,67.41) 163.98,67.41 162,69.39 158.6,69.39 158.41,69.19 UC1.AC1
SIO_PWRBTN#: length 393.3
  TOP w0.086: UE1.K11 v2(267.76,57.04) ; JXDP1.41 64.47,92.42 v2(64.89,92.85) ; v2(69.65,32.45) 70.47,31.63 73.63,31.63 76.12,34.12 78.66,34.12 80.31,32.47 80.31,31.07 81.46,29.92 107.78,29.92 v1(110.86,26.83) 111.6,26.09 145.95,26.09 148.21,28.36 154.76,28.36 156.18,26.94 160.39,26.94 v2(160.57,26.76)
  IN1 w0.051: v4(54.22,78.5) 53.59,78.5 48.5,73.41 v4(48.5,73.09)
  IN2 w0.061: v4(48.5,73.09) 47.1,73.09 45.35,71.35 45.35,62.19 47.15,60.39 47.15,58.62 46.89,58.37 45.48,58.37 44.56,57.44 44.56,53.41 43.36,52.2 43.36,48.14 42.54,47.32 v4(42.54,46.63) ; v2(150.75,52.87) 150.75,52.11 154.45,48.41 158.98,48.41 161.59,45.8 161.59,44.6 163.74,42.45 163.74,40.62 164.3,40.06 165.35,40.06 168.57,36.85 168.57,35.31 169.24,34.64 172.12,34.64 v4(173.32,33.44) 174.85,31.91 179.94,31.91 181.11,30.74 187.7,30.74 188.22,30.22 200.52,30.22 200.99,29.76 208.31,29.76 209.24,30.69 v4(209.25,30.69)
  IN3 w0.061: v4(51.31,86.58) 52.44,85.44 56.06,85.44 57.02,86.4 57.02,86.72 58.91,88.61 58.91,91.42 59.66,92.17 59.66,92.93 60.16,93.43 62.43,93.43 63.41,92.45 64.61,92.45 64.89,92.73 v2(64.89,92.85) ; v2(267.76,57.04) 267.4,56.67 266.01,56.67 265.73,56.39 265.73,56.07 265.52,55.87 264.92,55.87 264.53,55.48 264.53,54.8 263.85,54.11 263.06,54.11 262.65,53.7 262.65,52.08 262.91,51.82 262.91,50.38 262.42,49.89 258.22,49.89 255.99,47.67 255.99,44.15 256.57,43.58 256.57,39.67 255.36,38.46 255.36,34.98 251.11,30.72 241.8,30.72 241.28,31.25 226.52,31.25 225.85,31.91 210.46,31.91 209.25,30.71 v4(209.25,30.69)
  IN4 w0.051: v2(62.4,46.16) 61.7,45.46 56.63,45.46 56.51,45.58 54.21,45.58 53.65,45.02 42.25,45.02 41.83,45.44 41.83,46.4 42.05,46.63 v4(42.54,46.63) ; v4(51.31,86.58) 51.31,84.66 54.22,81.75 v4(54.22,78.5)
  GND5 w0.086: v4(173.32,33.44) 173.32,32.93 v5(173.58,32.67)
  BOTTOM w0.076: UC1.BA15 147.32,59.08 147.32,57.37 148.14,56.55 148.14,56.3 149.7,54.75
  BOTTOM w0.086: CC269.1 RC241.1 65.26,92.48 v2(64.89,92.85) ; v2(69.65,32.45) 69.67,32.47 69.67,35.96 69.61,36.01 69.61,42.53 68.33,43.81 64.89,43.81 62.54,46.16 v2(62.4,46.16) ; v2(150.75,52.87) 150.75,53.19 149.7,54.24 149.7,54.75
  BOTTOM w0.117: v2(160.57,26.76) 161.08,26.25 171.65,26.25 173.73,28.33 173.73,32.45 173.58,32.61 v5(173.58,32.67)
SIO_SLP_A#: length 198.1
  TOP w0.086: v3(198.64,35.18) 197.82,36 197.82,39.72 196.87,40.67 v6(195.99,40.67) 193.46,40.67 192.34,41.78 JAPS1.6 ; UE1.M11 v2(267.76,55.44)
  GND1 w0.086: v4(199.27,34.7) 198.8,35.17 198.65,35.17 v3(198.64,35.18)
  IN1 w0.051: 199.29,34.68 v4(199.27,34.7) ; 199.29,34.68 199.23,34.68 198.86,34.3 198.48,34.3 197.74,35.05 185.1,35.05 183.08,37.06 179.24,37.06 178.82,37.49 172.34,37.49 170.08,39.74 166.35,39.74 165.91,40.19 161.76,40.19 161.39,40.56 161.37,40.56 161.14,40.78 161.14,40.81 159.69,42.26 159.69,45 157.73,46.95 156.83,46.95 154.5,49.28 154.5,51.24 154.73,51.47 154.73,55.5 149.96,60.27 148.77,60.27 148.28,60.77 147.41,60.77 147.15,61.03 146.44,61.03 146.25,61.22 146.25,64.33 v2(146.62,64.7) ; 199.29,34.68 199.67,34.3 206.76,34.3 206.86,34.2 217.87,34.2 218.95,35.28 223.52,35.28 224.91,36.66 235.63,36.66 236.01,36.28 240.23,36.28 241.74,37.8 241.74,41.75 v4(241.06,42.43) ; v2(255.01,49.06) 254.12,49.95 254.12,54.72 254.65,55.26 254.65,56.52 254.3,56.88 254.3,59.28 252.2,61.38 v4(250.69,61.38)
  IN2 w0.061: v4(250.69,61.38) 250.17,60.85 249.46,60.85 248.26,59.65 241.17,59.65 239.4,57.89 239.4,56.79 241.6,54.59 241.6,48.87 240.78,48.05 240.78,42.71 v4(241.06,42.43)
  BOTTOM w0.086: v2(255.01,49.06) 255.57,49.06 255.72,48.9 256.79,48.9 257.32,49.44 263.42,49.44 266.08,52.1 266.08,52.82 267.76,54.5 v2(267.76,55.44) ; v2(146.62,64.7) 146.62,64.68 146.89,64.41 UC1.AN16
SIO_SLP_LAN#: length 167
  TOP w0.086: UE1.H9 v2(266.16,58.64)
  IN3 w0.061: v4(255.03,48.47) 255.78,48.47 257.28,49.97 257.28,51.62 258.05,52.39 259.41,52.39 261.78,54.76 261.78,55.65 261.99,55.86 262.4,55.86 262.63,56.09 262.63,56.37 262.88,56.63 263.24,56.63 263.39,56.78 263.39,57.16 263.64,57.41 264.25,57.41 265.09,58.25 265.5,58.25 265.88,58.64 v2(266.16,58.64)
  IN4 w0.051: v4(255.03,48.47) 253.34,46.78 253.34,42.33 254.15,41.52 254.15,39.6 254.72,39.03 254.72,31.71 253.17,30.16 252.39,30.16 251.87,29.64 237.14,29.64 235.89,30.89 232.08,30.89 231.61,30.42 225.61,30.42 224.8,31.23 219.33,31.23 218.94,30.85 213.73,30.85 211.41,28.52 207.34,28.52 206.38,29.48 205.8,29.48 205.1,30.18 195.61,30.18 195.49,30.06 195.03,30.06 194.95,30.13 188.05,30.13 187.28,30.9 180.23,30.9 179.77,31.36 178.59,31.36 177.58,32.37 173.68,32.37 170.52,35.53 170.23,35.53 168.32,37.44 168.32,38.85 167.48,39.68 166.62,39.68 165.29,41.01 165.29,43.77 164.58,44.48 163.71,44.48 162.04,46.15 159.7,46.15 159.12,46.73 159.12,49.31 156.78,51.66 v2(156.78,52.18)
  BOTTOM w0.076: 148.49,56.69 147.85,57.32 147.85,60.01 UC1.AW15
  BOTTOM w0.086: v2(156.78,52.18) 156.78,51.36 RC68.1 RC344.1 155.74,51.9 155.31,52.33 152.85,52.33 148.49,56.69
SIO_SLP_S0#: length 126.5
  TOP w0.086: v2(175.23,42.31) 175.23,42.33 ; 175.23,42.33 175.21,42.31 175.04,42.31 174.92,42.19 174.35,42.19 172.82,40.66 172.82,38.47 172.31,37.96 172.31,35.96 171.87,35.52 171.06,35.52 v3(170.98,35.44) 170.98,34.42 PR426.1 170.34,33.78 170.34,33.65 v1(169.44,32.75) 169.23,32.55 169.23,28.96 169.47,28.72 169.47,28.44 PR425.1 ; 175.23,42.33 175.35,42.45 177.44,42.45 178.05,41.84 179.26,41.84 179.66,42.24 180.12,42.24 180.48,42.6 180.48,43.24 181.35,44.1 183.69,44.1 185.04,45.46 188.02,45.46 188.26,45.22 188.26,43.47 187.84,43.05 JAPS1.15 ; v2(170.75,84.57) 170.75,83.42 171.98,82.2 171.98,76.78 169.54,74.34 169.54,67.97 169.17,67.61 169.05,67.48 169.05,67.48 168.92,67.36 168.92,63.96 167.29,62.33 164.88,62.33 163,60.46 163,54.01 162.84,53.85 162.84,53.25 163.2,52.89 163.2,49.46 v3(161.64,47.89)
  GND1 w0.086: v3(161.64,47.89) 161.21,47.89 v4(160.62,48.47) ; v4(171.28,35.82) 170.98,35.52 v3(170.98,35.44)
  IN2 w0.061: v2(149.37,62.11) 149.78,62.11 150.02,61.88 150.02,61.07 150.02,61.06 150.02,60.88 158.21,52.69 158.21,50.89 v4(160.62,48.47) 160.62,48.06 163.31,45.37 163.31,44.82 164.38,43.74 164.48,43.74 165.11,43.11 165.11,42.57 168.75,38.93 169.85,38.93 171.52,37.26 171.52,36.05 171.29,35.82 v4(171.28,35.82)
  GND5 w0.086: v5(170.76,36.05) 171.05,36.05 v4(171.28,35.82)
  BOTTOM w0.086: UZ35.1 172.53,85.22 171.87,84.57 v2(170.75,84.57) ; v5(170.76,36.05) 170.6,36.2 169.45,36.2 169.17,36.48 RZ363.1 ; RZ362.2 172.86,40.85 173.66,41.65 RZ112.1 174.66,41.74 v2(175.23,42.31) ; UC1.AT11 149.72,62.46 v2(149.37,62.11)
SIO_SLP_S3#: length 447.8
  TOP w0.086: v3(200.5,28.41) 200.27,28.64 v1(200.27,29.04) 200.27,35.31 199.09,36.49 199.09,39.48 196.92,41.65 194.46,41.65 194.34,41.77 JAPS1.2 ; RE280.1 255.82,74.02 256.05,73.8 256.05,72.65 255.57,72.17 UE5.1 255.57,71.05 255.74,70.87 257.07,70.87 257.45,71.26 257.45,72.14 v2(257.47,72.17) 259.47,72.17 259.53,72.1 UE3.2 ; v3(258.25,43.38) 258.21,43.38 258.13,43.3 257.17,43.3 256.91,43.04 251.96,43.04 251.24,43.76 251.24,44.86 QE11.2 ; v3(172.51,40.22) 172.58,40.15 172.58,38.53 172.07,38.02 172.07,36.01 171.79,35.74 170.61,35.74 169.13,34.26 169.13,33.95 169.01,33.84 169.01,28.74 v3(169.15,28.6) ; UE1.K9 v2(266.16,57.04)
  GND1 w0.086: v3(258.25,43.38) 258.25,43.79 v4(258.49,44.03) ; v3(200.5,28.41) 200.5,28.06 v4(200.65,27.9) ; v3(172.51,40.22) 172.51,40.52 v4(172.79,40.8) ; v3(169.15,28.6) 169.08,28.53 169.08,28.46 v4(168.85,28.23)
  IN1 w0.051: v4(172.79,40.8) 172.39,41.2 165.12,41.2 163.37,42.96 163.09,42.96 161.42,44.62 161.42,46.12 158.89,48.65 158.03,48.65 156.72,49.96 156.72,50.13 156.23,50.63 156.23,55.37 149.97,61.62 149.97,62.37 149.31,63.03 148.88,63.03 v2(148.45,63.46) ; v2(266.16,57.04) 265.76,57.44 264.99,57.44 264.46,56.9 264.46,50.47 263.73,49.74 263.73,48.19 263.16,47.62 262.87,47.62 262.19,46.95 262.19,46.65 261.85,46.31 260.39,46.31 260.14,46.06 260.14,45.92 258.49,44.27 v4(258.49,44.03) 259.1,43.42 259.1,42.39 257.79,41.08 257.79,39.6 256.47,38.28 256.47,31.91 253.96,29.4 253.96,28.59 253.12,27.74 251.19,27.74 250.69,28.25 236.22,28.25 235.82,27.84 234.47,27.84 233.76,28.56 229.41,28.56 228.84,28 220.35,28 219.76,27.41 207.29,27.41 206.21,28.48 200.98,28.48 200.65,28.15 v4(200.65,27.9) 200.58,27.83 195.52,27.83 195.35,28.01 182.28,28.01 180.22,30.07 173.5,30.07 172.02,28.59 169.21,28.59 v4(168.85,28.23)
  IN2 w0.061: v4(28.8,68.94) 28.63,68.78 28.07,68.78 27.15,69.7 24.53,69.7 19.73,64.9 19.73,49.3 19.26,48.82 19.26,48.67 19.26,41.98 20.17,41.07 v2(20.17,40.78)
  IN4 w0.051: v4(168.85,28.23) 168.25,28.83 165.62,28.83 164.8,29.65 160.93,29.65 157.94,32.64 125.38,32.64 125.06,32.95 95.69,32.95 95.36,33.28 92.61,33.28 90.68,35.2 90.68,40.37 90.11,40.94 90.11,42.44 87.82,44.74 81.16,44.74 80.11,45.79 78.61,45.79 78.3,45.49 76.5,45.49 76.29,45.28 75.4,45.28 75.01,45.68 73.73,45.68 73.15,45.09 69.99,45.09 69.23,44.33 68,44.33 67.54,43.87 64.19,43.87 63.24,42.92 63.24,42.25 62.96,41.97 59.91,41.97 59.39,42.49 54.32,42.49 53.62,43.19 51.45,43.19 50.99,42.73 48.24,42.73 46.33,40.83 37.15,40.83 36.09,39.76 34.26,39.76 33.98,39.48 32.97,39.48 32.11,38.62 26.87,38.62 25.54,37.3 24.8,37.3 22.61,39.48 21.18,39.48 20.17,40.48 v2(20.17,40.78)
  GND5 w0.086: v5(29.1,68.56) 29.1,68.64 v4(28.8,68.94)
  BOTTOM w0.076: UT1.D2 29.57,63.42 29.57,64.21
  BOTTOM w0.086: v2(266.16,57.04) 266.57,57.44 266.57,59.7 266.01,60.26 265.4,60.26 264.99,60.66 264.99,64.5 263.17,66.32 260.64,66.32 258.37,68.59 258.37,71.27 v2(257.47,72.17) ; v5(29.1,68.56) 29.01,68.48 29.01,65.66 29.58,65.1 29.58,64.22 29.57,64.21 ; UC1.AP15 148.15,63.76 v2(148.45,63.46)
SIO_SLP_S4#: length 372.1
  TOP w0.086: v3(161.19,45.21) 161.21,45.23 161.21,46.36 163.96,49.12 163.96,52.6 165.82,54.46 168.96,54.46 171.09,56.59 171.09,60.29 170.59,60.79 170.59,66.6 171.38,67.39 171.38,73.65 174.52,76.78 174.52,83.15 172.75,84.91 172.75,89.07 171.6,90.23 167.33,90.23 v1(163.45,94.11) ; v3(198.42,29.85) 199.78,31.22 199.78,35.11 198.63,36.26 198.63,39.25 196.72,41.16 193.51,41.16 192.84,41.83 JAPS1.5 ; PR208.1 89.06,47.08 89.53,46.61 v3(89.53,45.45) ; UE1.N12 267.77,54.59 v3(267.71,54.59)
  TOP w0.117: UZ21.4 v1(163.45,94.11)
  GND1 w0.086: v3(81.11,55.86) v4(80.62,55.86) ; v4(89.2,45.81) 89.53,45.48 v3(89.53,45.45) ; v3(161.19,45.21) 160.61,44.64 v4(160.34,44.64) ; v3(198.42,29.85) 198.37,29.8 198.26,29.8 198.05,29.59 v4(198.05,29.49) ; v3(94.32,41.65) 94.29,41.65 v4(93.57,42.38)
  GND1 w0.117: v3(267.71,54.59) v4(267.07,54.59)
  IN1 w0.051: v2(256.24,49.53) 256.24,47.79 255.61,47.17 255.61,40.27 254.79,39.45 254.79,34.39 250.32,29.92 230.99,29.92 230.8,30.11 227.06,30.11 226.17,29.22 220.86,29.22 220.86,29.22 219.75,29.22 219.16,28.63 208.15,28.63 206.93,29.84 200.48,29.84 199.69,29.05 198.48,29.05 v4(198.05,29.49) 197.62,29.05 196.03,29.05 195.85,29.23 182.89,29.23 180.69,31.43 173.04,31.43 171.5,29.89 170.01,29.89 v4(168.69,31.21) 168.55,31.35 168.55,31.94 166.05,34.44 159.87,34.44 158.37,32.94 127.74,32.94 126.48,31.68 126.48,31.23 125.72,30.46 110.2,30.46 107.77,32.9 97.1,32.9 95.75,34.25 91.1,34.25 89.81,35.54 89.81,38.03 88.97,38.87 88.97,45.58 v4(89.2,45.81)
  IN2 w0.061: v4(149.32,52.92) 148.82,52.42 148.82,51.12 152.68,47.26 157.65,47.26 160.05,44.86 160.12,44.86 v4(160.34,44.64) 160.16,44.45 160.16,42.12 160.93,41.35 160.93,39.87 162.48,38.33 162.48,37.04 163.92,35.59 165.61,35.59 168.69,32.52 v4(168.69,31.21) ; v4(80.62,55.86) 80.62,54.73 81.11,54.25 81.11,50.47 82.22,49.35 82.22,47.76 83.92,46.06 88.94,46.06 v4(89.2,45.81) 89.2,45.3 92.12,42.38 v4(93.57,42.38)
  GND5 w0.086: v5(149.31,53.43) 149.31,52.92 v4(149.32,52.92)
  GND5 w0.127: v5(266.77,54.21) 266.77,54.29 v4(267.07,54.59)
  BOTTOM w0.076: UC1.BA16 146.99,59.64 146.99,57.2 147.81,56.39 147.81,56 148.66,55.15
  BOTTOM w0.086: v5(266.77,54.21) 265.87,53.3 265.87,52.19 263.33,49.65 256.36,49.65 v2(256.24,49.53) ; 148.66,55.15 148.84,54.97 148.84,53.9 v5(149.31,53.43)
SIO_SLP_S5#: length 176.8
  TOP w0.086: UE1.N8 265.65,54.35 v2(265.65,53.98) ; v3(199,29.9) v1(199.93,30.83) 200.02,30.93 200.02,35.21 198.84,36.39 198.84,39.38 196.82,41.41 193.61,41.41 193.34,41.67 JAPS1.4
  GND1 w0.086: v3(199,29.9) 198.8,29.7 198.8,29.47 v4(198.79,29.46)
  IN2 w0.061: v2(148.4,53.96) 149.47,53.96 150.03,53.4 150.03,50.44 152.76,47.71 157.79,47.71 160.16,45.34 160.46,45.34 160.94,44.85 160.94,44.17 161.46,43.65 161.46,42.66 162.35,41.77 162.35,40.93 163.03,40.24 163.05,40.24 163.11,40.18 163.11,38.94 168.02,34.03 168.96,34.03 168.99,34 171.77,34 173.54,32.23 174.61,31.16 179.8,31.16 180.85,30.11 187.44,30.11 188.49,29.06 198.39,29.06 v4(198.79,29.46)
  IN3 w0.061: v2(265.65,53.98) 265.65,52.33 264,50.68 263.66,50.68 262.56,49.58 260.76,49.58 258.62,47.44 257.81,47.44 256.31,45.94 256.31,44.28 256.88,43.71 256.88,39.54 255.67,38.33 255.67,34.85 251.24,30.41 241.67,30.41 241.15,30.93 226.13,30.93 225.5,31.56 210.82,31.56 209.36,30.1 199.42,30.1 v4(198.79,29.46)
  BOTTOM w0.076: 148.34,55.11 147.64,55.81 147.64,56.27 146.83,57.09 146.83,59.24 146.66,59.4 146.66,59.83 146.88,60.19 UC1.AY16
  BOTTOM w0.086: 148.34,55.11 148.4,55.05 v2(148.4,53.96)
SIO_SLP_SUS#: length 162.5
  TOP w0.086: v2(260.88,51.24) 260.82,51.29 RE349.1 ; v3(169.21,36.53) RC441.1 168.65,36.75 168.27,37.13 v1(168.27,37.49)
  GND1 w0.086: v4(170.38,36.42) 169.32,36.42 v3(169.21,36.53)
  IN2 w0.061: v4(222.55,27.47) 222.55,27.21 221.98,26.65 200.8,26.65 199.33,28.12 188.03,28.12 186.99,29.16 180.47,29.16 179.41,30.22 174.25,30.22 173,31.46 v4(171.06,31.46) ; v4(170.38,36.42) 170.36,36.42 168.04,38.74 167.71,38.74 164.92,41.53 164.92,43.04 164.41,43.55 164.3,43.55 163.12,44.74 163.12,45.3 159.56,48.86 159.56,49.27 158.02,50.81 158.02,52.56 149.64,60.94 149.14,60.94 148.88,61.2 148.88,62.44 147.97,63.36 147.97,63.64 v4(147.54,64.07)
  IN4 w0.051: v2(260.88,51.24) 260.44,50.81 260.44,47.39 260.29,47.24 260.29,46.86 259.8,46.36 259.8,42.96 257.68,40.84 257.68,38.48 258.31,37.85 258.31,35.25 257.12,34.06 257.12,29.16 255.94,27.98 254.87,27.98 254.33,27.43 242.64,27.43 242.08,26.88 234.09,26.88 232.99,27.97 230.62,27.97 229.48,26.83 223.18,26.83 v4(222.55,27.47)
  GND5 w0.086: v5(171.52,31.61) 171.14,31.61 171.06,31.52 v4(171.06,31.46) ; v5(170.4,35.87) 170.4,36.4 v4(170.38,36.42) ; v5(147.99,64.41) 147.64,64.07 v4(147.54,64.07)
  BOTTOM w0.086: v5(171.52,31.61) 171.52,32.34 170.4,33.46 v5(170.4,35.87)
SIO_SLP_SUS#_R: length 10.2
  TOP w0.086: v3(260.82,52.77) 260.82,54.04 UE1.N4 ; RE561.1 259.36,47.24 259.36,48.38 v3(259.32,48.41)
  GND1 w0.086: v3(259.32,48.41) 259.32,48.97 v4(259.37,49.02) ; v3(260.82,52.77) 260.82,51.99 v4(260.89,51.93)
  IN1 w0.051: v4(259.37,49.02) 259.86,49.02 261.29,50.45 261.29,51.53 v4(260.89,51.93)
SIO_SLP_WLAN#: length 179.3
  TOP w0.086: UE1.D9 v2(266.16,62.58)
  IN1 w0.051: v4(271.59,57.8) 270.67,58.72 270.25,58.72 269.54,59.43 269.54,61.11 268.22,62.43 268.22,62.85 268.04,63.03 266.61,63.03 v2(266.16,62.58)
  IN2 w0.061: v4(199.55,29.49) 198.93,28.87 188.41,28.87 187.36,29.93 180.77,29.93 179.72,30.97 174.53,30.97 171.69,33.81 167.98,33.81 162.97,38.82 162.25,38.82 161.11,39.95 161.11,41.43 160.37,42.18 160.37,43.87 160.75,44.25 160.75,44.78 160.41,45.11 160.07,45.11 157.69,47.48 152.72,47.48 149.8,50.4 149.8,53.15 149.5,53.45 148.12,53.45 147.61,53.96 v2(147.61,54.01)
  IN3 w0.061: v4(199.55,29.49) 199.94,29.88 209.4,29.88 210.9,31.37 225.42,31.37 226.08,30.72 232.55,30.72 v4(232.96,30.31) 233.39,30.74 240.92,30.74 241.44,30.22 251.32,30.22 255.86,34.77 255.86,38.25 257.07,39.46 257.07,43.78 256.5,44.36 256.5,45.86 257.88,47.24 258.73,47.24 260.89,49.39 262.63,49.39 263.72,50.48 264.06,50.48 266.5,52.92 268.62,52.92 270.73,55.03 270.73,56.33 271.59,57.19 v4(271.59,57.8)
  GND5 w0.086: v4(232.96,30.31) 232.96,30.45 v5(233.25,30.74)
  BOTTOM w0.076: 147.26,55.39 147.26,56.12 146.5,56.88 146.5,58.59 UC1.BB17
  BOTTOM w0.086: v5(233.25,30.74) 233.58,31.07 236.22,31.07 236.58,31.43 QZ15.1 ; v2(147.61,54.01) 147.61,55.03 147.26,55.39
SLEEVE:
  vias: v1(278.68,36.09)
SLEEVE_R:
  vias: v1(289.16,39.01)
SLOT2_SATA_LED#: length 4.6
  TOP w0.086: v1(230.31,83.5) 230.04,83.77 RN101.1 230.87,84.54 JNGFF2.10
SLP_WLAN#_GATE: length 51.8
  GND1 w0.086: v3(265.03,46.12) 265.03,46.45 v4(265.19,46.62)
  IN3 w0.061: v4(265.19,46.62) 263.74,46.62 263.2,46.08 263.2,44.69 261.2,42.7 261.2,40.47 260.18,39.44 260.18,35.64 260.32,35.5 260.32,28.93 257.6,26.22 253.17,26.22 251.8,27.58 240.9,27.58 v4(240.89,27.6)
  GND5 w0.086: v4(240.89,27.6) v5(240.4,27.6)
  BOTTOM w0.086: RZ518.2 237.44,32.43 237.5,32.49 QZ15.2 239,32.49 239.53,31.96 v1(239.53,30.78) 239.53,28.48 v5(240.4,27.6)
SLP_WLAN#_M: length 10.5
  TOP w0.086: v3(233.55,30.86) 233.55,30.93 233.98,31.36 RZ71.1
  GND1 w0.086: v3(233.55,30.86) v4(233.55,30.34)
  GND5 w0.086: v4(233.55,30.34) 233.55,30.45 v5(233.84,30.74)
  BOTTOM w0.086: DZ9.3 238.04,28.65 237.62,29.07 237.62,30.07 238.48,30.93 QZ15.3 237,31.19 236.35,30.54 v1(234.52,30.54) 234.04,30.54 v5(233.84,30.74)
SM_RCOMP0: length 2.7
  TOP w0.127: RC5.1 146.4,63.62 v1(145.91,64.11)
  TOP w0.381: RC5.1 145.9,62.95 v2(145.7,62.75)
  BOTTOM w0.254: v2(145.7,62.75) 146.13,63.09 UC1.AR18
SM_RCOMP1: length 9.6
  TOP w0.381: RC6.1 146.39,55.74 144.57,57.56 v1(144.57,59.33) 144.57,60.77 144.85,61.05 144.85,61.44 145.53,62.11 v2(145.7,62.11)
  BOTTOM w0.254: v2(145.7,62.11) 146.13,62.44 UC1.AT18
SM_RCOMP2: length 10.5
  TOP w0.381: v2(145.7,61.48) 145.45,61.23 145.45,60.82 145.15,60.51 145.15,57.74 v1(146.31,56.58) 147.03,55.86 147.03,53.6 147.51,53.12 RC7.1
  BOTTOM w0.254: UC1.AU18 146.13,61.8 v2(145.7,61.48)
SML0_SMBCLK: length 14.8
  TOP w0.086: CC318.1 v3(159.97,78.61) 160.14,78.78 160.14,79.5 v1(160.17,79.54)
  GND1 w0.086: v3(159.97,78.61) 159.24,78.61 v4(158.82,78.19)
  IN3 w0.061: v2(151.66,73.95) 152.16,73.44 153.87,73.44 154.27,73.85 154.27,76.46 154.53,76.72 155.41,76.72 156.89,78.19 v4(158.82,78.19)
  BOTTOM w0.086: v2(151.66,73.95) 151.66,73.85 151.45,73.65 UC1.R9
SML0_SMBDATA: length 5.5
  TOP w0.086: v2(158.61,71.28) 158.93,70.96 v1(159.11,70.96) 159.86,70.21 RC348.1
  BOTTOM w0.076: UC1.W2 155.77,70.98 155.79,70.97 156.13,70.92 156.39,70.92 156.53,71.05 157.44,71.05 157.57,70.93 158.26,70.93 v2(158.61,71.28)
SML1_SMBCLK: length 156.6
  TOP w0.086: CC319.1 162.57,72.2 RC15.1 162.4,71.15 v3(161.69,71.15) ; UE1.D8 v2(265.36,62.58)
  GND1 w0.086: v3(161.69,71.15) 161.07,71.15 161.05,71.18 v4(160.87,71.18)
  IN3 w0.061: v4(260.81,67.81) 259.77,66.77 258.55,66.77 258.37,66.95 258.06,66.95 257.93,66.82 247.58,66.82 242.15,61.4 239.19,61.4 237.55,59.75 236.44,59.75 235.96,60.23 232.1,60.23 231.21,61.12 230.12,61.12 228.07,59.07 228.07,58.27 228.78,57.56 229.18,57.56 230.04,56.7 230.04,55.21 229.18,54.35 229.18,50.7 229,50.52 229,48.35 224.61,43.96 220,43.96 219.32,43.28 217.65,43.28 216.57,42.19 214.07,42.19 213.92,42.04 191.36,42.04 190.45,42.96 187.25,42.96 185.33,44.88 181.74,44.88 179.15,47.47 179.15,50.01 179.15,50.27 172.44,56.98 172.44,59.76 171.34,60.87 171.34,64.25 164.42,71.17 163.05,71.17 162.72,70.84 161.21,70.84 v4(160.87,71.18)
  GND5 w0.086: v5(160.31,71.33) 160.47,71.18 v4(160.87,71.18)
  GND5 w0.127: v5(260.85,67.29) 260.81,67.33 v4(260.81,67.81)
  BOTTOM w0.076: 159.08,71.39 158.81,71.66 157.78,71.66 157.57,71.45 156.04,71.45 155.9,71.39 155.77,71.39 155.54,71.46 155.54,71.46 155.41,71.46 155.19,71.38 UC1.W3
  BOTTOM w0.086: 159.08,71.39 159.35,71.13 v1(159.87,71.13) 160.11,71.13 v5(160.31,71.33) ; v2(265.36,62.58) 265.75,62.97 265.75,64.45 263.42,66.78 261.7,66.78 261.18,67.29 v5(260.85,67.29)
SML1_SMBDATA: length 163
  TOP w0.086: v2(266.99,61.8) UE1.E11
  GND1 w0.086: v4(159.73,71.21) 160.01,71.21 v3(160.22,70.99)
  IN2 w0.061: v4(257.19,60.46) 256.07,59.34 256.07,57.62 255.1,56.64 255.1,54.35 255.63,53.82 255.63,50.61 253.93,48.9 253.93,43.46 253.13,42.67 253.13,37.73 250.69,35.29 249.5,35.29 249,34.8 241.96,34.8 240.62,36.14 236.86,36.14 233.35,39.65 222.83,39.65 221.8,40.68 220.41,40.68 220.33,40.77 217.3,40.77 216.56,40.02 212.1,40.02 210.33,41.79 191.58,41.79 190.85,41.07 189.6,41.07 188.66,42 187.02,42 185.18,43.84 180.25,43.84 177.95,46.14 177.95,48.34 170.96,55.33 170.96,59.44 169.02,61.38 166.71,61.38 164.3,63.79 164.3,67.18 162.38,69.1 161.35,69.1 159.73,70.72 v4(159.73,71.21)
  IN4 w0.051: v4(257.19,60.46) 257.19,60.61 258.91,62.33 258.91,63.24 260.3,64.64 265.88,64.64 266.57,63.95 266.57,62.23 v2(266.99,61.8)
  GND5 w0.086: v5(159.27,71.76) 159.35,71.69 159.35,71.64 159.63,71.36 159.63,71.33 159.73,71.23 v4(159.73,71.21)
  BOTTOM w0.076: v5(159.27,71.76) 159.25,71.76 159.14,71.87 157.75,71.87 157.52,71.64 156.05,71.64 155.87,71.56 155.79,71.56 155.59,71.62 155.56,71.62 155.38,71.62 155.24,71.58 154.78,71.58 UC1.V3
SNK0_CONFIG1: length 11.2
  TOP w0.086: v3(36.11,68.54) 36.16,68.54 36.29,68.67 36.41,68.67 36.42,68.67 RT337.1 RT129.1
  GND1 w0.086: v4(36.61,69.06) 36.16,68.61 36.16,68.59 v3(36.11,68.54)
  IN1 w0.051: v2(33.36,62.17) 33.7,62.5 33.7,63.05 36.57,65.92 36.57,67.81 36.24,68.14 36.24,68.69 v4(36.61,69.06)
  BOTTOM w0.117: UT1.N4 33.39,62.22 33.39,62.17 v2(33.36,62.17)
SNUB_1.8VALW: length 2.3
  TOP w0.117: v1(214.17,32.6) 214.23,32.53 PC506.1
  TOP w0.508: PR502.2 214.48,31.34 PC506.1
SNUB_1V_PRIM: length 1
  BOTTOM w0.086: PC419.1 v1(159.47,27.05)
SNUB_1VS_VCCIO: length 2.2
  TOP w0.086: v1(183.32,30.54) 183.29,30.51 183.29,29.99 PC401.1
  TOP w0.117: PC401.1 182.03,29.52 PR405.2
SNUB_CHG1: length 1.9
  TOP w0.086: PR923.2 v6(52.29,49.77)
SNUB_CHG2: length 1.3
  TOP w0.086: PC941.1 v1(69.51,46.15)
SPK_DET#: length 210.9
  TOP w0.086: v2(247.01,33.61) 247.01,33.28 246.43,32.71 244.07,32.71 242.94,31.58 241.95,31.58 239.06,28.69 239.06,27.64 v6(239.74,26.96) 240.17,26.53 250.25,26.53 251.37,25.41 259.45,25.41 v2(259.73,25.69)
  TOP w0.117: v2(295.36,19.58) 295.11,19.82 RA58.2
  IN2 w0.061: v4(152.41,71.84) 153.13,71.13 153.13,70.28 153.19,70.21 154.13,70.21 155.58,68.76 155.58,68.43 155.11,67.95 155.11,66.86 155.21,66.76 155.21,66.28 154.98,66.05 154.39,66.05 153.81,65.46 153.81,64.2 155.58,62.42 155.58,59.86 160.46,54.97 160.46,53.96 162.01,52.41 163.02,52.41 166.4,49.04 166.4,48.51 169.39,45.51 169.85,45.51 174.62,40.75 175.25,40.75 177.32,38.68 178.46,38.68 179.04,38.1 186.94,38.1 187.04,37.99 190.3,37.99 190.56,38.25 191.88,38.25 193.31,39.68 193.82,39.68 194.07,39.43 194.07,39.05 194.3,38.82 194.73,38.82 195.82,39.91 208.25,39.91 209.69,38.46 217.75,38.46 218.46,37.75 221.92,37.75 222.23,38.07 230.66,38.07 231.15,37.58 233.51,37.58 235.79,35.3 239.29,35.3 240.54,34.05 246.57,34.05 v2(247.01,33.61)
  IN4 w0.051: v2(259.73,25.69) 260.11,26.07 283.22,26.07 284.85,24.44 286.96,24.44 291.83,19.58 v2(295.36,19.58)
  GND5 w0.086: v4(152.41,71.84) 152.75,71.51 v5(152.75,71.21)
  BOTTOM w0.076: UC1.W7 v5(152.75,71.21)
  BOTTOM w0.117: JSPK1.5 283.53,13.12 288.21,13.12 294.67,19.58 v2(295.36,19.58)
SPKR: length 216.3
  TOP w0.086: v2(154.04,61.27) 154.27,61.27 160.15,55.4 160.15,53.16 159.4,52.41 159.4,51.19 RC183.1
  TOP w0.117: v2(274.79,41) 274.95,40.85 v1(275.66,40.85) 275.83,40.85 277.04,39.64 277.04,37.19 276.51,36.66 RA12.2
  IN1 w0.051: v4(227.37,41.28) 226.71,41.28 224.65,39.22 223.21,39.22 220.85,36.86 218.86,36.86 218.55,37.18 206.78,37.18 206.22,36.62 204.56,36.62 203.87,35.93 200.85,35.93 200.41,36.37 195,36.37 194.39,36.98 187.39,36.98 186.42,37.96 184.36,37.96 183.69,38.63 179.86,38.63 178.68,39.81 177.93,39.81 176.53,41.22 173.68,41.22 172.34,42.56 167.02,42.56 166.03,43.54 165.98,43.54 163.14,46.38 163.14,48.58 157.14,54.58 157.14,55.14 157.14,55.77 154.01,58.91 154.01,61.24 v2(154.04,61.27)
  IN2 w0.061: v4(268.32,42.46) 271.62,42.46 273.08,41 v2(274.79,41) ; v4(247.36,65.72) 247.36,65.58 243.77,61.98 240.91,61.98 237.02,58.09 237.02,55.37 236.43,54.79 236.43,51.71 231.39,46.67 230.66,46.67 227.63,43.63 227.63,41.54 v4(227.37,41.28)
  IN4 w0.051: v4(268.32,42.46) 268.37,42.52 268.37,44.28 270.09,46 270.09,47.33 270.07,47.35 270.07,47.67 270.29,47.89 271.09,47.89 274.53,51.33 275.7,51.33 275.89,51.52 275.89,55.68 273.39,58.17 273.39,58.71 271.55,60.55 271.55,61.6 271.75,61.79 271.75,66.76 268.88,69.62 267.9,69.62 263.75,73.77 260.41,73.77 259.87,74.3 251.93,74.3 251.69,74.06 251.69,72.03 248.11,68.45 248.11,66.47 v4(247.36,65.72)
  BOTTOM w0.076: v2(154.04,61.27) 153.86,61.27 153.69,61.1 UC1.AW5
SPKR_R: length 4.2
  TOP w0.117: RA51.1 CA72.1 275.69,37.57 275.69,37.25 RA12.1 274.68,36.24 v1(274.22,36.24) 273.8,36.24 CA27.1
SRTCRST#: length 22.9
  TOP w0.086: v2(145.71,64.7) 145.2,64.19 145.2,62.52 144.52,61.84 144.52,61.19 144.24,60.91 144.24,57.39 145.25,56.37 CC24.1 144.75,53.94 144.75,53.12 146.93,50.94 148.35,50.94 148.71,51.29 v1(150.65,51.29) 151.01,50.94 152.26,50.94 152.62,51.29 RC56.1
  BOTTOM w0.086: v2(145.71,64.7) 146,64.41 UC1.AN18
SS_1V_PRIM: length 9.7
  TOP w0.254: PC420.1 156.57,31.02 PR428.1 157.08,30.13 159.74,32.78 v1(160.7,32.78) v2(161.82,33.89)
  BOTTOM w0.254: v2(161.82,33.89) 161.82,33.69 162.6,32.9 PU402.7
SS_1VS_VCCIO: length 2.4
  TOP w0.117: PU401.7 177.06,31.38 PR427.1 PC410.1
SUSACK#: length 138.3
  TOP w0.086: v3(162.6,44) v1(162.01,44) 161.75,44.26 RC443.1 ; UE1.K12 v2(268.56,57.04)
  GND1 w0.086: v3(162.6,44) 162.33,44.27 v4(162.33,44.52)
  IN1 w0.051: v4(162.33,44.52) 163.15,44.52 166.15,41.52 172.94,41.52 173.55,40.92 176.4,40.92 177.84,39.47 178.54,39.47 179.72,38.29 183.6,38.29 184.08,37.81 186.36,37.81 188.05,36.11 200.21,36.11 200.71,35.61 205.63,35.61 205.8,35.77 217.71,35.77 218.48,36.54 221.01,36.54 223.35,38.88 225.09,38.88 226.81,40.6 227.86,40.6 228.6,41.34 228.6,42.08 v4(228.72,42.2)
  IN2 w0.061: v4(248.76,64.78) 248.76,64.19 247.49,62.92 245.34,62.92 243.73,61.31 240.87,61.31 237.47,57.91 237.47,55.19 236.86,54.57 236.86,51.87 232.08,47.09 232.08,45.46 228.82,42.2 v4(228.72,42.2) ; v4(258.87,66.35) 259.08,66.35 259.63,66.89 260.74,66.89 261.15,66.48 261.15,66.21 261.99,65.38 261.99,64.55 262.8,63.75 263.86,63.75 264.2,63.41 264.2,62.3 264.42,62.09 264.42,61.06 265.03,60.44 267.07,60.44 268.45,59.06 268.45,57.15 v2(268.56,57.04)
  IN3 w0.061: v4(258.87,66.35) 258.87,66.26 258.67,66.06 256.84,66.06 256.4,66.51 252.5,66.51 251.51,65.52 249.55,65.52 248.81,64.78 v4(248.76,64.78)
SUSACK#_R: length 49
  TOP w0.086: v3(162.27,45.47) 161.75,45.99 RC443.2 161.75,46.61 164.28,49.14 v1(164.28,50.96) 164.28,51.35 165.37,52.43 166.04,52.43 167.46,53.85 169.3,53.85 172.19,56.75 172.19,58.19 173.78,59.77 175.83,59.77 RC550.2
  GND1 w0.086: v3(162.27,45.47) 161.99,45.19 161.99,45 v4(161.99,44.99)
  IN1 w0.051: v2(149.36,64.07) 149.76,63.67 149.76,63.3 150.31,62.75 150.31,61.74 156.53,55.52 156.53,55.39 156.53,53.24 159.02,50.75 159.02,49.01 161.99,46.04 v4(161.99,44.99)
  BOTTOM w0.086: v2(149.36,64.07) 149.67,63.76 UC1.AP11
SUSCLK: length 296.9
  TOP w0.086: RZ56.1 238.24,45.09 v1(229.2,45.09) 228.59,45.09 226.53,43.04 226.53,41.75 225.73,40.94 217.13,40.94 211.55,35.37 207.42,35.37 204.87,32.81 204.87,30.26 204.13,29.52 204.13,27.82 v2(203.83,27.52) ; RN99.2 19.56,15.82 19.88,15.82 20.39,16.33 v2(20.39,18.4)
  IN3 w0.061: v4(178.29,27.57) 176.45,27.57 176.22,27.34 174.07,27.34 173.65,26.92 170.71,26.92 170.44,26.65 163.46,26.65 162.64,27.47 159.25,27.47 157.17,29.55 144.63,29.55 141.97,26.88 108.83,26.88 105.54,30.17 92.29,30.17 91.91,30.56 71.4,30.56 70.74,31.22 59.15,31.22 58.64,30.7 51.51,30.7 50.59,31.62 37.87,31.62 35.06,28.82 33.81,28.82 31.85,26.86 31.85,26.29 29.52,23.96 27.07,23.96 26.29,23.19 25.81,23.19 24.81,22.18 24.17,22.18 v2(20.39,18.4)
  IN4 w0.051: v2(203.83,27.52) 203.62,27.52 203.08,26.97 194.35,26.97 193.65,27.67 188.12,27.67 187.52,27.07 180.08,27.07 179.67,27.48 178.38,27.48 v4(178.29,27.57) 178.29,28.07 177.96,28.39 176.54,28.39 175.18,29.76 170.85,29.76 169.96,30.66 169.96,31.64 169.22,32.38 168.68,32.38 165.84,35.22 164.45,35.22 162.86,36.81 162.86,42.64 161.29,44.2 159.78,44.2 158.34,45.64 158.24,45.64 155.74,48.14 155.26,48.14 153.95,49.45 153.95,50.26 v2(153.32,50.89)
  BOTTOM w0.076: UC1.BA17 146.39,59.14 146.66,58.88 146.66,56.95 147.48,56.14 147.48,55.62 147.79,55.3
  BOTTOM w0.086: 147.79,55.3 148.02,55.08 148.02,53.71 148.18,53.55 148.58,53.55 150.11,52.03 151.55,52.03 RC48.1 152.99,51.22 153.3,50.91 153.33,50.91 153.33,50.89 v2(153.32,50.89)
SUSCLK_R: length 2.7
  TOP w0.086: JNGFF3.68 v1(18.67,13.27) 18.97,13.57 RN99.1
SW_+1VALWP: length 0.6
  TOP w0.086: v2(60.49,70.71) v6(59.94,70.71)
  vias: v2(60.62,74.46) v2(61.13,74.14) v2(61.13,70.78)
SW_USB20_N9: length 2.2
  TOP w0.088: LI7.1 273.47,73.74 273.32,73.59 272.98,73.59 272.65,73.92 272.29,73.92 272.11,74.09 UI3.11
SW_USB20_P9: length 2.2
  TOP w0.088: LI7.4 273.47,73.24 273.3,73.42 272.91,73.42 272.58,73.74 272.3,73.74 272.15,73.59 UI3.10
SYS_PWROK: length 290
  TOP w0.086: v2(161.49,90.23) 161.21,89.95 v6(161.21,89.66) 161.21,88.55 158.35,85.69 152.68,85.69 150.56,83.57 150.56,82.33 152.06,80.83 152.98,80.83 v3(153.04,80.9) ; v3(256.13,62.57) 255.69,62.57 255.57,62.44 253.12,62.44 RE56.1
  GND1 w0.086: v4(255.92,63.48) 256.13,63.28 v3(256.13,62.57) ; v3(153.04,80.9) v4(153.38,81.24)
  IN3 w0.061: v4(61.18,90.64) 61.61,91.07 65.27,91.07 66.21,92.01 72.76,92.01 73.23,91.55 76.28,91.55 77.21,90.63 81.36,90.63 82.5,91.76 85.31,91.76 87.95,89.13 102.57,89.13 104.32,90.88 105.49,90.88 106.68,92.07 108.31,92.07 108.92,91.47 115.3,91.47 115.6,91.77 122.34,91.77 124.7,94.13 128.89,94.13 129.57,94.13 130.49,93.21 130.49,92.51 133.29,89.71 136.24,89.71 137.34,90.81 137.34,93.43 138.37,94.46 143.9,94.46 148.42,89.93 154.61,89.93 155.47,90.79 160.92,90.79 v2(161.49,90.23) 162.05,90.79 164.3,90.79 165.21,89.88 171.78,89.88 175.49,86.18 175.49,86.17 176.67,84.99 176.68,84.99 177.42,84.24 177.42,82.15 177.12,81.85 177.12,80.54 177.7,79.96 177.7,76.79 177.49,76.58 177.49,67.46 177.49,65.33 178.41,64.42 178.41,60.66 180.74,58.32 180.74,56.22 185.82,51.14 188.99,51.14 190.29,49.84 190.52,49.84 192.81,47.55 200.96,47.55 201.84,46.67 202.01,46.67 202.02,46.67 202.09,46.67 208.71,46.67 210.56,48.52 212.34,48.52 214.8,50.99 217.8,50.99 218.19,50.6 221.59,50.6 224.92,53.93 224.92,60.29 224.56,60.65 224.56,64.13 226.53,66.09 227.1,66.09 232.55,66.09 232.97,65.67 236.98,65.67 237.31,65.34 239.51,65.34 240.72,66.56 240.72,66.86 242.89,69.03 242.89,69.89 244.09,71.09 245.07,71.09 v2(245.41,71.43)
  GND5 w0.086: v4(153.38,81.24) 153.29,81.14 v5(153.29,80.35) ; v5(61.26,91.14) 61.26,91.12 61.18,91.04 v4(61.18,90.64) ; v4(255.92,63.48) 255.95,63.51 v5(255.95,64.02)
  BOTTOM w0.086: v2(245.41,71.43) 246.97,71.43 249.73,68.67 249.73,68.33 251.91,66.15 254.45,66.15 255.95,64.65 v5(255.95,64.02)
SYS_RESET#: length 73.4
  TOP w0.086: v2(153.61,82.03) v6(159.81,82.03) 161.66,83.88 169.71,83.88 170.96,82.63 170.96,78.75 v3(171.57,78.14) ; v3(189.4,45.14) 189.4,44.71 188.84,44.16 JAPS1.13
  GND1 w0.086: v3(171.57,78.14) 171.49,78.07 v4(171.49,77.61) ; v4(189.43,45.75) 189.43,45.17 v3(189.4,45.14)
  IN2 w0.061: v4(171.49,77.61) 171.49,71.18 175.36,67.31 175.36,66.02 175.47,65.91 175.47,60.57 177.79,58.24 177.79,55.1 182.21,50.69 182.21,50.2 182.21,49.94 184.04,48.11 185.61,48.11 188.29,45.42 189.1,45.42 v4(189.43,45.75)
  GND5 w0.086: v5(171,78.17) 171,78.04 171.44,77.61 v4(171.49,77.61)
  BOTTOM w0.086: v2(153.61,82.03) 153.56,81.97 153.56,81.19 153.87,80.88 UC1.B5 ; CC302.1 170.46,76.67 RC224.2 171,77.21 v5(171,78.17)
SYS_RESET#_R: length 9.7
  BOTTOM w0.086: RC290.2 177.44,79.63 177.32,79.75 176.61,79.75 176.09,79.23 176.09,78.9 175.81,78.62 174.28,78.62 174.16,78.5 174.16,77.81 173.93,77.58 172.29,77.58 RC224.1 172.18,76.95 UC12.4
SYSTEM_ID: length 10.2
  TOP w0.086: CE47.1 RE300.2 v2(268.51,53.49) ; UE1.J10 v2(266.96,57.84)
  IN3 w0.061: v2(266.96,57.84) 267.39,57.41 267.91,57.41 268.14,57.18 268.14,56.02 267.94,55.81 266.77,55.81 266.57,55.61 266.57,54.24 266.77,54.03 268.14,54.03 268.51,53.67 v2(268.51,53.49)
TACH_FAN1: length 147.1
  TOP w0.086: v2(168.24,69.33) v1(167.27,68.36) 166.64,67.73 RE51.2 ; UE1.E3 v2(260.62,61.78)
  IN2 w0.061: v2(168.24,69.33) 169.07,69.33 173.76,64.63 173.76,56.31 179.97,50.11 179.97,46.78 180.34,46.41 185.44,46.41 187.75,44.1 190.48,44.1 190.93,44.56 200.51,44.56 201.18,43.89 211.18,43.89 212.23,42.83 216.81,42.83 217.44,43.47 v4(217.44,44.03)
  IN4 w0.051: v4(246.85,75.14) 246.22,74.51 246.22,70.58 246.08,70.44 246.08,67.72 244.75,66.38 244.75,65.46 243.33,64.04 237.66,64.04 236.52,62.9 236.52,61.73 234.72,59.93 234.72,57.65 234.92,57.45 234.92,56.35 233.19,54.62 233.19,51.16 230.63,48.6 229.45,48.6 225.18,44.33 218.76,44.33 218.46,44.03 v4(217.44,44.03)
  GND5 w0.086: v5(246.58,74.71) 246.58,74.74 246.85,75.02 v4(246.85,75.14)
  BOTTOM w0.086: v2(168.24,69.33) 168.19,69.38 JFAN1.3 ; v5(246.58,74.71) 246.58,72.62 250.24,68.95 250.24,68.12 251.88,66.48 254.7,66.48 257.22,63.97 258.43,63.97 v2(260.62,61.78)
TBT_CIO_PLUG_EVENT#: length 157.3
  TOP w0.086: v3(39.9,72.2) 40,72.09 40.38,72.09 40.53,71.94 40.53,71.16 40.06,70.7 RT391.1 v1(40.05,69.31) 40.05,68.79 39.15,67.89 39.15,67.18 RT371.1 39.29,66.96 39.29,65.24 37.53,63.48 37.21,63.48 v3(37.19,63.47)
  GND1 w0.086: v3(37.19,63.47) 36.59,62.87 v4(36.59,62.82) ; v3(39.9,72.2) 39.51,72.2 39.36,72.04 v4(39.36,71.94)
  IN3 w0.061: v4(39.36,71.94) 39.81,72.39 39.81,73.38 39.52,73.67 39.52,76.27 39.73,76.47 39.73,77.26 41.77,79.31 42.07,79.31 44.9,82.14 59.48,82.14 59.48,82.14 59.61,82.14 61.78,84.32 65.81,84.32 66.03,84.54 67.17,85.68 76.91,85.68 78.63,83.97 103.98,83.97 104.2,84.19 105.71,85.7 124.49,85.7 124.67,85.53 128.53,85.53 130.11,83.95 130.42,83.95 139.24,83.95 139.52,83.67 142.06,83.67 142.58,84.18 145.88,84.18 146.56,83.5 149.52,83.5 150.36,82.66 153.92,82.66 154.55,82.03 154.55,79.03 155.08,78.49 155.08,77.36 154.75,77.03 154.39,77.03 153.92,76.55 153.92,74.85 153.41,74.34 150.65,74.34 150.41,74.1 150.41,73.35 150.49,73.27 150.49,71.5 149.9,70.91 149.9,70.63 v2(149.92,70.61)
  GND5 w0.086: v4(36.59,62.82) 36.52,62.9 v5(35.96,62.9)
  BOTTOM w0.086: UT1.W2 36.25,63.19 v5(35.96,62.9) ; v2(149.92,70.61) 149.9,70.59 149.9,70.54 UC1.AB12
TBT_DP_RBIAS: length 1.2
  TOP w0.086: v2(34,60.88) 33.83,61.06 RT35.1
  BOTTOM w0.102: UT1.N6 v2(34,60.88)
TBT_FORCE_PWR: length 148.9
  GND1 w0.086: v4(30.75,63.69) 30.98,63.92 v3(31.28,63.92)
  IN3 w0.061: v4(152.65,81.24) 150.51,81.24 148.67,83.08 143.36,83.08 143.15,83.29 139.37,83.29 139.09,83.57 132.62,83.57 131.99,82.94 131.97,82.94 131.97,82.94 130.49,82.94 129.14,81.59 127.87,81.59 124.14,85.32 115.11,85.32 112.82,83.03 112.37,83.03 110.76,84.64 105.37,84.64 104.25,83.52 78.54,83.52 76.8,85.27 68.89,85.27 66.97,83.34 65.02,83.34 64.73,83.63 61.81,83.63 59.74,81.57 44.86,81.57 42.23,78.93 41.93,78.93 40.1,77.11 40.1,76.31 39.9,76.11 39.9,73.82 40.19,73.54 40.19,68.51 39.42,67.75 39.27,67.75 39.27,67.75 36.24,67.75 35.55,68.43 35.55,68.85 35.16,69.24 32.3,69.24 31.26,68.2 31.26,64.17 30.78,63.69 v4(30.75,63.69)
  GND5 w0.086: v5(31.08,62.5) 31.06,62.53 31.06,63.38 v4(30.75,63.69) ; v5(152.61,80.7) 152.61,81.2 v4(152.65,81.24)
TBT_I2C_SCL: length 59.4
  IN1 w0.051: v4(33.1,71.86) 33.1,71.86 33.1,71.8 33.62,71.28 33.62,70.36 32.51,69.25 32.51,68.54 32.78,68.26 35.48,68.26 36.11,67.62 36.11,66.24 35.74,65.87 v4(35.53,65.87)
  IN3 w0.061: v4(35.53,65.87) 35.53,65.31 37.03,63.81 37.03,60.08 37.69,59.42 37.69,55.09 37.54,54.94 37.54,51.34 37.69,51.19 37.69,49.49 36.74,48.54 36.39,48.54 35.64,47.78 35.64,46.12 35.96,45.79 35.96,42.64 36.42,42.18 36.42,40.9 34.8,39.28 26.8,39.28 26.13,39.95 v4(26.13,42.73)
  GND5 w0.086: v4(33.1,71.86) 33.06,71.86 v5(32.72,71.53) ; v5(35.87,65.53) 35.81,65.59 v4(35.53,65.87) ; v5(26.73,43.12) 26.52,43.12 v4(26.13,42.73)
  BOTTOM w0.076: UT1.U2 35.33,63.2 35.56,63.44 35.56,64.33 35.73,64.5 35.73,65.39 v5(35.87,65.53) 36.1,65.75
  BOTTOM w0.086: 36.1,65.75 36.1,66.17 37.03,67.1 37.97,67.1 RT19.1
TBT_I2C_SDA: length 58.8
  IN1 w0.051: v4(32.55,70.52) 32.2,70.16 32.2,68.41 32.66,67.95 35.32,67.95 35.73,67.55 v2(35.73,66.43)
  IN3 w0.061: v2(35.73,66.43) 35.91,66.25 35.91,65.37 37.34,63.94 37.34,60.21 38,59.55 38,54.96 37.85,54.81 37.85,51.8 39.27,50.38 39.27,48.54 38.94,48.22 38.94,48.22 37.82,47.09 37.27,47.09 36.48,46.3 36.48,43.29 36.74,43.04 36.74,40.77 34.93,38.97 26.67,38.97 24.97,40.66 24.97,41.55 25.6,42.17 25.6,43.02 v2(25.4,43.22)
  GND5 w0.086: v5(32.72,71.03) 32.55,70.86 v4(32.55,70.52)
  BOTTOM w0.076: UT1.U1 35.33,65.41
  BOTTOM w0.086: 35.33,65.41 35.32,65.41 35.32,66.02 v2(35.73,66.43) 35.83,66.43 v6(36.39,66.99) 36.92,67.52 RT18.1 ; v2(25.4,43.22) 25.49,43.12 UT11.D1
TBT_JTAG_TCK: length 2.4
  TOP w0.086: v3(34.71,63.56) 34.71,63.79 34.84,63.92 RT6.1
  GND1 w0.086: v4(34.97,63.03) 34.98,63.04 34.98,63.3 v3(34.71,63.56)
  GND5 w0.086: v4(34.97,63.03) 34.98,63.02 v5(34.98,62.5)
TBT_JTAG_TDI: length 3.7
  TOP w0.086: RT8.1 37.51,64.21 v1(37.28,63.98) 36.9,63.6 36.9,63.24 36.6,62.94 v2(36.6,62.18)
  BOTTOM w0.086: UT1.Y4 v2(36.6,62.18)
TBT_JTAG_TDO: length 3.6
  TOP w0.086: RT5.1 36.62,63.27 35.95,62.61 v2(35.95,62.18)
  BOTTOM w0.086: UT1.W4 v2(35.95,62.18)
TBT_JTAG_TMS: length 2.3
  TOP w0.086: RT7.1 36.19,63.54 v1(35.3,62.65) 35.27,62.62 35.27,62.21 v2(35.3,62.18)
  BOTTOM w0.086: v2(35.3,62.18) UT1.V4
TBT_PCIE_RBIAS: length 1.1
  TOP w0.086: v2(33.36,56.34) 33.38,56.34 33.38,56.36 33.39,56.37 33.94,56.37 RT34.1
  BOTTOM w0.086: UT1.N16 33.68,56.65 33.38,56.36 33.38,56.34 v2(33.36,56.34)
TBT_PERST#: length 61.9
  TOP w0.086: v6(22.62,20.09) 22.62,21.62 RT419.1 21.96,22.63 21.52,23.07 RT420.1 20.67,23.07 20.38,22.78 v2(20.38,22.37)
  IN1 w0.051: v4(34.29,44.51) 33.42,44.51 27.94,39.03 27.94,36.95 27.13,36.13 27.13,33.42 23.2,29.49 22.01,29.49 20.46,27.94 20.46,23.2 20.38,23.11 v2(20.38,22.37)
  IN3 w0.061: v4(34.29,44.51) 34.29,47.41 36.25,49.37 36.59,49.37 36.98,49.76 36.98,50.92 36.85,51.05 36.85,55.23 37,55.38 37,59.13 36.69,59.44 36.09,59.44 35.11,60.42 35.11,61.16 34.49,61.78 34.49,62.39 34.08,62.8 v4(33.29,62.8)
  GND5 w0.086: v4(33.29,62.8) 33.25,62.75 32.13,62.75 v5(32.12,62.76)
  BOTTOM w0.086: v2(20.38,22.37) 21.47,22.37 RT443.2 ; UT1.L4 v5(32.12,62.76)
TBT_PERST#_R: length 3.8
  BOTTOM w0.086: RT443.1 RT442.2 24.48,26.11 24.63,26.26 v1(24.83,26.26) 25.09,26.26 25.61,25.74 UT33.4
TBT_RBIAS: length 1.3
  TOP w0.086: RT39.2 30.9,62.03 v2(31.4,61.53)
  BOTTOM w0.127: UT1.H6 31.4,61.53 v2(31.4,61.53)
TBT_RESET_N_EC: length 346.4
  TOP w0.086: v2(30.11,62.19) 30.4,62.47 30.4,65.49 RT11.1
  IN1 w0.051: v4(27.42,78.22) 27.63,78.01 27.63,75.83 27.98,75.47 27.98,73.89 29.63,72.24 29.63,70.38 29.18,69.92 29.18,66.42 29.68,65.91 29.68,65.24 29.53,65.08 29.53,62.83 30.11,62.24 v2(30.11,62.19) 30.11,61.81 29.63,61.33 29.63,60.39 30.69,59.33 31.05,59.33 32.1,58.29 32.61,58.29 33.17,57.73 33.17,57.34 34.6,55.9 34.6,54.07 34.98,53.69 36.82,53.69 37.02,53.49 37.02,51.76 36.59,51.33 36.59,49.99 34.88,48.28 v4(34.88,45.13)
  IN2 w0.061: v4(252.35,39.14) 252.95,39.73 252.95,42.87 253.74,43.66 253.74,48.98 255.44,50.68 255.44,53.63 254.45,54.62 254.45,58.33 253.47,59.31 253.47,61.5 253.7,61.73 253.7,63.34 v4(253.65,63.39)
  IN4 w0.051: v4(27.42,78.22) 27.88,78.67 31.34,78.67 v4(31.56,78.44) ; v4(34.88,45.13) 34.94,45.07 36.43,45.07 40.37,41.13 42.95,41.13 44.85,43.04 50.86,43.04 51.32,43.49 53.75,43.49 54.44,42.8 59.52,42.8 59.77,42.54 62.25,42.54 63.74,44.03 67.25,44.03 68.57,45.34 73.19,45.34 73.93,46.08 76,46.08 76.45,45.64 78.24,45.64 78.55,45.94 80.17,45.94 81.21,44.9 87.87,44.9 90.31,42.47 90.31,41 90.84,40.47 90.84,35.26 92.67,33.43 95.42,33.43 95.74,33.12 125.18,33.12 125.51,32.79 158,32.79 160.16,30.63 164.04,30.63 165.68,28.98 168.9,28.98 169.54,28.34 173.73,28.34 176.71,25.36 179.17,25.36 179.32,25.52 242.38,25.52 243.12,26.26 254.24,26.26 255.01,25.5 257.24,25.5 258.96,27.21 258.96,27.9 257.94,28.91 257.94,31.28 v2(258.07,31.4)
  GND5 w0.086: v4(253.65,63.39) 253.92,63.13 v5(253.92,62.95) ; v4(34.88,45.13) 34.97,45.04 v5(35.51,45.04) ; v5(253.01,38.86) 252.71,39.16 252.38,39.16 v4(252.35,39.14) ; v4(31.56,78.44) 31.84,78.44 v5(32.05,78.65)
  BOTTOM w0.086: v5(35.51,45.04) 35.76,45.04 36.96,43.84 36.96,42.68 36.78,42.5 RT203.2 ; CT205.1 v5(32.05,78.65) ; v2(258.07,31.4) 260,31.4 v1(260.32,31.73) 260.53,31.94 260.53,35.83 260.45,35.91 253.91,35.91 252.88,36.94 252.88,38.73 v5(253.01,38.86)
  BOTTOM w0.127: v2(30.11,62.19) 30.1,62.2 30.41,62.5 30.43,62.5 UT1.F4
TBT_RESET_N_EC_R: length 20.3
  TOP w0.086: UE1.L8 v2(265.36,56.24) ; v2(255.06,61.98) 254.39,61.98 RE95.1 253.78,61.38 252.8,61.38 v1(252.25,60.83)
  IN2 w0.061: v2(255.06,61.98) 255.06,61.93 256.04,60.95 258.51,60.95 260.42,59.04 261.61,59.04 261.84,59.27 261.84,59.75 262.16,60.06 264.15,60.06 264.25,59.96 264.25,59.62 264.27,59.62 264.84,59.05 264.84,56.76 v2(265.36,56.24)
  BOTTOM w0.086: RE506.2 254.83,62.21 v2(255.06,61.98)
TBT_ROM_CLK: length 21.2
  IN4 w0.051: v4(39.36,62.75) 39.58,62.75 41,64.17 41,70.02 41.79,70.81 42.05,70.81 42.28,71.04 42.28,72.97 v4(40.95,74.3)
  GND5 w0.086: v4(40.95,74.3) 40.91,74.3 v5(40.58,74.63) ; v5(38.88,62.72) 39.34,62.72 v4(39.36,62.75)
  BOTTOM w0.076: UT1.AB4 37.63,62.29 37.75,62.41
  BOTTOM w0.086: 37.75,62.41 37.77,62.41 37.88,62.52 38.56,62.52 38.77,62.72 v5(38.88,62.72) ; UT2.6 40.05,75.17 v5(40.58,74.63)
TBT_ROM_CS#: length 13.2
  IN4 w0.051: v4(39.36,63.33) 39.73,63.33 40.7,64.29 40.7,70.21 41.83,71.34 v4(41.89,71.34)
  GND5 w0.086: v5(38.85,63.15) 38.96,63.15 39.13,63.33 v4(39.36,63.33) ; v5(41.78,70.87) 41.78,71.23 v4(41.89,71.34)
  BOTTOM w0.076: UT1.AC3 38.4,62.74 38.4,62.77 38.78,63.15 v5(38.85,63.15)
  BOTTOM w0.086: UT2.1 42.59,71.69 v5(41.78,70.87)
TBT_ROM_DI: length 19.6
  IN4 w0.051: v4(40.45,73.85) 40.54,73.76 40.54,64.42 40.04,63.92 v4(39.36,63.92)
  GND5 w0.086: v5(38.83,63.69) 39.06,63.92 v4(39.36,63.92) ; v5(40.12,74.2) 40.45,73.86 v4(40.45,73.85)
  BOTTOM w0.076: UT1.AB3 37.86,62.97 38.32,62.97 38.52,63.18 38.52,63.38 v5(38.83,63.69)
  BOTTOM w0.086: UT2.5 38.78,77.96 39.17,77.57 39.17,75.14 v5(40.12,74.2)
TBT_ROM_DO: length 13.5
  IN4 w0.051: v4(39.36,62.16) 39.43,62.16 41.31,64.04 41.31,69.77 v4(41.89,70.35)
  GND5 w0.086: v5(40.89,70.87) 41.41,70.35 v4(41.89,70.35) ; v4(39.36,62.16) 38.93,62.16 v5(38.88,62.21)
  BOTTOM w0.086: v5(38.88,62.21) 38.57,62.21 38.5,62.28 UT1.AC4 ; v5(40.89,70.87) 41.32,71.31 UT2.2
TBT_ROM_HOLD#: length 3.3
  BOTTOM w0.086: v1(39.25,81.47) RT1.1 41.32,80.3 UT2.7
