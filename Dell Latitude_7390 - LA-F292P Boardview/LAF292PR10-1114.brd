# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 95.6
  TOP w0.102: v6(279.23,29.31) 279.6,29.68 v2(281.09,29.68) ; v6(278.19,32.03) 278.65,32.49 v2(278.7,32.49) ; RA36.1 277.2,28.36 v6(277.41,28.57)
  TOP w0.203: UA1.18 266.97,31.39 v2(267.38,30.99) ; UA1.37 v2(270.07,37.97)
  TOP w0.356: v2(266.18,30.64) 266.45,30.38 CA57.2 ; CA8.2 269.8,39.9 269.84,39.86 v2(269.84,39.81)
  TOP w0.381: v2(274.36,28.36) RA36.1
  TOP w0.508: v2(277.44,40.43) 276.67,41.19 RA37.1 ; CA35.2 v2(273.33,42.31) ; CA25.2 v2(273.26,34.75) ; CA1.1 280.54,36.08 v2(279.75,36.08) 279.44,35.77 CA3.2 ; v2(281.09,29.68) 281.12,29.7 DA2.2 ; CA74.2 v2(275.72,40.23) ; CA2.2 279.14,32.93 v2(278.7,32.49) ; CA52.2 CA58.2 v2(268.7,29.18) ; v2(272.19,28.43) 272.12,28.5 CA49.2 ; RA35.1 v2(273.73,29.17) ; CA4.2 v2(277.97,40.85) ; CA51.2 v2(272.66,42.12)
  GND1 w0.203: 286.82,27.6 JHP1.5 ; JHP1.5 286.82,26.93 ; JHP1.5 288.98,26.93 ; JHP1.5 287.9,26.93 ; JHP1.5 288.98,27.6 ; 289.47,37.77 JHP1.7 ; JHP1.7 291.63,37.1 ; JHP1.7 289.47,37.1 ; JHP1.7 291.63,37.77 ; JHP1.7 290.55,37.77
  GND1 w0.508: v3(260.96,40.06) 260.96,39.91 261.49,39.39 v4(261.49,39.37) ; v3(271.24,40.47) v4(271.24,41.08) ; v3(270.03,42.66) v4(270.03,42.05)
  GND2 w0.203: 289.47,37.1 JHP1.7 ; JHP1.7 290.55,37.77 ; JHP1.7 291.63,37.77 ; JHP1.7 291.63,37.1 ; JHP1.7 289.47,37.77 ; JHP1.5 288.98,27.6 ; JHP1.5 286.82,27.6 ; JHP1.5 288.98,26.93 ; JHP1.5 287.9,26.93 ; JHP1.5 286.82,26.93
  GND3 w0.203: JHP1.5 288.98,27.6 ; JHP1.5 286.82,27.6 ; JHP1.5 286.82,26.93 ; JHP1.5 287.9,26.93 ; JHP1.5 288.98,26.93 ; 289.47,37.1 JHP1.7 ; JHP1.7 289.47,37.77 ; JHP1.7 291.63,37.1 ; JHP1.7 290.55,37.77 ; JHP1.7 291.63,37.77
  VCC w0.203: 287.9,26.93 JHP1.5 ; JHP1.5 286.82,26.93 ; JHP1.5 288.98,26.93 ; 289.47,37.77 JHP1.7 ; JHP1.7 291.63,37.77 ; JHP1.7 290.55,37.77
  IN3 w0.508: v2(266.18,30.64) 265.14,30.64 263.77,32.02 263.77,35.36 261.49,37.64 v4(261.49,39.37)
  GND4 w0.203: JHP1.7 291.63,37.1 ; JHP1.7 289.47,37.1 ; JHP1.7 290.55,37.77 ; JHP1.7 291.63,37.77 ; JHP1.7 289.47,37.77 ; 286.82,27.6 JHP1.5 ; JHP1.5 286.82,26.93 ; JHP1.5 288.98,26.93 ; JHP1.5 287.9,26.93 ; JHP1.5 288.98,27.6
  GND5 w0.203: 286.82,26.93 JHP1.5 ; JHP1.5 288.98,26.93 ; JHP1.5 286.82,27.6 ; JHP1.5 288.98,27.6 ; JHP1.5 287.9,26.93 ; 289.47,37.1 JHP1.7 ; JHP1.7 289.47,37.77 ; JHP1.7 291.63,37.1 ; JHP1.7 291.63,37.77 ; JHP1.7 290.55,37.77
  vias: v2(281.55,41.56) v2(282.14,41.56) v3(274.82,38.43)
VBAT1_ISL9538: length 6.9
  TOP w0.117: PR940.2 59.59,41.66 60.11,42.19 v1(60.6,42.19)
  TOP w0.203: 58.36,39.23 58.36,37.88 58.02,37.54 PU901.31
  TOP w0.254: PR940.2 PC950.2 58.84,40.34 58.36,39.86 58.36,39.23
VBUS1_ECOK: length 27.9
  TOP w0.086: v2(244.06,67.47) 243.82,67.71 v1(242.69,67.71) 241.56,67.71 RE603.2 ; UE1.M6 v2(263.02,55.44)
  BOTTOM w0.086: v2(263.02,55.44) 262.53,54.95 259.69,54.95 257.42,57.23 257.42,57.81 253.29,61.94 251.67,61.94 248.51,65.1 247.3,65.1 244.92,67.47 v2(244.06,67.47)
VBUS1_ECOK_R: length 11.1
  TOP w0.086: v2(60.76,87.29) 60.43,87.63 58.42,87.63 57.54,86.76 PR1221.2
  BOTTOM w0.086: v2(60.76,87.29) 61.03,87.03 61.03,84.53 v1(61.71,83.85) 63.21,82.35 RE602.1 63.54,82.43 PR1276.1
VBUS2_ECOK: length 288.8
  TOP w0.086: UE1.N3 260.99,54.63 260.01,53.65 v2(260.01,53.55)
  IN2 w0.061: v2(260.01,53.55) 260.01,52.85 259.53,52.37 258.54,52.37 257.56,51.39 257.56,48.51 255.7,46.65 255.7,43.71 253.51,41.51 253.51,37.32 250.32,34.13 249.1,34.13 249,34.23 240.62,34.23 239.36,35.49 235.86,35.49 233.59,37.77 231.23,37.77 230.74,38.26 222.15,38.26 221.87,37.97 220.79,37.97 219.87,38.89 211.63,38.89 209.86,40.66 192.05,40.66 191.32,39.94 189.13,39.94 188.74,40.33 182.25,40.33 181.41,39.49 180.06,39.49 178.56,40.98 177.24,40.98 176.67,41.55 176.67,42.36 174.52,44.5 174.52,48.52 172.08,50.96 v4(172.08,51.29)
  IN3 w0.061: v2(58.87,87.23) 58.95,87.23 60.04,88.32 65.28,88.32 66.35,89.4 79.42,89.4 80.79,88.02 86.34,88.02 87.07,87.3 102.96,87.3 104.32,88.66 105.4,88.66 106.04,89.3 125.08,89.3 125.89,88.49 129.72,88.49 131.32,86.89 136.13,86.89 138.14,88.9 144.09,88.9 144.39,89.2 146.62,89.2 147.46,88.36 156.86,88.36 156.94,88.44 162.56,88.44 163.53,87.47 166.59,87.47 167.92,86.15 170.76,86.15 172.57,84.33 173.48,84.33 174.4,83.42 174.4,76.76 174.82,76.34 174.82,74.25 175.58,73.49 175.58,67.95 176.11,67.42 176.11,64.24 v4(176.79,63.56)
  GND5 w0.086: v4(172.08,51.29) 171.94,51.43 v5(171.94,51.75) ; v4(176.79,63.56) 176.79,64 v5(176.68,64.11)
  BOTTOM w0.086: v2(58.87,87.23) 58.87,86.08 59.54,85.42 59.54,85 61.62,82.93 62.03,82.93 62.7,82.26 62.7,81.55 62.32,81.17 62.32,80.43 v1(62.49,80.26) 62.87,80.26 63.45,80.84 RE602.2 ; v5(176.68,64.11) 175.16,62.59 175.16,60.78 175.73,60.2 175.73,58.94 175.39,58.59 175.39,56.84 175.71,56.52 175.71,51.98 174.85,51.11 172.58,51.11 v5(171.94,51.75)
VBUS2_ECOK_R: length 359
  TOP w0.086: v3(43.01,40.1) 42.25,39.33 PR1255.2 ; v2(241.79,65.25) 241.5,65.54 v1(241.5,65.77) RE603.1
  GND1 w0.086: v3(43.01,40.1) v4(42.64,39.73)
  IN2 w0.061: v4(36.7,87.16) 36.62,87.16 36.39,86.93 35.34,86.93 35.18,86.78 33.72,86.78 33.22,86.27 28.41,86.27 22.47,80.33 20.52,80.33 17.82,77.63 17.82,75.92 14.98,73.08 14.98,70.98 16.14,69.82 16.14,64.65 15.18,63.69 15.18,57.22 v4(15.65,56.75)
  IN3 w0.061: v2(241.79,65.25) 241.79,65.01 240.89,64.11 231.62,64.11 230.65,65.08 229.08,65.08 228.07,64.07 226.34,64.07 225.57,63.29 225.57,61.07 225.93,60.71 225.93,53.51 222.01,49.59 214.64,49.59 210.71,45.67 201.68,45.67 201.42,45.67 200.55,46.55 192.4,46.55 190.44,48.51 188.54,48.51 186.91,50.13 185.4,50.13 179.73,55.8 179.73,57.91 177.4,60.24 177.4,63.82 176.49,64.74 176.49,67.57 175.97,68.09 175.97,77.2 175.46,77.71 175.46,84.5 174.29,85.67 174.29,85.68 172.12,87.85 163.69,87.85 162.72,88.82 156.78,88.82 156.7,88.74 147.93,88.74 143.4,93.26 138.86,93.26 138.54,92.93 138.54,90.32 136.73,88.51 132.8,88.51 132.44,88.87 126.05,88.87 125.24,89.68 105.89,89.68 105.25,89.04 104.16,89.04 103.06,87.94 87.45,87.94 86.92,88.47 80.88,88.47 79.58,89.77 66.2,89.77 65.43,89 v4(65.05,89)
  IN4 w0.051: v4(15.65,56.75) 15.76,56.75 15.77,56.75 15.89,56.75 17.43,55.22 17.43,50.36 17.06,50 17.06,49.73 17.76,49.03 17.76,42.66 21.09,39.33 22.55,39.33 26.33,35.54 26.84,35.54 27.07,35.77 27.07,36.09 28.05,37.07 32.13,37.07 33.02,37.96 33.53,37.96 34.57,39 36.4,39 37.41,40.01 42.36,40.01 v4(42.64,39.73) ; v4(65.05,89) 65.03,89 65.06,89 65.06,88.9 64.57,88.41 58.99,88.41 58.83,88.57 48.79,88.57 48,89.36 45.02,89.36 44.19,90.19 42.88,90.19 41.14,88.45 37.99,88.45 v4(36.7,87.16)
  GND5 w0.086: v5(64.88,88.48) 65.05,88.65 65.05,88.96 65.06,88.97 65.06,89 65.03,89 v4(65.05,89)
  BOTTOM w0.086: PR1275.1 64.8,88.55 v5(64.88,88.48)
VCC_GT: length 11.4
  TOP w0.508: v2(93.32,56.23) 93.65,56.56 93.65,58.02 v1(93.47,58.2) 93.31,58.36 93.31,61.35 PR1300.2
  BOTTOM w0.254: PU612.3 91.31,57.17 PC669.1 92.9,55.81 v2(93.32,56.23)
VCC_GT_SENSE: length 52.6
  TOP w0.102: v3(78.54,77.37) v1(79.52,77.37)
  TOP w0.254: PC639.1 v3(78.54,77.37) ; RC161.1 114.54,76.31 114.54,75.55 v2(114.51,75.52)
  GND1 w0.254: v4(78,76.92) 78.09,76.92 v3(78.54,77.37)
  IN1 w0.203: v2(114.51,75.52) 114.54,75.55 114.54,75.66 114.34,75.87 114,75.87 113.36,75.23 107.05,75.23 104.46,77.83 103.87,79.26 103.87,81.42 103.36,81.92 96.13,81.92 94.63,80.43 78.85,80.43 77.55,79.13 77.55,77.12 77.75,76.92 v4(78,76.92)
  GND5 w0.254: v4(78,76.92) v5(78,76.41)
  BOTTOM w0.076: v2(114.51,75.52) 114.82,75.83 114.84,75.83 115.18,76.18 115.61,76.18 115.86,76.3 116.14,76.43 UC1.J70
  BOTTOM w0.254: PR648.1 77.89,76.21 77.89,75.47 PC653.1
VCC_IA1: length 2.8
  BOTTOM w0.254: PU610.3 88.22,73.24 87.38,72.39 PC1335.1 86.59,72.39 PR688.2
VCC_IA2: length 3.7
  TOP w0.254: PR691.2 87.19,64.35 v1(86.93,64.09) 86.67,63.83 v2(86.67,63.57)
  BOTTOM w0.254: PU613.3 86.65,63.58 v2(86.67,63.57) 86.67,63.45 86.94,63.18 PC677.1
VCCDSW_EN: length 137.6
  TOP w0.086: UE1.M7 264.19,55.8 v2(263.82,55.43) ; RC445.1 170.15,37.07 CE66.1 170.15,36.03 169.65,35.53 v1(169.4,35.53) 169.4,35.28 168.53,34.41 168.53,32.56 168.19,32.22 167.52,32.22 167.13,31.84 v3(167.13,26.5)
  GND1 w0.086: v4(167.45,27.04) 167.45,26.82 v3(167.13,26.5)
  IN1 w0.051: v4(262.48,51.09) 262.44,51.12 262.44,53.93 263.82,55.3 v2(263.82,55.43) ; v4(255.31,26.98) 254.48,26.15 250.53,26.15 250.03,26.65 243.05,26.65 242.25,25.86 231.38,25.86 230.76,26.48 230,26.48 229.28,25.76 195.37,25.76 194.69,26.44 181.13,26.44 180.81,26.12 178.62,26.12 178.62,26.12 178.31,26.12 178.3,26.12 177.96,26.12 177.96,26.12 177.64,26.12 177.64,26.12 177.39,26.12 176.78,25.51 168.98,25.51 v4(167.45,27.04)
  IN4 w0.051: v4(255.31,26.98) 255.31,27.08 255.72,27.48 256.14,27.48 257.61,28.95 257.61,33.85 258.79,35.02 258.79,41.49 261.35,44.05 261.35,47 261.45,47.1 261.45,50.19 262.35,51.09 v4(262.48,51.09)
VCCDSW_EN_GPIO: length 243
  TOP w0.086: RC445.2 169.21,38.77 168.9,38.46 168.9,37.54 169.12,37.32 169.36,37.32 169.72,36.96 169.72,36.32 168.93,35.53 168.93,35.28 168.32,34.67 168.32,33.43 DC1.2 166.92,32.04 166.92,29.19 166.08,28.36 166.08,27.09 165.75,26.76 162.07,26.76 161.04,27.78 v1(159.53,27.78) 157.59,27.78 v3(157.55,27.75)
  GND1 w0.086: v4(157.07,27.75) v3(157.55,27.75)
  IN2 w0.061: v2(25.7,84.79) 25.7,84.57 23.92,82.79 23.74,82.79 21.66,80.7 20.3,80.7 17.64,78.04 17.64,76 14.61,72.97 14.61,70.06 12.36,67.81 12.36,66.38 11.52,65.55 11.52,62.44 13.4,60.56 13.4,56.84 13.99,56.25 13.99,48.45 16.68,45.76 16.68,33.21 19.54,30.35 19.54,26.74 20.71,25.57 23.27,25.57 24.06,24.78 25.7,24.78 28.75,27.83 28.75,28.51 29.93,29.7 104.97,29.7 106.59,28.08 125.79,28.08 126.86,29.15 144.77,29.15 145.25,29.64 155.18,29.64 v4(157.07,27.75)
  BOTTOM w0.086: RC431.1 18.6,87.27 19.46,87.27 QC6.2 20.61,86.37 24.12,86.37 v2(25.7,84.79)
VCCDSW_EN_Q: length 8.9
  TOP w0.086: DC2.2 169.69,41.16 169.25,40.71 169.25,40.01 v1(169.36,39.9) 169.36,39.71 168.69,39.04 168.69,37.45 169.03,37.11 169.27,37.11 169.51,36.87 169.51,36.41 169.2,36.1 168.98,36.1 RC442.1 167.68,34.81 DC1.1
VCCIO_SENSE: length 59.5
  TOP w0.117: v2(142.04,64.67) 141.93,64.67 141.18,65.42 RC165.1 ; v1(179.88,33.87) 180.23,33.51 v2(180.23,33.08)
  TOP w0.254: PR422.2 180.26,33.05 v2(180.23,33.08)
  IN4 w0.051: v2(142.04,64.67) 143.19,65.82 144.54,65.82 145.13,65.23 145.13,64.7 146.19,63.64 147.74,63.64 148.56,62.82 150.44,62.82 150.92,62.34 151.22,62.34 151.88,61.68 151.96,61.68 152.22,61.43 152.22,61.43 152.44,61.2 152.44,61.2 153.51,60.13 153.51,59.7 155.9,57.31 158.33,57.31 161.23,54.42 163.03,54.42 166.08,51.36 166.08,50.31 167.35,49.04 167.35,48.73 171.62,44.46 171.62,42.73 173.78,40.57 173.78,38.17 174.94,37.02 176.29,37.02 180.23,33.08 v2(180.23,33.08)
  BOTTOM w0.254: v2(142.04,64.67) UC1.AM23
VCCSA_B+: length 1.5
  TOP w0.086: PC608.1 v6(83.09,53.88)
  vias: v2(83.77,52.89)
VCCSENSE: length 87.4
  TOP w0.203: PC618.2 71.85,82.96 71.83,82.94 PC617.1 71.83,82.92 71.71,82.8 PC620.1
  TOP w0.254: v3(73.58,83.55) v1(73.1,84.03) 72.07,84.03 71.86,83.82 PC618.2
  GND1 w0.254: v4(74.21,83.47) 74.09,83.47 74.01,83.55 v3(73.58,83.55)
  IN3 w0.203: v4(74.21,83.47) 75.53,82.15 77.55,82.15 77.97,81.74 103.74,81.74 104.32,81.15 104.32,78.56 106.24,76.64 110.18,76.64 110.43,76.64 112.89,79.1 114.62,79.1 116.32,80.81 117.14,80.81 118.29,79.66 132.91,79.66 133.04,79.54 136.54,79.54 137.3,78.78 137.3,78.52 v4(137.58,78.24)
  GND5 w0.086: v4(137.58,78.24) 137.93,78.59 v5(137.93,78.61)
  GND5 w0.254: v4(74.21,83.47) 74.24,83.45 74.24,83.04 v5(74.29,82.99)
  BOTTOM w0.086: v5(137.93,78.61) 137.93,78.9 138.02,78.99 138.02,79.24 138.03,79.26 138.03,80.14 138.02,80.15 138.02,81.48 137.67,81.83 137.67,83.94 RC140.1
  BOTTOM w0.117: v5(137.93,78.61) UC1.E32
  BOTTOM w0.254: v5(74.29,82.99) 71.82,82.99 71.23,82.39 PR622.1
VCCST_PWRGD: length 305.8
  TOP w0.086: v2(263.54,70.86) 264.27,70.86 264.82,71.41 UE4.4 ; v2(107.01,90.8) v6(106.48,90.27)
  GND1 w0.086: v3(265.93,46.11) 265.96,46.18 v4(266.35,46.35)
  IN3 w0.061: v4(68.42,90.81) 69.15,90.09 79.71,90.09 81.01,88.78 87.05,88.78 87.58,88.25 102.93,88.25 104.68,90 105.85,90 106.65,90.8 v2(107.01,90.8) 108.35,90.8 108.57,90.58 115.68,90.58 115.97,90.86 124.5,90.86 126.18,89.18 132.58,89.18 132.93,88.83 136.6,88.83 138.22,90.45 138.22,93.07 138.73,93.58 143.53,93.58 148.06,89.05 156.57,89.05 156.65,89.13 162.85,89.13 163.82,88.16 172.26,88.16 174.61,85.81 174.61,85.8 175.81,84.6 175.81,77.8 176.29,77.33 176.29,68.22 176.8,67.7 176.8,64.87 177.72,63.95 177.72,60.37 180.05,58.04 180.05,55.93 185.53,50.45 187.04,50.45 188.67,48.82 190.57,48.82 192.53,46.86 200.68,46.86 201.56,45.98 201.73,45.98 201.81,45.98 201.81,45.98 210.58,45.98 214.51,49.9 221.88,49.9 225.62,53.64 225.62,60.58 225.25,60.94 225.25,63.84 226.82,65.4 232.26,65.4 232.68,64.98 236.69,64.98 237.02,64.65 240.64,64.65 243.58,67.59 243.58,69.6 244.31,70.34 246.83,70.34 247.37,69.81 251.75,69.81 254.93,72.98 257.75,72.98 259.86,75.09 263.38,75.09 263.95,74.52 263.95,71.27 v2(263.54,70.86)
  GND5 w0.086: v5(266.81,46.5) 266.66,46.35 266.36,46.35 v4(266.35,46.35) ; v5(67.84,90.61) 68.22,90.61 v4(68.42,90.81)
  BOTTOM w0.086: CC301.1 RC78.1 110.46,86.72 RC71.1 110.46,88.04 107.7,90.8 v2(107.01,90.8) ; v5(67.84,90.61) 67.84,91.09 RC123.1 ; v5(266.81,46.5) 267,46.69 267.84,46.69 270.8,49.66 270.8,55.87 270.3,56.37 270.3,58.88 271.66,60.24 271.66,66.14 267.48,70.32 264.09,70.32 v2(263.54,70.86)
VCCST_PWRGD_CPU: length 13
  BOTTOM w0.076: 116.56,82.7 116.72,82.54 118.86,82.54 119.55,81.86 119.55,80.95 UC1.B65
  BOTTOM w0.086: RC78.2 v1(110.53,84.68) 110.53,83.96 111.57,82.91 116.35,82.91 116.56,82.7
VCCST_PWRGD_EC: length 12.8
  TOP w0.086: RE552.2 265.04,47.02 RE308.2 265.93,47.46 v1(265.42,47.96) 265.42,48.68 v3(265.45,48.7) ; UE1.K10 v2(266.96,57.04)
  GND1 w0.086: v4(265.42,49.26) 265.45,49.23 v3(265.45,48.7)
  IN1 w0.051: v2(266.96,57.04) 266.96,56.9 266.59,56.53 266.59,56.12 266.31,55.84 265.96,55.84 265.75,55.63 265.75,55.1 266.09,54.76 266.09,52.92 265.45,52.28 265.45,49.28 v4(265.42,49.26)
VCCSTG_EN: length 151.3
  TOP w0.086: v3(141.57,27.82) 141.57,27.39 141.96,27 145.77,27 147.91,29.14 151.23,29.14 154.52,32.43 156.15,32.43 163.28,39.57 163.28,41.64 160.46,44.46 160.46,47.36 162.74,49.64 162.74,53.05 162.63,53.16 162.63,53.94 162.79,54.1 162.79,60.55 164.79,62.54 167.2,62.54 168.71,64.05 168.71,67.73 169.1,68.12 169.1,74.6 170.38,75.88 170.38,77.01 v2(170.05,77.35) ; RZ120.1 91.09,46.01 91.09,40.18 91.96,39.31 ; v3(141.57,28.56) 141.57,30.97 140.2,32.34 114.09,32.34 112.69,33.74 93.64,33.74 91.96,35.42 v1(91.96,38.43)
  TOP w0.117: 91.96,39.31 v1(91.96,38.43)
  GND1 w0.086: v3(141.57,28.56) v3(141.57,27.82)
  BOTTOM w0.086: v2(170.05,77.35) 170.54,77.84 170.54,78.62 170.74,78.83 170.74,80.51 170.64,80.61 170.64,80.62 170.64,80.63 170.45,81.59 169.13,82.91 169.13,83.66 169.76,84.3 170.35,84.3 170.72,83.92 UZ35.4 171.15,83.59 170.94,83.38 RZ320.2 171.73,82.07 171.73,81.68 171.6,81.55 UZ19.4
VDD_ISL9538: length 16.8
  TOP w0.203: PR919.1 54.19,33.06 PR918.2 ; 54.19,33.52 54.19,33.72 54.54,34.06 PU901.18
  TOP w0.381: v3(53.34,33.08) 54.19,33.08 PR918.2 54.19,33.52 ; v3(49.57,36.01) 49.17,36.42 v1(49.17,37.46) 49.17,38.26 50.39,39.48 PR915.2
  GND1 w0.381: v3(49.57,36.01) 49.74,35.85 v4(50.16,35.85) ; v4(53.85,33.09) 53.84,33.08 v3(53.34,33.08)
  IN2 w0.381: v4(53.85,33.09) 53.75,33.09 53.74,33.1 49.71,33.1 49.33,33.48 49.33,35.02 v4(50.16,35.85)
VIN_1.8VALW: length 1.1
  TOP w0.086: PL502.2 v1(207.04,25.56)
VIN_1V_PRIM: length 1.4
  GND1 w0.086: 166.39,37.58 166.34,37.58 166.31,37.55 v4(166.18,37.55) ; 165.96,38.05 v3(165.98,38.03)
  BOTTOM w0.086: PL408.2 v1(163.86,36.99)
  vias: v3(166.44,38.03) v4(165.6,37.55) v5(166.67,37.78) v5(167.39,38.08)
VIN_1VS_VCCIO: length 1.5
  TOP w0.086: v1(172.62,31.56) 171.91,30.84 PL407.2
VSS_GT_SENSE: length 55.3
  TOP w0.254: v2(76.14,75.4) 75.99,75.4 75.77,75.61 75.39,75.61 PC654.2 ; v2(115.13,75.52) 115.08,75.58 115.08,76.26 RC163.1
  IN1 w0.203: v2(115.13,75.52) 115,75.66 115,75.85 114.53,76.32 113.81,76.32 113.17,75.69 107.24,75.69 104.85,78.09 104.32,79.35 104.32,81.61 103.55,82.38 95.94,82.38 94.44,80.88 78.66,80.88 77.09,79.32 77.09,75.97 76.52,75.4 v2(76.14,75.4)
  BOTTOM w0.076: UC1.J69 116.42,76.18 116.1,76.18 115.58,75.97 v2(115.13,75.52)
  BOTTOM w0.203: PC653.2 76.92,75.53 76.27,75.53 v2(76.14,75.4) 76.01,75.53 PU602.18
VSSIO_SENSE: length 56.1
  TOP w0.117: RC167.1 142.69,64.67 v2(142.96,64.67)
  TOP w0.127: v2(179.29,33.08) 179.37,33 PR412.2
  IN4 w0.127: v2(142.96,64.67) 143.4,65.11 143.93,65.11 144.44,64.6 144.84,64.6 146.28,63.16 147.38,63.16 148,62.54 149.6,62.54 149.95,62.19 149.95,60.77 156.7,54.02 158.67,54.02 159.92,52.76 163.18,52.76 165.36,50.59 165.36,50.01 166.63,48.74 166.63,48.43 170.88,44.17 170.88,41.97 172.82,40.03 172.82,38.11 174.64,36.29 175.99,36.29 179.2,33.08 v2(179.29,33.08)
  BOTTOM w0.127: v2(142.96,64.67) UC1.AM22
VSSSENSE: length 82.3
  TOP w0.203: PC620.2 72.48,80.39 v2(72.48,80.3) 72.48,79.97 72.43,79.92 PC619.2
  IN3 w0.203: v2(72.48,80.3) 72.49,80.3 72.49,80.53 73.78,81.82 77.41,81.82 77.83,81.41 103.6,81.41 103.99,81.01 103.99,78.43 106.11,76.31 110.04,76.31 110.04,76.31 110.57,76.31 113.03,78.77 114.75,78.77 116.46,80.48 117,80.48 118.15,79.33 132.78,79.33 132.9,79.21 136.19,79.21 v4(136.57,78.83)
  GND5 w0.086: v4(136.57,78.83) 136.82,78.83 137.01,78.63 v5(137.01,78.6)
  BOTTOM w0.086: RC141.1 v1(137.42,84.59) 137.29,84.45 137.29,80.64 137.46,80.47 137.46,80.23 137.46,80.22 137.46,79.82 137.46,79.82 137.46,79.58 137.46,79.57 137.46,79.04 v5(137.01,78.6)
  BOTTOM w0.203: PU602.6 72.49,80.3 v2(72.48,80.3)
32KHZ_OUT: length 11.6
  TOP w0.086: UE1.F3 v2(260.62,60.98)
  GND1 w0.117: v3(252.84,65.08) 252.84,64.74 v4(253,64.58)
  IN1 w0.051: v4(253,64.58) 253,63.39 253.95,62.44 256.81,62.44 257.14,62.77 259.58,62.77 260.22,62.14 260.22,61.38 v2(260.62,60.98)
+AC1_IN: length 18.1
  GND1 w0.254: v4(55.29,80.96) 55.29,80.96 v3(54.74,80.96)
  GND5 w0.254: v4(55.29,80.96) 55.29,81.4 v5(55.04,81.65)
  BOTTOM w0.254: 52.75,82.36 52.57,82.53 PR1203.1 PC1205.1 52.57,84.81 51.68,85.7 PR1287.1 51.68,85.86 52.24,86.42 PC1204.2 52.6,87.31 PR1206.1 ; 52.75,82.36 54.33,82.36 v5(55.04,81.65) ; 52.75,82.36 52.29,81.9 49.33,81.9 47.74,83.49 PQ1225.3 47.58,84.12 PR1277.1
  vias: v6(53.94,79.18)
+AC2_IN: length 10.6
  TOP w0.254: v2(43.34,39.52) 43.35,39.52 43.74,39.91 43.74,40.93 44.88,42.07 PQ1227.3 ; 43.87,45.11 44.05,44.93 44.05,43.82 44.88,42.99 PQ1227.3 ; PQ1227.3 46.76,42.56 PR1280.1
  BOTTOM w0.254: v2(43.34,39.52) 43.35,39.52 43.69,39.18 43.69,38.66 43.98,38.36 PR1288.1
  vias: v1(42.27,46.25)
+BL_PWR_SRC: length 2.3
  TOP w0.102: 223.93,38.16 224.41,38.16 v6(224.64,38.39) ; v6(221.16,38.64) 221.54,38.26 221.94,38.26
  TOP w0.127: 223.27,36.66 223.27,36.37 v6(223.09,36.19)
  vias: v2(222.32,37.02) v2(222.95,37.02) v2(223.59,37.02)
+CHARGER_SRC:
  vias: v2(48.04,55.64) v2(49.28,55.64) v2(49.4,57.58) v2(49.98,57.58) v2(50.56,57.58) v2(51.15,57.58) v6(52.19,58.91)
+COINCELL: length 5.3
  TOP w0.508: v2(289.35,20.15) 288.87,20.63 JRTC1.1
  BOTTOM w0.508: PR2.1 PC2.2 v1(289.86,21.74) 289.86,21.55 289.35,21.04 v2(289.35,20.15)
+DCPRTC: length 5.6
  TOP w0.254: CC214.1 153.25,55.38 v2(150.71,57.92)
  BOTTOM w0.203: UC1.BB10 150.57,58.06 v2(150.71,57.92)
+DDR_VREF_A_DQ: length 39.7
  IN2 w0.508: v2(117.29,59.19) 117.29,58.96 110.52,52.18 109.9,52.18 106.47,48.75 98.37,48.75 97.45,47.84 94.2,47.84 90.93,44.56 v2(90.7,44.56)
  BOTTOM w0.254: UC1.AY68 117.29,59.73 v2(117.29,59.19)
  BOTTOM w0.508: RD37.1 CD40.1 90.04,40.65 89.45,41.23 89.45,43.93 90.09,44.56 v2(90.7,44.56)
+DDR_VREF_B_DQ: length 11.3
  BOTTOM w0.152: 117.41,58.35 117.6,58.54 117.6,58.86 117.92,59.18 UC1.BA67
  BOTTOM w0.203: 116.8,57.75 117.41,58.35
  BOTTOM w0.508: 116.8,57.75 116.28,57.22 116.28,54.27 114.87,52.86 v1(114.32,52.86) 114.32,52.59 113.43,51.7 CD67.1 RD76.1
+DDR_VREF_CA: length 38.6
  IN2 w0.508: v2(91.78,44.2) 91.78,44.51 94.47,47.2 106.09,47.2 110.08,51.19 111.24,51.19 v2(111.6,50.83)
  BOTTOM w0.203: UC1.AY67 118.24,59.68 118.24,58.67 118.35,58.56 118.35,57.99 117.29,56.93 117.29,56.53
  BOTTOM w0.508: v2(91.78,44.2) 91.53,44.44 91.53,45.32 CD39.1 RD36.1 ; v2(111.6,50.83) 113.78,50.83 v6(114.1,51.15) 117.29,54.34 117.29,56.53
+DV_12S: length 2.9
  TOP w0.203: UR1.21 281.86,57.79
  TOP w0.508: 281.86,57.79 v1(282.35,57.79) 282.59,57.79 283.1,58.3 CR10.1 283.1,58.65 CR9.1
+EC_DEBUG_VCC: length 4.8
  BOTTOM w0.102: 247.54,29.7 248.28,28.97 v1(248.28,28.72)
  BOTTOM w0.254: JDEG1.1 245.03,29.42 245.28,29.17
  BOTTOM w0.508: RE71.2 247.54,29.7 246.83,28.99 245.46,28.99 245.28,29.17
+EDP_VDD: length 1.2
  BOTTOM w0.102: UV24.1 v1(230.8,25.56)
+LCDVDD: length 3.4
  TOP w0.102: v2(226.57,27.34) v6(226.57,25.9) ; v2(226.57,27.34) v6(225.59,27.34) ; v2(226.57,27.34) v6(227.56,27.34)
+MIC2-VREFO-L: length 2.9
  TOP w0.203: RA5.2 272.4,31.89 v1(271.48,32.81) 270.78,33.52 UA1.27
+MIC2-VREFO-R: length 2.8
  TOP w0.203: UA1.28 270.76,33.92 270.81,33.87 271.01,33.87 272.13,32.75 RA6.2
+PBATT: length 7.3
  TOP w0.508: 63.11,47.44 63.11,43.85 61.76,42.5 61.76,42.48 PR940.1
  vias: v6(63.87,52.08)
+PECI_VREF: length 17.3
  TOP w0.102: v3(268.65,47.02) v1(269.56,47.02)
  TOP w0.254: UE1.J11 267.78,57.82 269.18,57.82 270.71,56.3 270.82,56.3 CE25.1 270.87,55.94 270.25,55.94 v3(270.1,56.09)
  GND1 w0.254: v3(268.65,47.02) 268.65,47.27 v4(268.97,47.58) ; v4(269.49,56.32) 269.71,56.09 v3(270.1,56.09)
  IN4 w0.254: v4(269.49,56.32) 269.4,56.23 269.4,54.72 269.98,54.14 269.98,48.63 268.97,47.62 v4(268.97,47.58)
+PWR_SRC: length 198.2
  TOP w0.381: PC989.1 v2(66.51,60.92)
  TOP w0.508: PC986.1 64.69,61.2 v2(64.94,60.94) ; PD901.2 69.21,34.49 v2(69.21,35.14) ; v2(223.51,30.19) 224.02,30.19 v2(226.52,32.69) ; v2(55.69,44.97) 55.69,42.64 56.13,42.21 PR929.2 ; v2(65.63,60.94) 65.57,60.99 PC988.1 ; 89.45,36.28 89.45,33.79 92.3,30.95 107.99,30.95 111.17,27.77 v6(113.12,27.77) 125.77,27.77
  IN1 w0.508: v4(68.9,44.76) 73.18,44.76 74.23,45.81 74.23,50.4 v2(75.1,51.27)
  IN2 w0.508: v4(68.9,44.76) 68.9,44.08 68.93,44.05 68.93,43.47 69.69,42.71 69.69,41.79 69.21,41.3 v2(69.21,35.14)
  IN2 w1.016: 129.07,26.5 129.63,25.94 145.27,25.94 147.43,28.1 152.87,28.1 154.63,26.34
  BOTTOM w0.508: CV13.2 226.85,32.36 v2(226.52,32.69) ; 158.23,25.79 158.41,25.61 173.23,25.61 174.43,26.81 198.42,26.81 200.65,29.04 ; JIR1.5 172.92,47.5 173.6,46.83 177.81,46.83 180.64,49.67 183.63,49.67 184.19,50.22 186.15,50.22 187.08,49.3 187.08,47.65 186.72,47.29 186.72,46.57 188.04,45.25 193.36,45.25 194.22,44.38 194.22,41.41 195.06,40.57 195.33,40.57 199,36.91 199.01,36.91 199.1,36.81 200.43,36.81 200.88,37.26 203,37.26 203.56,36.7 RZ85.1 203.89,36.42 204.28,36.03 204.28,35.01 203.29,34.02 203.29,33.02 202.61,32.33 202.61,29.8 ; PR102.2 56.38,74.1 v2(56.18,74.3)
  vias: v2(54.27,76.36) v2(54.27,75.74) v2(54.88,76.13) v2(54.88,75.52) v2(54.91,74.94) v2(54.9,74.33) v2(55.53,76.12) v2(55.53,75.52) v2(55.54,74.3) v2(55.55,74.93) v2(56.16,76.12) v2(56.16,75.52) v2(56.19,74.93) v2(62.46,58.51) v2(62.46,57.87) v2(62.46,57.29) v2(62.46,56.65) v2(62.46,56.07) v2(62.82,55.5) v2(63.02,59.46) v2(63.12,57.87) v2(63.12,57.29) v2(63.12,56.65) v2(63.12,56.07) v2(63.45,55.5) v2(63.63,59.46) v2(63.84,57.87) v2(63.84,57.29) v2(63.84,56.65) v2(63.84,56.07) v2(64.42,56.65) v2(64.42,56.07) v2(65,56.65) v2(65.59,56.65) v2(66.12,52.66) v2(66.17,56.65) v2(66.76,56.65) v2(67.37,52.66) v2(68.61,52.66) v2(69.85,52.66) v2(75.1,52.54) v2(75.1,51.9) v2(75.73,52.54) v2(75.74,51.9) v2(75.74,51.27) v2(79.72,48.45) v2(80.33,48.45) v2(80.92,48.45) v2(127.65,27.39) v2(128.29,27.39) v2(155.49,25.87) v2(156.13,25.87) v2(210.88,29.64) v2(221.53,30.13)
+PWR_SRC_AC: length 2.2
  TOP w0.102: v6(52.66,55.48) 53.49,56.32 PD906.1
  vias: v2(55.59,56.69) v2(55.59,56.05)
+PWR_SRC_R: length 1.7
  BOTTOM w0.381: RZ85.2 CZ78.2 202.7,35.53 201.85,35.53
+RREF: length 2.5
  TOP w0.203: UR1.7 276.71,56.59 276.65,56.52 276.47,56.52 276.42,56.47
  TOP w0.305: 276.42,56.47 275.63,55.68 RR4.2
+RTC_CELL: length 134.9
  TOP w0.254: RE507.2 v3(259.83,67.75) ; v3(263.43,42.04) 263.43,42.24 263.11,42.55 262.77,42.55 262.46,42.86 260.12,42.86 259.79,42.54 259.25,42.54 258.08,41.37 258.08,40.57 257.88,40.37 255.95,40.37 255.12,41.19 v6(254.42,41.19) 254.35,41.19 253.19,40.04 v3(252.19,40.04) ; v2(247.57,75.9) 246.96,75.9 246.49,75.43 RE31.1 ; RE32.2 252.76,69.01 v2(253.03,69.27)
  TOP w0.381: QE15.3 v2(264.79,83.96)
  TOP w0.508: RE324.2 251.68,62.95 v2(251.05,63.58) ; RE551.2 266.87,45.83 266.36,45.32 265.9,45.32 264.89,44.31 264.89,43.65 263.72,42.48 263.72,42.33 v3(263.43,42.04)
  GND1 w0.254: v3(259.83,67.75) 259.83,68.08 v4(259.53,68.39) ; v4(263.36,42.53) 263.43,42.47 v3(263.43,42.04) ; v4(251.87,40.42) 251.87,40.36 v3(252.19,40.04)
  IN2 w0.254: v4(251.87,40.42) 251.87,43.51 252.24,43.88 252.24,45.04 251.91,45.37 251.91,48.62 252.32,49.03 252.82,49.03 253.17,49.37 253.17,52.35 252.91,52.6 252.4,52.6 252.01,52.99 252.01,55.91 252.39,56.29 252.39,58.3 250.92,59.78 250.92,60.84 251.25,61.17 251.25,63.28 251.05,63.48 v2(251.05,63.58)
  IN2 w0.381: v2(264.79,83.96) 262.88,82.05 262.88,74.56 v2(262.86,74.53)
  IN3 w0.254: v2(262.86,74.53) 262.86,74.46 262.22,73.82 260.82,73.82 260.57,73.57 260.57,69.43 v4(259.53,68.39) 259.2,68.39 258.97,68.16 257.95,68.16 257.62,68.49 253.81,68.49 v2(253.03,69.27)
  IN4 w0.254: v2(253.03,69.27) 253.03,68.51 251.1,66.59 250.86,66.59 250.36,66.08 250.36,64.24 251.02,63.58 v2(251.05,63.58)
  GND5 w0.254: v4(263.36,42.53) 263.59,42.53 263.91,42.21 v5(263.91,41.77)
  BOTTOM w0.254: v2(253.03,69.27) 253.03,71.27 252.58,71.71 249.99,71.71 248.68,73.02 248.68,75.52 248.3,75.9 v2(247.57,75.9) ; v5(263.91,41.77) 263.8,41.66 263.8,30.19 267.59,26.4 282.06,26.4 283.25,25.21 PC3.1 285.59,25.19 PD3.1
+RTC_CELL_PCH: length 254.5
  TOP w0.254: CE63.1 269.31,84.18 269.31,84.95 268.85,85.4 265.8,85.4 263.11,88.1 263.11,89.54 262.81,89.85 259.1,89.85 258.36,90.59 254.47,90.59 254.2,90.31 250.19,90.31 247.85,87.96 246.8,87.96 242.61,83.78 242.61,77.07 242.89,76.79 242.89,71.1 244.64,69.35 244.64,65.13 v2(246.38,63.39) ; v3(148.38,58.99) 148.38,58.48 151.73,55.13 151.73,54.19 RC69.2 151.73,52.76 CC213.1 RC56.2 152.67,52.49 153.92,51.24 v6(153.92,50.97) 153.92,50.68 153.54,50.3 v2(153.31,50.3)
  TOP w0.381: QE15.1 267.58,84.03 268.09,83.52 CE63.1
  TOP w0.508: v2(267.12,81.52) 266.97,81.37 RE546.1 266.39,81.77 266.87,82.25 268.27,82.25 268.65,82.64 CE63.1 ; RC57.2 154.9,52.89 153.59,51.57
  GND1 w0.254: v3(144.1,65.24) 144.51,65.24 144.58,65.16 v4(144.58,65.1) ; v4(148.3,59.72) 148.38,59.65 v3(148.38,58.99)
  GND1 w0.508: v4(266.34,47.18) 266.31,47.18 266.46,47.02 v3(266.87,47.02)
  IN1 w0.254: v4(227.12,35.26) 226.71,35.67 224.78,35.67 223.1,33.99 218.56,33.99 218.19,33.61 218.18,33.61 218.15,33.59 206.61,33.59 206.59,33.61 198.25,33.61 197.67,34.19 184.66,34.19 183.13,35.72 176.84,35.72 175.68,36.88 172.09,36.88 169.83,39.14 166.1,39.14 165.68,39.56 161.34,39.56 157.36,43.54 157.36,44.79 157.98,45.42 157.98,45.82 157.85,45.96 157.85,45.98 157.48,46.34 156.58,46.34 153.46,49.46 153.46,50.15 v2(153.31,50.3) ; v4(148.3,59.72) 147.97,59.72 147.94,59.76 147.93,59.76 146.93,60.77 145.5,60.77 145.25,61.02 145.25,64.5 144.65,65.1 v4(144.58,65.1)
  IN3 w0.508: v4(266.34,47.18) 266.34,48.37 267.96,50 269.13,50 270.53,51.39 270.53,52.28 272.31,54.06 272.76,54.06 273.63,54.92 273.63,59.19 275.18,60.74 275.18,65.79 276.22,66.84 276.22,70.65 274.19,72.68 273.04,72.68 270.78,74.94 270.78,76.31 267.12,79.97 v2(267.12,81.52)
  IN4 w0.254: v4(227.12,35.26) 227.12,35.34 229.18,37.4 229.18,38.01 229.56,38.39 229.9,38.39 241.23,49.72 241.23,58.34 246.29,63.39 v2(246.38,63.39)
  GND5 w0.254: v4(148.3,59.72) 148.15,59.57 v5(148.15,59.02) ; v5(144.92,65.44) v4(144.58,65.1)
  BOTTOM w0.254: v5(144.92,65.44) 144.98,65.44 145.36,65.83 UC1.AK19
+RTC_CELL_VBAT: length 11.1
  TOP w0.102: CE11.1 251.11,66.98 v1(251.06,66.94)
  TOP w0.254: UE1.A2 v2(259.82,64.98) ; v2(253.59,67.53) 253.39,67.73 RE32.1 252.59,67.57 CE11.1
  BOTTOM w0.508: v2(259.82,64.98) 257.62,64.98 255.07,67.53 v2(253.59,67.53)
+SD40_AV12: length 5.6
  TOP w0.102: CR8.1 283.08,61.68 284.22,60.54 v1(284.37,60.54)
  TOP w0.203: 281.24,59.19 281.24,59 UR1.24
  TOP w0.508: 281.24,59.19 281.24,60.43 281.83,61.02 282.34,61.02 CR8.1
+SDC_IN: length 19.9
  TOP w0.254: PR1238.1 51.1,49.23 52.62,47.71 PR944.1 52.34,43.92 51.85,44.4 PR943.1 ; PQ1212.3 46.68,49.66 46.25,49.66 46.07,49.84 46.07,50.53 45.81,50.79 43.93,50.79 42.5,52.22 PQ1213.3 42.5,56.16 42.51,56.17 42.51,57.15 PR1235.2
  vias: v2(48.33,71.05) v2(48.33,70.44) v2(48.33,69.86) v2(48.35,71.66) v2(48.99,71.66) v2(48.96,71.05) v2(48.96,70.44) v2(48.96,69.86) v2(50.15,47.53) v2(50.15,46.89) v2(50.15,46.26) v2(50.74,47.53) v2(50.74,46.89) v2(50.74,46.26) v2(51.33,47.53) v2(51.33,46.9) v2(51.35,46.27) v2(57.95,61.76) v2(57.95,61.15) v2(58.59,61.76) v2(58.59,61.15) v2(58.59,60.51) v2(61.26,61.68) v2(61.26,61.05) v2(61.26,60.41) v2(61.26,59.78) v2(61.82,61.38) v6(44.18,74.89) v6(44.53,71.97) v6(50.51,48.81)
+SDREG2: length 6.4
  TOP w0.102: CR15.1 281.28,51.39 v1(282.35,50.33)
  TOP w0.203: UR1.14 279.78,54.95 279.89,54.83
  TOP w0.381: 280.88,53.82 280.88,53.92 280.54,54.26 280.46,54.26 279.89,54.83
  TOP w0.508: 280.88,53.82 280.88,52.2 281.09,51.99 CR15.1
+SIM_PWR: length 119.6
  TOP w0.508: JNGFF2.36 231.67,79.9 230.3,78.53 229.45,78.53 CZ304.1 229.4,78.75 v3(230.44,79.79)
  GND1 w0.508: v4(230.97,80.18) 230.6,79.8 230.46,79.8 v3(230.44,79.79)
  IN3 w0.508: v4(253.13,85.1) 252.57,85.66 245.69,85.66 240.48,90.86 237.56,90.86 236.36,92.06 228.92,92.06 228.01,91.14 v4(228.01,90.38)
  IN4 w0.508: v4(253.13,85.1) 269.61,85.1 272.41,82.3 272.41,77.55 276.19,73.77 276.19,71.86 277.51,70.54 277.51,67.03 277.97,66.58 277.97,61.9 279.94,59.93 281.26,59.93 283.75,57.44 283.75,56.12 284.4,55.47 284.4,52.49 v2(284.22,52.31) ; v4(228.01,90.38) 227.65,90.03 226.32,90.03 224.84,88.55 224.84,84.12 226.46,82.51 226.46,81.08 227.64,79.89 229.45,79.89 229.92,80.36 230.79,80.36 v4(230.97,80.18)
  BOTTOM w0.33: 281.09,57.53 280.81,57.25 280.81,55.46 281.22,55.05
  BOTTOM w0.381: 281.09,57.53 CZ41.1
  BOTTOM w0.508: CZ41.1 CZ37.1 282.17,57.79 282.96,58.58 RZ335.1 ; v2(284.22,52.31) 285.13,53.22 JSIM1.1 283.39,55.05 281.22,55.05
+TBTA_LDO_BMC: length 1.7
  BOTTOM w0.254: UT5.E1 32.22,70.47 32.81,69.88 CT71.1
+TBTA_SENSE: length 3
  TOP w0.102: v1(34.28,75.29) 34.69,75.7 v2(34.84,75.7)
  TOP w0.508: v2(34.84,75.7) 35.2,75.7 RT397.2
  BOTTOM w0.203: UT5.B10 UT5.A10
  BOTTOM w0.254: UT5.A10 34.24,75.54 34.43,75.54 34.54,75.65 34.79,75.65 v2(34.84,75.7)
+TBTA_VBUS: length 7.8
  TOP w0.102: v2(21.63,87.46) 21.09,87.46 v6(20.96,87.59) ; v6(25,87.51) 24.35,87.51 v2(24.3,87.46)
  TOP w0.254: JUSBC1.B9 6.95,84.08 7.2,83.82 JUSBC1.A4 8.28,83.82 8.32,83.78 v2(9.57,83.78)
  TOP w0.279: JUSBC1.B4 6.3,81.57 6.49,81.38 7,81.38 7.06,81.32 JUSBC1.A9 8.16,81.32 8.35,81.52
  vias: v2(10.15,83.75) v2(10.28,84.34) v2(10.3,81.62) v2(10.51,81.03) v2(10.74,83.96) v2(10.79,84.79) v2(10.91,81.57) v2(10.96,80.65) v2(11.22,84.39) v2(11.33,81.15) v2(14.62,81.72) v2(14.6,81.14) v2(14.6,80.55) v2(21.63,88.1) v2(22.27,88.1) v2(22.27,87.46) v2(23.03,88.1) v2(23.03,87.46) v2(23.66,88.1) v2(23.66,87.46) v2(24.3,88.1) v2(49.19,91.78) v2(49.19,91.14) v2(49.83,91.78) v2(49.83,91.14) v2(50.46,91.78) v2(50.46,91.14) v2(50.46,90.51) v2(51.07,91.82) v2(51.1,91.14) v2(51.1,90.51) v6(49.47,89.71)
+TBTA_VBUS_1: length 66.2
  IN3 w0.508: v2(28.35,35.58) 28.35,35.86 28.86,36.37 32.26,36.37 32.57,36.05 36.83,36.05 37.48,36.7 37.48,37.92 39.54,39.98 39.54,46.32 40.73,47.52 40.73,50.83 39.2,52.36 39.2,54.25 39.36,54.4 39.36,60.11 38.69,60.77 38.69,66.19 39.2,66.7 39.99,66.7 41.23,67.94 41.23,71.59 42.66,73.02 42.66,76.84 42.15,77.35 v4(41.83,77.35)
  IN4 w0.508: v4(41.83,77.35) 41.39,77.35 40.84,77.91 37.69,77.91
  GND5 w0.254: v5(29.72,76.03) 30.09,76.42 v4(30.09,76.44)
  BOTTOM w0.508: v2(28.35,35.58) 29.05,34.88 29.05,33.54 28.22,32.71 CT94.1 26.62,32.63 UT8.1
  vias: v2(29.1,77.07) v2(29.18,76.49) v2(29.68,76.87) v2(36.77,79.24) v2(36.77,78.65) v2(37.36,79.22) v2(37.35,78.63) v6(55.06,85.72)
+TBTB_LDO_BMC: length 4.5
  BOTTOM w0.203: v1(24.87,43.65) 26.21,43.65 UT11.E1
  BOTTOM w0.254: CT147.1 24.62,43.39 v1(24.87,43.65)
+TBTB_SENSE: length 5.3
  GND1 w0.254: v4(33.29,43.53) 33.29,43.53 33.29,43.52 33.27,43.54 33.27,43.62 v3(32.73,44.15)
  IN3 w0.254: v4(30.99,42.68) 31.05,42.68 31.12,42.6 32.36,42.6 v4(33.29,43.53)
  GND5 w0.254: v5(30.37,42.5) 30.78,42.5 30.95,42.68 v4(30.99,42.68)
  BOTTOM w0.254: v5(30.37,42.5) 30.73,42.14 UT11.B10 UT11.A10
+TBTB_VBUS: length 3.4
  TOP w0.254: JUSBC2.B9 6.89,69.57 7.14,69.32 JUSBC2.A4
  TOP w0.279: JUSBC2.B4 6.32,67.07 6.57,66.82 JUSBC2.A9
  vias: v2(9.44,67.14) v2(9.52,69.27) v2(10.01,67.01) v2(10.06,69.53) v2(10.29,66.48) v2(10.5,69.93) v2(10.63,69.34) v2(10.71,66.9) v2(10.69,66.05) v2(10.94,70.32) v2(11.1,69.75) v2(11.12,66.46) v2(11.45,60.02) v2(11.45,59.43) v2(11.45,58.85) v2(11.45,58.26) v2(12.03,60.02) v2(12.03,59.43) v2(12.03,58.85) v2(12.03,58.26) v2(14.54,66.57) v2(14.54,65.99) v2(14.54,65.41) v6(13.56,57.17) v6(16.51,58.67) v6(23.92,48.73)
+TBTB_VBUS_1: length 18.2
  TOP w0.508: CT167.1 32.91,31.42 33.89,32.41 33.89,32.76 v2(34.04,32.91) 34.04,33.02 33.41,33.65 33.41,33.84 PR1252.1
  IN2 w0.508: 32.26,44.29 32.26,42.99 31.06,41.79 31,41.79 30.35,41.14 30.35,38.75 30.73,38.36 30.73,36.63 34.04,33.32 v2(34.04,32.91)
  BOTTOM w0.508: UT12.1 33.13,32.91 v2(34.04,32.91)
  vias: v2(32.19,46.34) v2(32.19,45.75) v2(32.47,45.22) v2(32.77,46.34) v2(32.77,45.75) v6(37.42,48.71)
+USB_EX2_PWR:
  vias: v2(13.63,30.95) v2(13.63,30.31) v2(13.63,29.68) v2(14.27,30.95) v6(14.42,27.63)
+UZ12_TPM: length 7.1
  GND1 w0.508: v4(164.13,42.76) 163.62,43.27 v3(163.62,43.77)
  GND5 w0.508: v5(163.5,43.04) 163.85,43.04 v4(164.13,42.76)
  BOTTOM w0.508: v5(163.5,43.04) CZ75.1 163.77,42.15 164.48,41.44 v1(164.48,41.02) 164.48,40.29 165.78,39
+UZ12_VHIO: length 19.7
  TOP w0.381: v3(167,46.92) 166.92,47 v6(166.92,47.74) 166.92,49.7 v3(166.54,50.08)
  GND1 w0.381: v3(167,46.92) 167.3,46.92 v4(167.53,46.69) ; v3(166.54,50.08) 166.54,50.61 v4(166.54,50.61)
  IN3 w0.381: v4(167.53,46.69) 167.28,46.95 165.85,46.95 165.14,47.66 v4(165.14,47.66)
  IN4 w0.381: v4(165.08,45.54) 165.4,45.85 165.4,46.51 165.14,46.77 v4(165.14,47.66)
  GND5 w0.381: v4(166.54,50.61) 166.33,50.61 v5(166.11,50.83) ; v5(164.72,44.88) 164.72,45.18 v4(165.08,45.54) ; v4(167.53,46.69) 167.86,46.36 v5(168.04,46.36)
  BOTTOM w0.254: CZ53.1 163.75,43.58 164.31,43.58 165.14,42.75 UZ12.14 ; UZ12.22 168.88,44.94 169.51,45.57 169.51,46.11 169.71,46.31 CZ54.1 168.99,46.4 RZ366.1 RZ365.1
  BOTTOM w0.356: CZ53.1 163.63,43.9 163.79,43.9 164.72,44.83 v5(164.72,44.88)
+VCHGR:
  vias: v6(57.02,57.87)
+VHDMI_IN: length 3.1
  BOTTOM w0.086: RV313.2 20.44,56.22 v1(21.12,56.9)
  BOTTOM w0.508: RV314.2 19.78,54.39 19.35,54.82 19.35,55.62
+VHDMI_VCC: length 9.5
  GND1 w0.508: v3(16.22,51.14) 16.22,50.71 v4(16.15,50.63)
  IN2 w0.508: v4(16.17,54.06) 16.17,53.63 15.24,52.69 15.24,51.16 15.77,50.63 v4(16.15,50.63)
  IN3 w0.508: v4(17.67,49.69) 17.59,49.69 16.65,50.63 v4(16.15,50.63)
  GND5 w0.508: v5(16.71,54.06) v4(16.17,54.06) ; v5(18.15,49.62) 17.75,49.62 v4(17.67,49.69)
  BOTTOM w0.508: v5(16.71,54.06) 17.16,53.61 UV2.3 ; v5(18.15,49.62) RV316.2
  vias: v6(14.78,51.71)
+VR_CAP: length 23.7
  TOP w0.102: v2(255.64,58.15) 255.02,57.53 v1(255.02,57.48)
  TOP w0.203: UE1.C10 v2(266.96,63.38)
  TOP w0.254: v2(255.64,58.15) 256.13,57.67 256.86,57.67 CE31.1 258.52,58.21 UE1.J1
  IN3 w0.152: 261.69,63.79 260.34,63.79
  IN3 w0.203: 261.69,63.79 263.01,65.11 265.24,65.11 v2(266.96,63.38) ; 260.34,63.79 259.5,63.79 259.22,64.07 257.34,64.07 257.04,63.76 257.04,63.15 256.15,62.26 256.15,59.01 255.64,58.5 v2(255.64,58.15)
+VREFCA: length 84.7
  TOP w0.254: CD11.2 119.34,37.93 v2(119.31,37.91)
  TOP w0.508: CD10.2 103.78,37.91 v2(103.76,37.89) ; 119.02,33.61 v6(124.38,33.61) 130.47,33.61 133.14,36.28 136.92,36.28 137.03,36.18 CD46.2 137.5,36.65 137.4,36.74 v2(137.4,37.1) ; 119.02,33.61 114.09,33.61 v2(113.23,34.48) ; 119.02,33.61 118.75,33.87 118.75,35.34 119.31,35.89 119.31,36.67 119.98,37.35 CD11.2
  IN2 w0.508: v4(94.3,45.33) 94.31,45.32 94.63,45.32 95.67,44.28 95.67,42.78 96.39,42.07 96.39,34.43 97.81,33 111.75,33 v2(113.23,34.48)
  IN4 w0.254: v4(94.3,45.33) 95.93,43.71 95.93,40.85 97.58,39.2 102.53,39.2 103.76,37.97 v2(103.76,37.89)
  GND5 w0.508: v5(93.32,45.33) v4(94.3,45.33)
  BOTTOM w0.254: UD4.H4 v2(152.94,37.93) ; v2(119.31,37.91) 119.28,37.88 119.28,37.78 UD2.H4 ; UD1.H4 v2(103.76,37.89) ; UD3.H4 137.08,37.49 v2(137.4,37.1)
  BOTTOM w0.508: CD47.2 150.39,35.03 150.4,35.04 v2(150.4,35.35) ; RD34.2 93.34,45.32 v5(93.32,45.33) RD38.1
+VREFDQ_A: length 20.6
  TOP w0.508: v2(118.69,43.5) 118.03,44.15 CD21.1
  IN1 w0.254: v2(93.29,41) 94.1,41 94.99,40.12 94.99,39.12 96.31,37.8 97.43,37.8 97.83,38.21 97.83,39.02 98.01,39.2 101.16,39.2 101.41,39.45 101.41,39.86 101.14,40.14 101.14,41.36 101.64,41.87 101.9,41.87 102.47,42.44 v2(102.47,43.51)
  IN3 w0.508: 119.19,41.51 119.19,41.94 118.69,42.45 v2(118.69,43.5)
  BOTTOM w0.254: UD2.J11 v2(118.69,43.5) ; UD1.J11 v2(102.47,43.51)
  vias: v2(93.29,41.61)
+VREFDQ_B: length 57.1
  TOP w0.381: CD53.1 135.41,44.99 v2(135.36,44.94)
  TOP w0.508: v2(152.7,44.54) 152.65,44.59 CD54.1 152.65,45.98 152.01,46.62 v6(142.16,46.62) 141.8,46.26 138.93,46.26 137.66,44.99 CD53.1 136.19,45.5 135.76,45.93 135.76,48.4 v2(135.1,49.06)
  BOTTOM w0.127: UD3.J11 136.1,43.44 136.1,44.44 135.6,44.94 v2(135.36,44.94) ; UD4.J11 152.27,43.48 152.27,44.11 v2(152.7,44.54)
  BOTTOM w0.508: v2(135.1,49.06) 134.87,49.28 126.27,49.28 126.27,49.28 125.03,49.28 124.36,49.95 119.12,49.95 118.46,49.28 111.34,49.28 110.83,49.79 110.83,51.19 RD75.2 RD77.1 111.37,52.61 RD76.2
+Z4012: length 2.6
  BOTTOM w0.508: v1(288.97,24.84) PR2.2 287.66,23.78 PD3.2
AC1_DISC#: length 159.3
  TOP w0.086: PR939.1 69.99,39.55 v1(70.17,39.73) 70.45,40.01 70.45,40.95 70.27,41.13 70.27,42.45 70.45,42.63 70.45,44.46 69.8,45.12 69.23,45.12 68.21,46.15 v3(67.99,46.15)
  GND1 w0.117: v4(67.38,46.01) 67.85,46.01 v3(67.99,46.15)
  IN2 w0.061: v4(62.79,42.39) 62.79,42.67 66.13,46.01 v4(67.38,46.01) 69.42,46.01 70.7,44.73 73.28,44.73 74.29,45.73 74.29,55.05 v4(73.53,55.81) ; v4(30.07,77.89) 30.07,78.37 29.79,78.64 28.97,78.64 27.97,77.64 27.97,75.19 26.12,73.34 26.12,72.34 26.13,72.34 26.13,70.43 25.58,69.89 24.45,69.89 19.55,64.98 19.55,57.64 18.81,56.91 18.81,56.23 19.43,55.62 19.43,49.26 19.07,48.9 19.07,48.59 19.07,41.9 19.78,41.2 19.78,40.62 20.01,40.39 20.59,40.39 v2(20.7,40.5)
  IN4 w0.051: v4(73.53,55.81) 73.97,56.25 73.97,67.41 67.48,73.9 66.4,73.9 65.96,74.34 65.96,81.67 66.16,81.87 v4(66.24,81.87) ; v4(62.79,42.39) 62.76,42.36 59.74,42.36 59.45,42.64 54.38,42.64 53.68,43.34 51.38,43.34 50.92,42.88 44.91,42.88 43.01,40.98 37.09,40.98 36.02,39.91 34.19,39.91 33.93,39.65 32.9,39.65 32.04,38.79 26.79,38.79 25.46,37.45 24.86,37.45 22.67,39.63 21.56,39.63 v2(20.7,40.5)
  GND5 w0.086: v4(66.24,81.87) 66.17,81.87 66.08,81.96 v5(66.08,82.64) ; v4(30.07,77.89) 30.14,77.96 v5(30.14,78.6)
  BOTTOM w0.086: PR1273.1 v5(66.08,82.64)
AC1_DISC#_R: length 2.1
  BOTTOM w0.086: RT72.1 31.22,76.6 UT5.G11
AC2_DISC#: length 119.7
  TOP w0.086: v2(66.62,35.37) v1(67.02,35.77) 67.3,36.05 PR941.1
  IN2 w0.061: v4(72.84,55.08) 72.84,54.47 74.1,53.2 74.1,45.81 73.21,44.91 70.78,44.91 69.3,46.39 66.25,46.39 62.35,42.49 62.35,41.11 63.16,40.29 64.74,40.29 66.62,38.41 v2(66.62,35.37) 66.54,35.29 65.4,35.29 62.68,32.57 59.32,32.57 58.04,31.29 49.59,31.29 48.35,32.53 39.22,32.53 34.71,37.04 34.71,41.66 35.94,42.88 v4(36.34,42.88)
  IN4 w0.051: v4(72.84,55.08) 73.4,55.08 74.14,55.81 74.14,67.48 70.65,70.96 70.65,73.75 69.59,74.81 69.59,80.86 70.29,81.57 71.26,81.57 71.42,81.42 75.3,81.42 75.58,81.7 76.88,81.7 77.23,81.34 v4(77.23,81.29)
  GND5 w0.086: v5(77.23,81.95) v4(77.23,81.29) ; v4(36.34,42.88) 36.52,43.06 v5(36.52,43.39)
  BOTTOM w0.086: v5(77.23,81.95) 77.11,82.08 77.11,84.16 76.37,84.9 PR1274.1
AC2_DISC#_R: length 4.9
  BOTTOM w0.086: UT11.G11 31.3,44.55 31.83,44.55 32.12,44.26 34.74,44.26 RT168.1
AC_DIS: length 272.2
  TOP w0.086: v2(266.87,50) 266.95,49.92 266.95,49.23 268,48.18 268,47.27 RE83.1 ; v1(47.82,30.13) 48.99,31.3 PR927.1 49.31,31.57 PQ909.2 50.82,31.57 51.03,31.78 v3(52.21,31.78) ; UE1.H12 267.79,58.61 v2(267.76,58.61)
  GND1 w0.086: v3(52.21,31.78) 52.48,31.78 v4(52.74,32.04)
  IN3 w0.061: v2(266.87,50) 266.85,50 263.01,46.15 263.01,44.77 261.02,42.77 261.02,40.54 259.99,39.52 259.99,35.57 260.13,35.42 260.13,29.01 258.89,27.77 243.78,27.77 243.57,27.99 240.73,27.99 240.2,27.46 240.2,27.41 238.82,26.03 231.41,26.03 230.67,26.77 227.39,26.77 226.94,26.32 202.59,26.32 202.54,26.37 181.42,26.37 179.39,28.4 176.34,28.4 175.85,27.91 170.9,27.91 170.23,27.25 168.12,27.25 167.73,27.64 163.98,27.64 162.78,28.84 159.68,28.84 158.1,30.42 144.17,30.42 143.02,29.27 116.42,29.27 115.56,28.4 112.21,28.4 109.31,31.31 95.04,31.31 93.99,32.35 91.73,32.35 88.73,35.35 88.73,37.75 87.24,39.24 87.24,40.95 84.92,43.27 73.96,43.27 73.42,43.81 71.01,43.81 68.38,41.18 68.38,36.85 67.45,35.92 66.54,35.92 63.03,32.42 58.65,32.42 58.08,31.85 52.93,31.85 v4(52.74,32.04)
  IN4 w0.051: v2(266.87,50) 267.75,50.88 267.75,52.15 267.97,52.37 267.97,54.72 268.13,54.87 268.13,58.19 267.76,58.55 v2(267.76,58.61)
AC_DISC#: length 387
  TOP w0.086: UE1.E13 269.1,61.3 270.32,61.3 271.16,60.46 271.49,60.46 v3(271.52,60.44) ; v3(35.07,41.94) 35.07,41.66 PR1243.2 ; PR1210.2 61.22,78.84 60.52,79.53 v1(60.52,80.13) 60.52,80.76 60.99,81.23 60.99,81.63 61.31,81.95 64.85,81.95 65.18,82.28 68.16,82.28 68.47,82.58 68.47,83.35 68.19,83.63 67.29,83.63 v3(67.28,83.62)
  GND1 w0.086: v4(35.53,41.81) 35.53,41.85 35.44,41.94 v3(35.07,41.94) ; v3(67.28,83.62) 67.23,83.62 67.23,83.65 67.11,83.65 v4(66.88,83.89)
  GND1 w0.117: v3(271.52,60.44) 272.18,60.44 v4(272.31,60.56)
  IN1 w0.051: v4(266.34,43.11) 266.42,43.19 267.84,43.19 269.13,44.49 269.13,45.58 268.67,46.03 268.67,46.73 269.81,47.86 269.81,50.18 270.73,51.11 270.73,52 273.45,54.72 273.45,58.63 272.31,59.78 v4(272.31,60.56) ; v4(55.36,32.39) 55.36,33.52 57.28,35.44 57.28,37.73 60.81,41.26 63.09,41.26 66,44.18 66,46.3 66.92,47.21 70.59,47.21 72.46,49.09 72.46,55.34 v4(72.91,55.79)
  IN2 w0.061: v4(35.53,41.81) 35.53,41.77 34.94,41.17 34.94,37.08 39.26,32.75 52.41,32.75 52.65,32.52 54.28,32.52 54.62,32.86 55.03,32.86 55.36,32.52 v4(55.36,32.39)
  IN4 w0.051: v4(55.36,32.39) 56.02,33.05 62.98,33.05 63.8,33.87 69.44,33.87 70.07,33.23 70.07,32.04 71.95,30.16 91.83,30.16 92.64,29.35 105.65,29.35 106.66,28.33 115.32,28.33 116.18,29.19 140.82,29.19 141.51,28.51 147.64,28.51 148.32,29.19 157.54,29.19 159.06,27.68 160.54,27.68 162,26.22 171.02,26.22 172,27.2 172,27.69 172.49,28.19 173.67,28.19 176.65,25.21 179.23,25.21 179.39,25.37 242.44,25.37 243.19,26.11 254.18,26.11 254.95,25.35 257.31,25.35 261.43,29.47 261.43,30.78 261.89,31.24 261.89,33.33 261.66,33.56 261.66,34.38 262.27,34.99 262.27,36.54 261.31,37.51 261.31,38.64 261.92,39.25 261.92,40.14 264.89,43.11 v4(266.34,43.11) ; v4(72.91,55.79) 73.52,56.4 73.52,67.64 67.41,73.75 66.34,73.75 65.79,74.3 65.79,82.8 v4(66.88,83.89)
  GND5 w0.086: v5(67.63,83.79) 67.49,83.93 66.92,83.93 v4(66.88,83.89) 66.83,83.89 v5(66.32,84.39)
  BOTTOM w0.086: PR1292.1 PR1291.1 72.32,87.62 72.32,87.36 72.19,87.24 PQ1222.3 72.19,85.88 71.77,85.45 70.74,85.45 70.42,85.13 70.42,84.74 69.76,84.08 69.76,83.57 69.66,83.47 67.96,83.47 v5(67.63,83.79) ; PC1285.2 64.03,84.51 PQ1221.6 64.25,85.73 64.66,86.14 65.4,86.14 65.55,86.29 PQ1221.3 65.97,86.63 66.34,86.27 66.34,84.41 v5(66.32,84.39)
AC_PRESENT: length 162.8
  TOP w0.086: UE1.K8 v2(265.36,57.04)
  IN3 w0.061: v4(255.06,47.89) 255.51,47.89 257.46,49.84 257.46,51.49 258.18,52.21 259.49,52.21 261.21,53.92 262.02,53.92 263.39,55.29 263.39,55.67 263.59,55.87 263.97,55.87 265.13,57.04 v2(265.36,57.04)
  IN4 w0.051: v4(255.06,47.89) 253.51,46.34 253.51,43.82 254.32,43.01 254.32,39.67 254.89,39.1 254.89,31.62 253.28,30.01 252.45,30.01 251.93,29.49 237.05,29.49 235.82,30.72 232.15,30.72 231.67,30.23 225.56,30.23 224.71,31.08 219.4,31.08 219.01,30.69 213.8,30.69 211.47,28.37 207.28,28.37 206.32,29.33 205.73,29.33 205.05,30.01 195.66,30.01 195.55,29.9 194.96,29.9 194.89,29.98 187.98,29.98 187.22,30.74 180.17,30.74 179.7,31.21 178.53,31.21 177.54,32.2 173.64,32.2 170.46,35.38 170.14,35.38 168.14,37.38 168.14,38.77 167.38,39.53 166.55,39.53 165.14,40.95 165.14,43.7 164.51,44.33 163.65,44.33 161.98,46 159.64,46 158.83,46.81 158.72,46.81 156.53,49 156.53,49.78 156.3,50.01 156.17,50.01 v4(155.11,51.06)
  GND5 w0.086: v5(153.97,51.19) 153.99,51.22 154.8,51.22 154.96,51.06 v4(155.11,51.06)
  BOTTOM w0.076: UC1.AY15 147.48,59.9 147.43,59.82 147.27,59.54 147.27,59.26 147.16,59.15 147.16,57.29 147.97,56.47 147.97,56.16 148.86,55.28
  BOTTOM w0.086: 148.86,55.28 149.22,54.92 149.22,54.08 v1(149.66,53.64) 149.66,53.19 150.56,52.28 151.86,52.28 152.39,51.75 153.43,51.75 RC243.1 v5(153.97,51.19)
ACAV_IN: length 247.3
  TOP w0.086: v6(71.32,32.13) 70.67,32.13 v2(70.48,32.32) ; v2(264.58,62.58) 264.58,62.62 UE1.C7
  TOP w0.117: PR953.1 v3(63.16,33.79)
  GND1 w0.117: v3(63.16,33.79) 63.11,33.79 62.76,33.44 v4(62.6,33.44)
  IN1 w0.051: v4(171.46,27.3) 171.86,27.3 173.47,28.91 176.22,28.91 176.51,28.62 179.91,28.62 181.28,27.25 195.03,27.25 195.63,26.65 228.57,26.65 229.67,27.75 233.42,27.75 234.44,26.72 241.92,26.72 242.66,27.47 250.37,27.47 250.87,26.96 253.49,26.96 254.77,28.25 254.77,29.06 257.29,31.57 257.29,34.22 258.79,35.72 258.79,40.79 260.72,42.72 260.72,44.59 261.84,45.71 262.55,45.71 263.28,46.44 263.41,46.44 265.98,49.01 265.98,51.48 266.83,52.33 266.83,53.63 268.19,55 268.19,59.05 266.92,60.32 265.47,60.32 264.6,61.2 264.6,62.57 v2(264.58,62.58)
  IN4 w0.051: v4(62.6,33.44) 63.11,33.44 63.7,34.02 69.37,34.02 69.5,34.02 70.48,33.04 v2(70.48,32.32) 70.48,31.85 72.01,30.31 91.89,30.31 92.7,29.5 105.71,29.5 106.73,28.48 115.26,28.48 116.12,29.35 140.89,29.35 141.57,28.66 147.58,28.66 148.26,29.35 157.6,29.35 159.08,27.87 160.6,27.87 162.08,26.39 170.55,26.39 v4(171.46,27.3)
ACAV_IN1: length 22.1
  TOP w0.086: v1(52.49,29.55) 52.1,29.94 PQ909.1
  TOP w0.127: v3(54.19,32.16) PR928.1 54.13,31.33 53.59,30.78 53.59,30.69 PR925.1 53.26,30.39 52.72,30.92 PQ909.1
  TOP w0.254: v2(64.43,39.33) 64.43,39.76 64.89,40.22 PR942.1
  GND1 w0.254: v4(54.78,32.47) 54.47,32.16 v3(54.19,32.16)
  IN2 w0.254: v2(64.43,39.33) 64.43,36.28 61.13,32.98 59.32,32.98 58.18,31.84 55.16,31.84 54.78,32.22 v4(54.78,32.47)
ACC1_I2C0_SCL: length 2.4
  BOTTOM w0.086: RZ137.2 235.36,58.48 234.29,57.4 JSEN2.3
ACC1_I2C0_SDA: length 2.5
  BOTTOM w0.086: JSEN2.5 234.54,59 RZ140.2
ACC1_INT1: length 3
  BOTTOM w0.086: RZ143.2 235.32,61.69 235.32,60.99 234.93,60.6 JSEN2.7
ACC1_SA0: length 3.9
  TOP w0.086: LGA1.3 272.39,88.1 271.96,87.68 RZ121.2 RZ122.1 v1(270.06,86.47)
ACIN_ISL9538: length 16.7
  TOP w0.203: PU901.19 v3(54.94,33.77)
  TOP w0.254: v2(49.76,40.31) 49.76,41.07 50.17,41.47 50.17,41.72 50.42,41.97 v1(51.58,41.97) 51.99,41.97 52.62,42.61 PR944.2 52.63,43.01 PR945.1 PC955.1
  GND1 w0.254: v3(54.94,33.77) v4(54.94,34.27)
  GND5 w0.254: v5(54.31,34.44) 54.32,34.45 54.76,34.45 v4(54.94,34.27)
  BOTTOM w0.254: v5(54.31,34.44) 53.66,35.09 52.93,35.09 50.18,37.83 50.18,39.89 v2(49.76,40.31)
ACOK_ISL9538: length 9.5
  TOP w0.203: PR928.2 55.01,29.6 56.53,29.6 v1(56.81,29.88) 58.43,31.5 58.43,33.38 58.07,33.74 57.19,33.74 56.94,34 PU901.24
ADP_ISL9538: length 13.9
  TOP w0.203: PU901.16 53.21,35.14 53,34.93 53,34.71
  TOP w0.254: v2(52.82,33.71) 53,33.89 53,34.71 ; v2(49.65,39.59) 49.24,40 v1(49.24,40.7) 49.24,41.22 49.78,41.75 49.78,41.91 50.87,43 PR943.2
  BOTTOM w0.254: v2(52.82,33.71) 52.82,34.53 49.65,37.7 v2(49.65,39.59)
ALS_I2C0_SCL: length 18.3
  TOP w0.086: QZ14.1 v2(226.85,47.32)
  BOTTOM w0.086: v2(226.85,47.32) 226.86,47.34 226.86,49.74 227.42,50.3 228.8,50.3 229.13,50.63 229.13,53.7 233.62,58.2 JSEN2.4 234.69,58.2 RZ138.2
ALS_I2C0_SDA: length 14.9
  TOP w0.086: QZ14.4 228.15,50.99 v2(228.31,51.14)
  BOTTOM w0.086: RZ141.2 235.92,61.29 234.43,59.8 JSEN2.6 233.49,59.8 228.62,54.93 228.62,51.46 v2(228.31,51.14)
ALS_INT#: length 2.4
  BOTTOM w0.086: RZ145.2 235.63,63.33 234.5,62.2 JSEN2.9
ALW_PWRGD_3V_5V: length 181.4
  TOP w0.086: v3(65.81,76.03) 65.47,75.68 64.04,75.68 v1(63.67,76.06) 63.14,76.59 62.68,76.59 62.54,76.73 PR119.2 ; v3(164.34,31.64) 164.95,32.26 164.95,32.43 165.22,32.7 165.63,32.7 166.36,33.44 166.36,36.04 168.48,38.16 168.48,39.13 169.02,39.67 169.02,42.12 DC2.1 169.02,43.47 169.02,43.85 166.37,46.49 v3(165.13,46.49)
  GND1 w0.086: v3(65.81,76.03) 66.11,76.03 66.48,75.66 v4(66.48,75.48) ; v3(165.13,46.49) 165.13,46.41 v4(164.67,45.95) ; v3(164.34,31.64) 164.28,31.64 164.28,31.65 v4(163.85,31.65)
  IN1 w0.051: v2(53.36,75.73) 53.64,76.01 53.64,77.33 54.45,78.14 58.77,78.14 59.43,77.48 61.3,77.48 62.57,78.75 65.17,78.75 65.91,78.02 65.91,76.05 v4(66.48,75.48) 66.97,74.98 66.97,73.92 65.75,72.7 65.75,70.43 66.62,69.57 66.62,64.24 77.18,53.68 77.18,48.29 79.65,45.83 83.71,45.83 85.16,44.38 86.71,44.38 87.22,43.87 87.22,42.45 87.8,41.86 87.8,39.87 88.46,39.22 88.46,38.66 89.3,37.82 89.3,35.33 91.43,33.2 95.29,33.2 96.11,32.38 107.56,32.38 109.94,30.01 126.87,30.01 127.87,31 127.87,31.52 128.78,32.43 158.53,32.43 159.39,33.29 162.88,33.29 163.58,32.58 163.58,31.91 v4(163.85,31.65)
  GND5 w0.086: v5(164.43,45.53) 164.43,45.71 v4(164.67,45.95)
  BOTTOM w0.086: v2(53.36,75.73) 53.36,75.15 PR120.2 ; v5(164.43,45.53) 164.43,45.6 163.87,46.16 163.1,46.16 162.82,45.88 UZ6.2
ALWON: length 240.7
  TOP w0.086: v2(262.43,65.24) 262.43,65.21 262.59,65.05 UE1.A5
  IN1 w0.051: v2(79.8,46.36) 80.13,46.69 83.06,46.69 85.22,44.54 86.95,44.54 88.63,42.86 88.63,38.73 89.47,37.89 89.47,35.4 91.45,33.42 95.31,33.42 96.18,32.56 107.63,32.56 110.03,30.16 126.78,30.16 127.7,31.07 127.7,31.59 128.71,32.6 158.46,32.6 159.3,33.44 163.77,33.44 163.95,33.61 166.44,33.61 168.08,31.98 168.08,31.15 168.08,31.15 168.08,31.02 169.54,29.56 171.6,29.56 173.15,31.11 180.58,31.11 182.77,28.93 195.73,28.93 195.9,28.75 199.84,28.75 200.6,29.5 206.75,29.5 207.93,28.32 219.28,28.32 219.87,28.91 219.97,28.91 226.29,28.91 227.18,29.8 230.45,29.8 230.67,29.58 250.46,29.58 255.12,34.24 255.12,39.29 255.95,40.12 255.95,47.07 256.89,48 256.89,53.68 256.38,54.19 256.38,58.7 257.75,60.07 257.75,61.5 256.98,62.27 255.9,62.27 v4(255.64,62.01)
  IN3 w0.061: v4(255.64,62.01) 255.64,62.75 255.47,62.92 255.47,64.17 256.27,64.98 258.68,64.98 259.19,64.48 260.27,64.48 260.39,64.6 261.79,64.6 v2(262.43,65.24)
  BOTTOM w0.086: v2(79.8,46.36) 78.73,47.43 PR114.1 78.73,47.52 78.22,48.03 77.56,48.03 v1(77.26,48.33)
