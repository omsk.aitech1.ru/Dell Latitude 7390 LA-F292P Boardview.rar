# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKRUN#: length 18.4
  BOTTOM w0.076: UC1.AW11 150.31,60.16 150.31,57.71 150.71,57.31 151.52,57.31
  BOTTOM w0.086: 151.52,57.31 153.62,55.21 158.47,55.21 v1(158.86,54.82) 160.63,53.04 163.42,53.04 RC27.1
CMOUT: length 17
  IN3 w0.061: v4(71.32,83.57) 70.92,83.98 69.31,83.98 66.58,81.24 64.71,81.24 64.05,81.9 63.42,81.9 62.78,82.53 v4(62.78,82.58)
  GND5 w0.086: v5(71.71,83.85) 71.71,83.83 71.46,83.57 v4(71.32,83.57) ; v4(62.78,82.58) 62.86,82.66 v5(62.86,83.4)
  BOTTOM w0.086: PQ1228.2 61.81,85.81 61.7,85.7 v1(61.7,85.24) 61.7,84.56 62.86,83.4 v5(62.86,83.4) ; v5(71.71,83.85) 71.54,84.02 PQ1222.5 PQ1222.6
COMP_GT: length 3.3
  TOP w0.203: v2(76.14,76.59) 75.81,76.59 75.71,76.49 PC636.2
  BOTTOM w0.203: PU602.16 75.73,76.33 75.99,76.59 v2(76.14,76.59) 76.14,76.62 76.74,77.21 PR639.2
COMP_ISL9538: length 4.7
  TOP w0.203: PU901.28 59.17,36.34 PR934.1
  TOP w0.508: PR934.1 59.36,36.53 PC943.1
COMP_VSA: length 2.6
  TOP w0.203: PR630.1 73.05,72.99 v2(73.12,73.06) 73.07,73.11 PC628.1
  BOTTOM w0.203: v2(73.12,73.06) 73.05,73.13 73.05,73.21 72.89,73.37 PU602.24
CONTACTLESS_DET#: length 85.2
  TOP w0.086: v3(163.14,66.15) 162.9,66.38 RC278.1 ; DZ8.2 189.59,32.83 v2(189.65,32.76) ; v2(150.5,70.59) 150.05,70.14 v1(149.57,70.14)
  GND1 w0.086: v4(162.67,66.03) 162.79,66.15 v3(163.14,66.15)
  IN1 w0.051: v2(150.5,70.59) 151.71,70.59 152.62,69.68 156.84,69.68 157.52,69 160.16,69 160.57,68.59 160.57,67.78 161.92,66.43 162.22,66.43 162.62,66.03 v4(162.67,66.03)
  IN2 w0.061: v2(150.5,70.59) 150.09,71 149.09,71 148.86,70.77 148.86,70.23 148.62,69.99 148.62,69.41 148.77,69.26 148.77,68.55 148.42,68.21 148.42,66 148.9,65.53 148.9,63.32 150.24,61.97 150.24,60.97 158.47,52.74 158.47,51.17 161.16,48.49 161.16,47.79 163.5,45.45 163.5,44.89 164.46,43.93 164.56,43.93 165.3,43.19 165.3,42.65 168.83,39.12 169.92,39.12 172.81,36.24 175.21,36.24 177.47,33.97 181.46,33.97 181.84,33.6 188.97,33.6 189.61,32.95 189.61,32.8 v2(189.65,32.76)
  BOTTOM w0.086: v2(150.5,70.59) 150.15,70.94 UC1.W11
CONTACTLESS_DET#_R: length 4.2
  TOP w0.086: v2(190.35,32.76) 191.09,33.5 DZ8.1
  BOTTOM w0.086: JUSH1.23 190.75,33.57 190.29,33.11 190.29,32.83 v2(190.35,32.76)
CORE_VID0: length 31.7
  TOP w0.086: v3(166.87,41.56) 167.23,41.21 PR408.1
  GND1 w0.086: v3(166.87,41.56) 166.9,41.56 167.2,41.87 v4(167.2,41.94)
  IN1 w0.051: v4(167.2,41.94) 166.77,42.38 165.76,42.38 162.42,45.72 162.42,47.57 161.8,48.18 161.79,48.18 161.48,48.5 161.48,48.5 156.68,53.3 156.68,55.33 156.69,55.58 150.51,61.76 150.51,63.78 v2(150.27,64.02)
  BOTTOM w0.086: UC1.AN11 150.21,64.02 v2(150.27,64.02)
CORE_VID1: length 31.3
  TOP w0.086: v3(165.55,42.71) 165.52,42.68 PR411.1
  GND1 w0.086: v4(166.08,42.76) 165.6,42.76 v3(165.55,42.71)
  IN1 w0.051: v4(166.08,42.76) 165.59,42.76 162.57,45.78 162.57,47.63 161.86,48.34 161.86,48.34 161.63,48.56 161.63,48.56 156.84,53.36 156.84,55.27 156.84,55.65 150.65,61.83 150.65,64.19 150.47,64.37 149.68,64.37 v4(149.37,64.69)
  GND5 w0.086: v5(148.9,64.41) 149.09,64.41 v4(149.37,64.69)
CPU_B+: length 17.8
  TOP w0.254: PR603.2 66.57,71.71 v2(67.23,71.05)
  IN3 w0.254: v2(79.52,63.36) 76.67,63.36 68.98,71.05 v2(67.23,71.05)
  vias: v2(79.52,62.67) v2(80.1,63.36) v2(80.1,62.67) v2(80.71,63.36) v2(80.73,62.67) v2(81.23,76.44) v2(81.25,75.78) v2(81.84,76.44) v2(81.86,75.75) v2(84.39,65.93) v2(84.39,65.26) v2(85.6,65.93) v2(85.6,65.26) v2(89.3,78.48) v2(89.3,77.9) v2(89.3,77.31) v2(89.49,75.5) v2(89.49,74.29) v2(90.16,75.5) v2(90.16,74.29) v6(88.98,79.83)
CPU_DP1_AUXN: length 116.1
  TOP w0.088: v2(41.93,68.08) 41.73,67.87 41.13,67.87 40.94,67.68 40.94,63.4 41.72,62.62 41.72,58.43 41.64,58.35 40.81,58.35 40.41,57.95 40.41,57.48 40.32,57.39 40.13,57.39 CT19.1
  IN2 w0.083: v2(41.93,68.08) 41.75,68.26 41.62,68.26 41.53,68.18 41.53,67.76 41.45,67.68 41.31,67.68 41.23,67.76 41.23,69.38 41.62,69.77 42.13,69.77 42.52,70.16 42.52,72.51 45.89,75.87 48.08,75.87 52.24,80.04 58.93,80.04 60.78,81.89 64.6,81.89 65.04,82.33 67.15,82.33 68.85,84.03 77.66,84.03 78.79,82.9 94.76,82.9 97.88,86.02 110.87,86.02 114.27,82.63 115.03,82.63 115.31,82.35 122.16,82.35 123.25,81.26 124.31,81.26 126.86,78.7 126.86,78.01 127.05,77.82 127.2,77.82 v2(127.41,77.61)
  BOTTOM w0.076: v2(127.41,77.61) 127.42,77.55 UC1.G50
CPU_DP1_AUXN_C: length 5.1
  TOP w0.088: v2(35.96,58.94) 36.39,59.37 37.1,59.37 37.38,59.1 37.38,58.56 37.74,58.2 37.79,58.2 38.16,57.82 38.16,57.77 38.35,57.59 CT19.2
  BOTTOM w0.076: v2(35.96,58.94) 35.96,58.97 36.25,59.25 UT1.W11
CPU_DP1_AUXP: length 116.1
  TOP w0.088: CT18.1 40.13,57.22 40.4,57.22 40.59,57.41 40.59,57.87 40.89,58.17 41.71,58.17 41.9,58.36 41.9,62.69 41.11,63.47 41.11,67.61 41.2,67.7 41.72,67.7 v2(41.93,67.49)
  IN2 w0.083: v2(127.41,78.2) 127.21,78 127.13,78 127.04,78.08 127.04,78.78 124.38,81.44 123.33,81.44 122.24,82.53 115.38,82.53 115.1,82.81 114.34,82.81 110.95,86.21 97.81,86.21 94.68,83.08 78.87,83.08 77.73,84.22 68.77,84.22 67.07,82.51 64.96,82.51 64.53,82.08 60.7,82.08 58.85,80.22 52.17,80.22 48,76.06 45.81,76.06 42.34,72.59 42.34,70.24 42.05,69.95 41.54,69.95 41.04,69.45 41.04,67.68 41.23,67.49 v2(41.93,67.49)
  BOTTOM w0.076: UC1.F50 v2(127.41,78.2)
CPU_DP1_AUXP_C: length 5.1
  TOP w0.088: CT18.2 39.13,56.8 38.96,56.8 38.88,56.87 38.88,57.35 38.81,57.42 38.27,57.42 v7(37.87,57.82) 37.21,58.49 37.21,59.02 37.03,59.2 36.7,59.2 36.61,59.11 v2(36.61,58.94)
  BOTTOM w0.076: UT1.Y11 36.89,59.25 36.61,58.97 v2(36.61,58.94)
CPU_DP1_CTRL_CLK: length 169.4
  TOP w0.086: RC175.1 157.17,72.85 158.25,72.85 158.34,72.93 158.34,73.14 v2(158.11,73.37) ; RT341.1 38.5,63.4 38.27,63.63 38.27,63.74 39.69,65.16 39.69,67.93 40.91,69.15 40.91,72.05 40.49,72.48 v3(40.17,72.48)
  GND1 w0.086: v3(40.17,72.48) 40.1,72.48 40.04,72.54 39.36,72.54 v4(39.34,72.56)
  IN1 w0.051: v2(158.11,73.37) 157.49,73.99 154.18,73.99 153.84,74.33 149.16,74.33 v2(148.6,74.89)
  IN3 w0.061: v2(158.11,73.37) 158.11,73.48 160.95,76.32 160.95,80.24 157.62,83.57 157.62,83.57 156.8,84.39 146.93,84.39 146.25,85.07 142.21,85.07 141.69,84.55 139.89,84.55 139.61,84.84 130.47,84.84 128.89,86.42 125.03,86.42 124.86,86.59 105.18,86.59 103.45,84.86 78.99,84.86 76.66,87.19 71.27,87.19 70.76,86.68 69.89,86.68 66.92,86.68 65.48,85.24 61.33,85.24 59.11,83.03 44.53,83.03 42.51,81 41.32,81 39.4,79.08 39.4,76.59 39.21,76.4 39.21,72.68 39.33,72.56 v4(39.34,72.56)
  BOTTOM w0.086: UC1.L13 148.85,75.14 v2(148.6,74.89)
CPU_DP1_CTRL_DATA: length 173.1
  TOP w0.086: RC178.1 157.15,72.67 158.34,72.67 158.51,72.85 158.51,73.19 v2(158.69,73.37) ; v2(35.4,70.75) 35.48,70.67 35.91,70.67 36.09,70.49 36.09,68.89 35.7,68.51 35.37,68.51 34.91,68.05 33.44,68.05 33.06,67.67 v6(33.06,67.14) RT342.1
  IN1 w0.051: v2(149.24,74.91) 149.68,74.47 153.9,74.47 154.24,74.13 157.93,74.13 v2(158.69,73.37) ; v4(34.17,75.12) 33.9,74.85 33.9,71.74 34.38,71.26 34.89,71.26 v2(35.4,70.75)
  IN3 w0.061: v4(34.17,75.12) 34.27,75.22 37.59,75.22 39.08,76.72 39.08,79.21 41.19,81.32 42.38,81.32 44.4,83.34 58.98,83.34 61.2,85.56 65.35,85.56 66.79,87 70.03,87 70.63,87 71.14,87.51 76.79,87.51 79.12,85.17 103.32,85.17 105.05,86.9 124.99,86.9 125.16,86.73 129.02,86.73 130.6,85.15 139.74,85.15 140.02,84.87 141.56,84.87 142.08,85.39 146.38,85.39 147.06,84.71 156.93,84.71 157.75,83.88 157.75,83.88 161.26,80.37 161.26,76.19 158.69,73.62 v2(158.69,73.37)
  BOTTOM w0.086: v2(149.24,74.91) 149.5,75.18 UC1.L12
CPU_DP1_HPD: length 144.5
  TOP w0.086: v2(41.83,64.32) v1(41.83,63.81)
  IN3 w0.061: v4(151.99,76.31) 151.99,76.34 152.09,76.44 152.09,77.56 152.44,77.91 152.44,79.21 152.06,79.59 150.19,79.59 147.26,82.52 139.2,82.52 138.79,82.92 132.89,82.92 130.91,80.95 127.67,80.95 126.12,82.51 120.02,82.51 119.55,82.98 118.18,82.98 117.63,82.43 112.18,82.43 110.53,84.08 105.61,84.08 104.39,82.86 78.41,82.86 76.56,84.7 69.24,84.7 67.31,82.77 64.79,82.77 64.49,83.07 62.04,83.07 59.07,80.1 50.41,80.1 50.07,80.44 44.55,80.44 42.74,78.62 42.74,77.92 43.41,77.25 43.41,67.08 41.42,65.08 41.42,64.73 v2(41.83,64.32)
  GND5 w0.086: v4(151.99,76.31) 151.96,76.28 151.96,75.9 151.45,75.4 v5(151.45,75.35)
  BOTTOM w0.076: UT1.AA2 37.17,63.22 37.41,63.46 37.41,63.89 37.53,64.02 37.69,64.02
  BOTTOM w0.086: 37.69,64.02 39.11,64.02 RT24.1 40.43,63.71 41.22,63.71 v2(41.83,64.32)
CPU_DP1_N0: length 106.5
  IN2 w0.083: v2(41.27,60.55) 41.38,60.45 41.56,60.45 41.67,60.56 41.67,60.88 41.74,60.95 41.99,60.95 42.54,61.49 42.54,66.18 43.13,66.78 43.13,72.31 46.11,75.29 48.3,75.29 52.48,79.47 59.16,79.47 60.98,81.28 67.46,81.28 69.11,82.93 71.44,82.93 71.77,82.61 74.92,82.61 75.25,82.93 77.94,82.93 78.55,82.32 95,82.32 98.12,85.45 109.34,85.45 112.8,81.98 114.83,81.98 115.7,81.11 117.36,81.11 117.9,80.57 123.63,80.57 125.11,79.09 125.11,78.61 125.02,78.52 124.83,78.52 124.67,78.68 v2(124.67,78.83)
  BOTTOM w0.076: v2(124.67,78.83) 124.65,78.83 UC1.E55
  BOTTOM w0.088: v2(41.27,60.55) 41.1,60.73 40.65,60.73 CT11.1
CPU_DP1_N0_C: length 2.5
  BOTTOM w0.076: 38.68,60.87 38.49,60.87 38.29,60.66 37.99,60.66 37.91,60.74 37.91,60.85 37.97,60.9 UT1.AC7
  BOTTOM w0.088: CT11.2 39.65,60.71 38.92,60.71 38.76,60.87 38.68,60.87
CPU_DP1_N1: length 99.8
  IN2 w0.083: v2(43.55,60.2) 43.74,60.01 43.88,60.01 44.71,60.85 44.71,71.61 46.83,73.73 48.92,73.73 52.69,77.5 60.06,77.5 60.14,77.43 60.83,77.43 61.99,78.6 65.06,78.6 66.15,79.69 68.06,79.69 69.13,80.76 70.68,80.76 70.83,80.91 75.45,80.91 75.57,80.79 95.63,80.79 98.26,83.42 109.14,83.42 111.03,81.53 111.03,81.06 113.37,78.72 115.09,78.72 115.49,78.33 117.1,78.33 117.68,78.91 121.23,78.91 121.79,78.35 122.08,78.35 122.32,78.6 122.61,78.6 v2(122.84,78.83)
  BOTTOM w0.076: UC1.E58 v2(122.84,78.83)
  BOTTOM w0.088: v2(43.55,60.2) 43.35,60 43.15,60 CT13.1
CPU_DP1_N1_C: length 5
  BOTTOM w0.076: 39.01,60.11 39,60.11 38.5,60.11 38.4,60.21 37.95,60.21 37.88,60.14 37.88,60.03 37.92,59.98 UT1.AC9
  BOTTOM w0.088: CT13.2 42.18,59.99 40.73,59.99 40.62,60.11 39.01,60.11
CPU_DP1_N2: length 107.6
  IN2 w0.083: v2(41.32,59.37) 41.53,59.16 41.79,59.16 41.99,59.36 41.99,60.34 43.55,61.9 43.55,72.15 46.29,74.89 48.45,74.89 52.64,79.08 59.32,79.08 60.11,79.87 64.69,79.87 65.68,80.86 67.61,80.86 69.23,82.48 71.34,82.48 71.7,82.12 75.06,82.12 75.42,82.48 77.82,82.48 78.36,81.94 95.16,81.94 97.81,84.59 109.63,84.59 112.62,81.59 114.62,81.59 115.61,80.6 117.23,80.6 117.75,80.08 123.37,80.08 124.31,79.14 124.31,77.88 124.48,77.71 124.81,77.71 125.1,78 125.4,78 v2(125.58,78.19)
  BOTTOM w0.076: UC1.F53 126.03,77.99 125.63,78.2 v2(125.58,78.19)
  BOTTOM w0.088: CT15.1 40.63,59.17 41.11,59.17 v2(41.32,59.37)
CPU_DP1_N2_C: length 2.5
  BOTTOM w0.076: 38.85,59.16 38.83,59.16 38.83,59.15 38.54,59.15 38.4,59.29 37.94,59.29 37.89,59.24 37.89,59.13 37.95,59.06 UT1.AC11
  BOTTOM w0.088: 38.85,59.16 39.64,59.16 CT15.2
CPU_DP1_N3: length 105.9
  IN2 w0.083: v2(123.76,78.19) 123.57,78 123.46,78 123.39,78.07 123.39,79.14 123.04,79.49 116.32,79.49 116.05,79.76 113.15,79.76 112.14,80.78 112.14,81.26 109.4,84.01 98.04,84.01 95.39,81.36 78.02,81.36 77.51,81.87 75.68,81.87 75.35,81.55 71.28,81.55 70.96,81.87 69.44,81.87 67.84,80.27 65.91,80.27 64.91,79.28 60.34,79.28 59.13,78.08 52.45,78.08 48.68,74.3 46.55,74.3 44.14,71.9 44.14,61.68 42.59,60.14 42.59,59.02 42.37,58.8 42.37,58.04 42.57,57.84 v2(43.55,57.84)
  BOTTOM w0.076: UC1.F56 123.92,78.1 v2(123.76,78.19)
  BOTTOM w0.088: CT17.1 43.16,58.05 43.35,58.05 v2(43.55,57.84)
CPU_DP1_N3_C: length 5
  BOTTOM w0.076: UT1.AC13 37.96,58.14 37.9,58.08 37.9,57.99 37.97,57.91 38.24,57.91 38.25,57.93 38.42,58.1 38.85,58.1 38.85,58.1 38.87,58.1
  BOTTOM w0.088: CT17.2 42.17,58.05 41.62,58.05 41.58,58.1 38.87,58.1
CPU_DP1_P0: length 106.6
  IN2 w0.083: v2(124.67,78.2) 124.8,78.33 125.1,78.33 125.3,78.53 125.3,79.17 123.71,80.76 117.98,80.76 117.44,81.29 115.78,81.29 114.9,82.17 112.88,82.17 109.41,85.63 98.04,85.63 94.92,82.51 78.63,82.51 78.02,83.12 75.17,83.12 74.85,82.79 71.84,82.79 71.52,83.12 69.03,83.12 67.38,81.47 60.9,81.47 59.09,79.65 52.41,79.65 48.23,75.47 46.04,75.47 42.95,72.39 42.95,66.86 42.35,66.26 42.35,61.57 41.92,61.14 41.27,61.14 v2(41.27,61.14)
  BOTTOM w0.076: v2(124.67,78.2) 124.66,78.2 UC1.F55
  BOTTOM w0.088: CT10.1 40.62,60.9 41.03,60.9 v2(41.27,61.14)
CPU_DP1_P0_C: length 2.5
  BOTTOM w0.076: UT1.AB7 37.85,61.13 38.4,61.13 38.5,61.03 38.61,61.03 38.61,61.03 38.66,61.03 38.66,61.04 38.68,61.04
  BOTTOM w0.088: CT10.2 39.65,60.88 38.99,60.88 38.83,61.04 38.68,61.04
CPU_DP1_P1: length 99.9
  IN2 w0.083: v2(122.84,78.19) 122.62,78.41 122.4,78.41 122.16,78.17 121.71,78.17 121.15,78.73 117.76,78.73 117.17,78.14 115.41,78.14 115.02,78.54 113.29,78.54 110.84,80.98 110.84,81.45 109.06,83.24 98.34,83.24 95.71,80.61 75.49,80.61 75.38,80.72 70.91,80.72 70.76,80.57 69.21,80.57 68.14,79.5 66.23,79.5 65.14,78.41 62.07,78.41 60.9,77.24 60.06,77.24 59.99,77.32 52.77,77.32 48.99,73.55 46.91,73.55 44.9,71.54 44.9,60.77 43.95,59.83 43.76,59.83 v2(43.55,59.61)
  BOTTOM w0.076: UC1.F58 v2(122.84,78.19)
  BOTTOM w0.088: v2(43.55,59.61) 43.34,59.83 43.17,59.83 CT12.1
CPU_DP1_P1_C: length 5.1
  BOTTOM w0.076: 38.85,59.94 38.83,59.94 38.83,59.94 38.48,59.94 38.3,59.75 37.86,59.75 UT1.AB9
  BOTTOM w0.088: CT12.2 42.18,59.82 40.66,59.82 40.55,59.94 38.85,59.94
CPU_DP1_P2: length 107.6
  IN2 w0.083: v2(125.58,77.61) 125.37,77.82 125.18,77.82 124.88,77.52 124.4,77.52 124.12,77.8 124.12,79.06 123.29,79.89 117.68,79.89 117.15,80.42 115.54,80.42 114.55,81.41 112.55,81.41 109.55,84.41 97.89,84.41 95.23,81.75 78.29,81.75 77.74,82.3 75.5,82.3 75.14,81.94 71.62,81.94 71.26,82.3 69.31,82.3 67.68,80.67 65.75,80.67 64.76,79.68 60.19,79.68 59.4,78.89 52.72,78.89 48.53,74.7 46.37,74.7 43.73,72.07 43.73,61.82 42.17,60.27 42.17,59.29 41.87,58.98 41.51,58.98 v2(41.32,58.79)
  BOTTOM w0.076: UC1.G53 v2(125.58,77.61)
  BOTTOM w0.088: v2(41.32,58.79) 41.11,58.99 40.63,58.99 CT14.1
CPU_DP1_P2_C: length 2.5
  BOTTOM w0.076: 38.85,58.98 38.83,58.98 38.83,58.99 38.45,58.99 38.3,58.83 37.86,58.83 UT1.AB11
  BOTTOM w0.088: 38.85,58.98 39.66,58.98 CT14.2
CPU_DP1_P3: length 106
  IN2 w0.083: v2(123.76,77.61) 123.55,77.82 123.38,77.82 123.21,77.99 123.21,79.06 122.96,79.31 116.24,79.31 115.97,79.58 113.08,79.58 111.96,80.7 111.96,81.19 109.32,83.82 98.11,83.82 95.47,81.18 77.94,81.18 77.44,81.69 75.75,81.69 75.43,81.37 71.21,81.37 70.88,81.69 69.51,81.69 67.91,80.09 65.98,80.09 64.99,79.1 60.41,79.1 59.21,77.89 52.53,77.89 48.76,74.12 46.63,74.12 44.33,71.82 44.33,61.61 42.78,60.06 42.78,58.95 42.56,58.73 42.56,58.11 42.64,58.03 42.87,58.03 42.96,58.11 42.96,58.51 43.14,58.69 43.29,58.69 v2(43.55,58.43)
  BOTTOM w0.076: UC1.G56 v2(123.76,77.61)
  BOTTOM w0.088: v2(43.55,58.43) 43.34,58.22 43.16,58.22 CT16.1
CPU_DP1_P3_C: length 5
  BOTTOM w0.076: UT1.AB13 37.76,58.28 37.85,58.37 38.4,58.37 38.5,58.26 38.85,58.26 38.85,58.27 38.87,58.27
  BOTTOM w0.088: 38.87,58.27 41.65,58.27 41.69,58.22 42.18,58.22 CT16.2
CPU_DP2_AUXN: length 141
  TOP w0.088: v2(112.46,92.05) 112.46,92.05 112.46,91.79 112.37,91.7 112.13,91.7 112.04,91.61 112.04,91.39 112.13,91.3 112.41,91.3 114.09,89.62 114.09,87.83 115.83,86.09 123.2,86.09 125.56,83.72 125.56,83.24 127.95,80.85 127.95,78.06 128.01,78 128.14,78 v2(128.33,78.19) ; CT184.1 39.95,55.36 40.28,55.68 40.38,55.68 40.46,55.6 40.46,54.93 40,54.47 38.65,54.47 38.29,54.83 37.19,54.83 37.1,54.92 37.1,55.18 37.03,55.25 36.9,55.25 36.79,55.15 v3(36.79,55.04)
  GND1 w0.088: v4(36.24,55.12) 36.44,54.91 36.61,54.91 36.74,55.04 v3(36.79,55.04)
  IN1 w0.062: v4(36.24,55.12) 36.32,55.04 36.94,55.04 37.1,55.2 37.1,70.07 36.93,70.25 36.93,76.87 38.63,78.58 38.63,79.16 41.05,81.57 42.31,81.57 42.67,81.93 42.67,83.21 45.29,85.83 48.07,85.83 50.01,87.77 50.01,87.77 50.36,88.12 55.56,88.12 57.37,89.93 63.1,89.93 63.33,90.16 80.18,90.16 80.69,90.67 87.71,90.67 88.91,89.46 92,89.46 95.76,93.23 111.95,93.23 112.22,92.95 112.22,92.28 v2(112.46,92.05)
  BOTTOM w0.076: v2(128.33,78.19) 128.72,78.54 UC1.E48
CPU_DP2_AUXN_C: length 5.7
  TOP w0.088: CT184.2 38.17,55.36 v7(37.41,56.11) 36.99,56.54 36.99,57.65 36.73,57.91 36.32,57.91 v2(35.95,58.28)
  BOTTOM w0.076: v2(35.95,58.28) 35.95,58.33 36.23,58.6 UT1.W12
CPU_DP2_AUXP: length 141
  TOP w0.088: CT178.1 40.01,55.85 40.46,55.85 40.63,55.68 40.63,54.86 40.07,54.29 38.58,54.29 38.22,54.66 v3(36.79,54.66) ; v2(111.87,92.05) 111.87,91.32 112.06,91.13 112.34,91.13 113.92,89.55 113.92,87.76 115.76,85.92 123.13,85.92 125.39,83.65 125.39,83.17 127.78,80.78 127.78,77.99 127.94,77.83 128.11,77.83 v2(128.33,77.61)
  GND1 w0.088: v3(36.79,54.66) 36.75,54.66 36.67,54.74 36.41,54.74 36.24,54.57 v4(36.24,54.53)
  IN1 w0.062: v4(36.24,54.53) 36.58,54.53 36.64,54.58 36.64,54.81 36.71,54.89 37,54.89 37.25,55.14 37.25,70.13 37.07,70.31 37.07,76.81 38.78,78.52 38.78,79.1 41.11,81.43 42.37,81.43 42.82,81.87 42.82,83.15 45.35,85.68 48.13,85.68 50.16,87.71 50.42,87.97 55.62,87.97 57.43,89.78 63.16,89.78 63.39,90.01 80.24,90.01 80.75,90.52 87.65,90.52 88.85,89.32 92.06,89.32 95.82,93.08 111.89,93.08 112.08,92.89 112.08,92.26 v2(111.87,92.05)
  BOTTOM w0.076: UC1.F48 128.78,77.9 128.43,77.6 v2(128.33,77.61)
CPU_DP2_AUXP_C: length 5.8
  TOP w0.088: v2(36.59,58.28) 36.61,58.28 37.16,57.72 37.16,56.61 37.24,56.52 37.29,56.52 37.75,56.07 37.75,56.02 38.24,55.53 38.7,55.53 38.79,55.62 38.79,56.13 38.87,56.22 39.06,56.22 CT178.2
  BOTTOM w0.076: v2(36.59,58.28) 36.64,58.28 36.93,58.56 UT1.Y12
CPU_DP2_CTRL_CLK: length 4.3
  TOP w0.086: RC176.1 154.5,74.66 154.23,74.66 154.04,74.47 154.04,73.64 153.89,73.49 152.89,73.49 152.77,73.61 152.77,73.7 153.01,73.94 v2(153.03,73.94)
  BOTTOM w0.086: UC1.N7 153.03,74.14 v2(153.03,73.94)
CPU_DP2_CTRL_DATA: length 4.5
  TOP w0.086: v2(152.42,73.92) 152.42,73.92 152.6,73.75 152.6,73.54 152.82,73.31 153.96,73.31 154.22,73.57 154.22,74.4 154.31,74.48 154.46,74.48 RC177.1
  BOTTOM w0.086: v2(152.42,73.92) 152.42,73.92 152.39,73.95 152.39,74.12 UC1.N8
CPU_DP2_HPD: length 149.7
  TOP w0.086: v2(36.62,60.88) 36.9,60.88 37.13,60.65 38.8,60.65 38.94,60.79 RT29.1
  IN3 w0.061: v4(152.49,75.99) 152.5,75.99 152.6,76.08 152.6,77.8 152.63,77.83 152.63,79.35 151.72,80.26 150.96,80.26 149.5,81.72 148.33,81.72 147.34,82.71 139.28,82.71 138.87,83.11 132.81,83.11 130.91,81.21 127.72,81.21 123.98,84.95 115.28,84.95 112.95,82.62 112.26,82.62 110.61,84.27 105.53,84.27 104.31,83.05 78.49,83.05 76.64,84.89 69.16,84.89 67.24,82.97 64.86,82.97 64.57,83.25 61.96,83.25 58.99,80.29 50.48,80.29 50.09,80.68 44.53,80.68 42.55,78.7 42.55,78.11 42.3,77.87 41.16,77.87 40.29,76.99 40.29,76.33 v4(40.48,76.14)
  IN4 w0.051: v2(36.62,60.88) 37.2,61.46 37.2,74.48 38.96,76.23 40.39,76.23 v4(40.48,76.14)
  GND5 w0.086: v4(152.49,75.99) 152.49,75.62 v5(152.77,75.35)
  BOTTOM w0.086: UT1.Y6 36.9,61.2 36.62,60.93 36.62,60.89 v2(36.62,60.88) ; UC1.L7 v5(152.77,75.35)
CPU_DP2_N0: length 132.1
  IN2 w0.083: v2(121.86,93.3) 122.08,93.08 122.08,92.76 121.66,92.34 115.1,92.34 114.11,93.34 96.62,93.34 92.24,88.96 88.03,88.96 84.87,92.12 78.79,92.12 78.48,91.81 65.68,91.81 65.11,91.25 60.93,91.25 59.91,90.23 59.25,90.23 56.24,87.22 48.39,87.22 47.03,85.86 45.77,85.86 45.55,85.64 45.55,85.31 v4(45.36,85.12)
  IN4 w0.062: v4(45.36,85.12) 45.34,85.1 45.34,84.82 45.43,84.73 45.6,84.73 45.66,84.67 45.66,83.28 45.64,83.25 45.64,74.78 43.34,72.49 43.34,62.04 41.72,60.42 41.72,57.39 41.66,57.32 41.57,57.32 v2(41.29,57.6)
  BOTTOM w0.076: 127.83,84.54 127.83,84.52 127.83,84.52 127.83,84.06 127.98,83.91 127.98,83.3 arc(128,83.05) 128.05,82.8 arc(128.09,82.57) 128.08,82.33 arc(128.04,81.93) 128.07,81.54 arc(128.1,81.31) 128.08,81.08 arc(128.07,80.93) 128.09,80.78 arc(128.1,80.65) 128.08,80.52 arc(128.06,80.32) 128.1,80.13 arc(128.13,79.96) 128.1,79.79 arc(128.04,79.72) 127.96,79.7 127.93,79.7 arc(127.79,79.78) 127.79,79.95 UC1.C50
  BOTTOM w0.088: v2(121.86,93.3) 122.07,93.09 122.07,92 127.83,86.24 127.83,84.54 ; CT187.1 40.62,57.4 41.09,57.4 v2(41.29,57.6)
CPU_DP2_N0_C: length 2.4
  BOTTOM w0.076: UT1.AC15 37.97,57.22 37.9,57.29 37.9,57.4 37.97,57.46 38.38,57.46 38.5,57.35 38.75,57.35 38.77,57.36 38.79,57.36
  BOTTOM w0.088: 38.79,57.36 39.62,57.36 CT187.2
CPU_DP2_N1: length 133.8
  IN2 w0.083: v4(46.75,86.27) 46.55,86.47 46.55,86.62 47.52,87.59 48.02,87.59 48.04,87.61 55.85,87.61 60.4,92.16 61.11,92.16 62.25,93.3 76.27,93.3 77.23,92.33 78.43,92.33 79.06,92.97 85.34,92.97 88.94,89.36 92.08,89.36 96.46,93.74 114.26,93.74 115.26,92.74 117.48,92.74 118.03,93.29 118.03,93.79 v2(118.21,93.96)
  IN4 w0.062: v4(46.75,86.27) 46.62,86.14 46.62,85.69 46.51,85.58 46.51,85.01 46.73,84.79 46.73,83.27 49.62,80.37 49.62,77.78 44.01,72.17 44.01,60.59 44.15,60.44 44.15,56.21 44.01,56.06 43.7,56.06 v2(43.55,55.91)
  BOTTOM w0.076: UC1.C52 126.72,79.79 arc(126.66,79.68) 126.53,79.69 126.43,79.76 arc(126.38,79.82) 126.36,79.89 arc(126.37,79.99) 126.4,80.08 arc(126.47,80.31) 126.45,80.55 arc(126.43,80.68) 126.45,80.81 arc(126.48,81) 126.44,81.19 arc(126.42,81.31) 126.45,81.44 126.5,81.55 arc(126.56,81.77) 126.52,82 arc(126.42,82.38) 126.39,82.77 126.39,82.88 125.96,83.31 125.96,83.65 125.97,83.65 125.97,83.67
  BOTTOM w0.088: CT180.1 43.04,55.81 43.29,56.06 43.42,56.06 43.55,55.93 v2(43.55,55.91) ; v2(118.21,93.96) 118.03,93.79 118.03,93.66 125.97,85.73 125.97,83.67
CPU_DP2_N1_C: length 5.2
  BOTTOM w0.076: 38.77,56.23 38.75,56.23 38.75,56.23 38.46,56.23 38.29,56.06 37.99,56.06 37.91,56.15 37.91,56.24 37.97,56.3 UT1.AC17
  BOTTOM w0.088: CT180.2 42.16,56.02 42,56.02 41.63,56.39 39.13,56.39 38.97,56.23 38.77,56.23
CPU_DP2_N2: length 140.5
  IN2 w0.083: v4(44.85,86.29) 45.07,86.51 45.07,86.87 46.54,88.35 47.71,88.35 47.76,88.4 55.57,88.4 59.66,92.49 59.66,93.18 60.57,94.09 77.26,94.09 77.56,93.79 85.59,93.79 89.25,90.13 91.74,90.13 96.11,94.5 114.6,94.5 115.56,93.53 115.88,93.53 115.94,93.58 115.94,93.78 v2(115.77,93.94)
  IN4 w0.062: v4(44.85,86.29) 44.85,85.71 44.55,85.41 44.55,82.98 44.99,82.54 44.99,75.44 42.82,73.27 42.82,68.97 42.35,68.51 42.35,63.41 41.1,62.16 40.05,62.16 38.99,61.11 38.99,55.04 39.29,54.75 40.84,54.75 41.09,55 41.09,55.53 41.15,55.6 41.27,55.6 v2(41.55,55.32)
  BOTTOM w0.076: UC1.A50 127.74,81.33 arc(127.67,81.34) 127.62,81.39 127.56,81.46 arc(127.51,81.54) 127.48,81.62 arc(127.45,81.76) 127.41,81.89 arc(127.37,82.01) 127.35,82.13 arc(127.34,82.25) 127.34,82.38 127.34,82.55 127.53,82.74 127.53,83.32 127.31,83.53 127.31,84.11 127.32,84.11 127.32,84.13
  BOTTOM w0.088: v2(115.77,93.94) 115.97,94.14 115.97,94.53 116.22,94.77 120.31,94.77 121.09,93.98 121.09,92.28 127.32,86.06 127.32,84.13 ; CT179.1 40.6,55.53 41.33,55.53 v2(41.55,55.32)
CPU_DP2_N2_C: length 2.5
  BOTTOM w0.076: UT1.AC19 37.97,55.38 37.91,55.33 37.91,55.2 37.97,55.15 38.24,55.15 38.45,55.35 38.75,55.35 38.75,55.35 38.77,55.35
  BOTTOM w0.088: 38.77,55.35 38.97,55.35 39.18,55.56 39.66,55.56 CT179.2
CPU_DP2_N3: length 145.5
  IN2 w0.083: v2(119.6,93.96) 119.82,94.19 119.82,94.81 119.71,94.92 95.97,94.92 91.58,90.53 89.4,90.53 85.69,94.24 77.72,94.24 77.44,94.52 60.26,94.52 59.12,93.38 59.12,92.51 55.42,88.81 47.62,88.81 47.55,88.74 45.75,88.74 44.19,87.18 44.19,86.76 43.88,86.45 43.88,86.27 43.77,86.17 v4(43.5,86.17)
  IN4 w0.062: v4(43.5,86.17) 43.72,86.38 43.9,86.38 43.97,86.31 43.97,82.8 44.48,82.29 44.48,75.65 43.71,74.89 40.52,74.89 38.48,72.85 38.48,54.05 39.04,53.49 39.04,53.14 39.19,52.99 40.93,52.99 41.08,53.14 41.08,53.3 41.24,53.46 41.33,53.46 v2(41.56,53.23)
  BOTTOM w0.076: UC1.D51 127,80.27 arc(126.99,80.29) 126.99,80.3 126.99,80.35 arc(126.99,80.35) 126.99,80.36 126.99,80.63 arc(126.97,80.73) 126.96,80.82 arc(126.96,81) 126.98,81.19 arc(126.97,81.4) 126.9,81.59 arc(126.8,81.8) 126.77,82.02 126.77,82.93 126.46,83.24 126.46,83.6 126.46,83.6 126.46,83.62
  BOTTOM w0.088: 126.46,83.62 126.46,85.82 119.8,92.48 119.8,93.76 v2(119.6,93.96) ; v2(41.56,53.23) 41.4,53.39 41.38,53.39 41.37,53.39 41.14,53.39 40.73,53.81 40.55,53.81 CT181.1
CPU_DP2_N3_C: length 2.6
  BOTTOM w0.076: UT1.AC21 37.96,54.46 37.9,54.4 37.9,54.31 37.97,54.23 38.3,54.23 38.47,54.41 38.6,54.41 38.6,54.4 38.62,54.4
  BOTTOM w0.088: CT181.2 39.57,53.81 39.33,53.81 38.74,54.4 38.62,54.4
CPU_DP2_P0: length 132.1
  IN2 w0.083: v2(122.44,93.3) 122.26,93.13 122.26,92.68 121.74,92.16 115.03,92.16 114.03,93.15 96.7,93.15 92.32,88.78 87.95,88.78 84.8,91.93 78.87,91.93 78.56,91.63 65.75,91.63 65.19,91.06 61,91.06 59.99,90.05 59.33,90.05 56.32,87.03 48.47,87.03 47.11,85.68 45.85,85.68 45.74,85.56 45.74,85.34 v4(45.95,85.12)
  IN4 w0.062: v2(41.29,57.02) 41.45,57.18 41.72,57.18 41.87,57.33 41.87,60.36 43.49,61.98 43.49,72.43 45.78,74.72 45.78,83.19 45.81,83.22 45.81,84.98 v4(45.95,85.12)
  BOTTOM w0.076: 128,84.54 128,84.53 128,84.52 128,84.47 127.99,84.47 127.99,84.12 128.14,83.97 128.14,83.3 arc(128.16,83.07) 128.21,82.85 arc(128.25,82.57) 128.23,82.3 arc(128.2,81.93) 128.23,81.57 arc(128.26,81.32) 128.24,81.06 arc(128.23,80.93) 128.24,80.81 arc(128.26,80.64) 128.23,80.47 arc(128.21,80.33) 128.25,80.19 arc(128.28,80.07) 128.29,79.95 arc(128.28,79.8) 128.22,79.67 128.21,79.66 arc(128.17,79.6) 128.12,79.54 arc(127.99,79.44) UC1.D50
  BOTTOM w0.088: v2(41.29,57.02) 41.08,57.23 40.64,57.23 CT186.1 ; v2(122.44,93.3) 122.24,93.1 122.24,92.07 128,86.31 128,84.54
CPU_DP2_P0_C: length 2.5
  BOTTOM w0.076: 38.83,57.19 38.82,57.19 38.49,57.19 38.31,57 37.85,57 UT1.AB15
  BOTTOM w0.088: CT186.2 39.67,57.19 38.83,57.19
CPU_DP2_P1: length 133.9
  IN2 w0.083: v4(46.17,86.27) 46.37,86.46 46.37,86.7 47.45,87.78 47.95,87.78 47.96,87.79 55.77,87.79 60.32,92.34 61.04,92.34 62.17,93.48 76.34,93.48 77.31,92.52 78.35,92.52 78.99,93.15 85.41,93.15 89.02,89.54 92.01,89.54 96.38,93.92 114.34,93.92 115.33,92.92 117.4,92.92 117.85,93.37 117.85,93.74 v2(117.62,93.96)
  IN4 w0.062: v4(46.17,86.27) 46.48,85.96 46.48,85.75 46.36,85.64 46.36,84.95 46.58,84.73 46.58,83.21 49.48,80.31 49.48,77.84 43.87,72.23 43.87,60.53 44.01,60.38 44.01,56.27 43.95,56.21 43.88,56.21 43.82,56.27 43.82,56.43 43.76,56.5 v2(43.55,56.5)
  BOTTOM w0.076: 125.79,83.67 125.79,83.65 125.8,83.65 125.8,83.24 126.22,82.82 126.22,82.77 arc(126.26,82.35) 126.37,81.94 arc(126.39,81.78) 126.35,81.62 126.3,81.51 arc(126.26,81.32) 126.29,81.13 arc(126.32,80.99) 126.29,80.86 arc(126.26,80.68) 126.29,80.49 arc(126.31,80.32) 126.26,80.16 126.25,80.16 arc(126.21,80.02) 126.2,79.88 arc(126.24,79.74) 126.33,79.63 arc(126.51,79.5) UC1.D52
  BOTTOM w0.088: CT183.1 43.1,56.24 43.31,56.24 43.55,56.47 v2(43.55,56.5) ; 125.79,83.67 125.79,85.66 117.86,93.59 117.86,93.73 v2(117.62,93.96)
CPU_DP2_P1_C: length 5.2
  BOTTOM w0.076: 38.77,56.4 38.75,56.4 38.75,56.4 38.42,56.4 38.29,56.53 37.85,56.53 37.76,56.44 UT1.AB17
  BOTTOM w0.088: 38.77,56.4 38.9,56.4 39.06,56.56 41.7,56.56 42.07,56.19 42.19,56.19 CT183.2
CPU_DP2_P2: length 140.5
  IN2 w0.083: v4(45.43,86.29) 45.25,86.48 45.25,86.8 46.62,88.17 47.79,88.17 47.84,88.22 55.64,88.22 59.84,92.41 59.84,93.1 60.65,93.91 77.18,93.91 77.49,93.6 85.51,93.6 89.17,89.94 91.81,89.94 96.18,94.31 114.52,94.31 115.48,93.35 115.96,93.35 116.12,93.51 116.12,93.7 v2(116.36,93.94)
  IN4 w0.062: v2(41.55,55.9) 41.39,55.74 41.09,55.74 40.94,55.59 40.94,55.06 40.78,54.89 39.35,54.89 39.13,55.1 39.13,61.05 40.11,62.02 41.16,62.02 42.5,63.35 42.5,68.45 42.96,68.91 42.96,73.21 45.14,75.38 45.14,82.6 44.7,83.04 44.7,85.35 44.99,85.65 44.99,85.86 45.1,85.96 45.29,85.96 45.43,86.11 v4(45.43,86.29)
  BOTTOM w0.076: 127.14,84.13 127.14,84.11 127.15,84.11 127.15,83.46 127.36,83.25 127.36,82.81 127.18,82.62 127.18,82.39 arc(127.18,82.25) 127.19,82.11 arc(127.21,81.97) 127.25,81.83 arc(127.28,81.75) 127.31,81.67 arc(127.31,81.63) 127.32,81.59 arc(127.36,81.47) 127.43,81.36 arc(127.47,81.31) 127.51,81.26 arc(127.69,80.98) UC1.B50
  BOTTOM w0.088: CT185.1 40.65,55.71 41.36,55.71 v2(41.55,55.9) ; v2(116.36,93.94) 116.15,94.15 116.15,94.45 116.29,94.6 120.24,94.6 120.92,93.91 120.92,92.21 127.14,85.99 127.14,84.13
CPU_DP2_P2_C: length 2.5
  BOTTOM w0.076: UT1.AB19 37.85,55.61 38.41,55.61 38.5,55.52 38.75,55.52 38.75,55.52 38.77,55.52
  BOTTOM w0.088: 38.77,55.52 38.9,55.52 39.11,55.73 39.64,55.73 CT185.2
CPU_DP2_P3: length 145.5
  IN2 w0.083: v4(43.5,86.75) 43.92,86.75 44,86.83 44,87.26 45.67,88.92 47.47,88.92 47.54,88.99 55.35,88.99 58.94,92.58 58.94,93.46 60.18,94.7 77.51,94.7 77.79,94.42 85.77,94.42 89.48,90.71 91.5,90.71 95.89,95.1 119.79,95.1 120,94.89 120,94.14 v2(120.18,93.96)
  IN4 w0.062: v4(43.5,86.75) 43.73,86.53 43.96,86.53 44.11,86.37 44.11,82.86 44.62,82.35 44.62,75.59 43.77,74.74 40.58,74.74 38.62,72.79 38.62,54.11 39.18,53.55 39.18,53.2 39.25,53.13 40.87,53.13 40.94,53.2 40.94,53.36 41.18,53.6 41.35,53.6 v2(41.56,53.81)
  BOTTOM w0.076: UC1.C51 127.27,80.35 arc(127.39,80.21) 127.54,80.3 127.55,80.33 arc(127.53,80.53) 127.34,80.63 arc(127.2,80.69) 127.13,80.83 arc(127.13,81) 127.14,81.16 arc(127.14,81.43) 127.04,81.68 arc(126.96,81.84) 126.94,82.02 126.94,83 126.62,83.31 126.62,83.6 126.63,83.6 126.63,83.62
  BOTTOM w0.088: v2(120.18,93.96) 119.98,93.76 119.98,92.55 126.63,85.9 126.63,83.62 ; CT182.1 40.56,53.98 40.8,53.98 41.2,53.58 41.32,53.58 v2(41.56,53.81)
CPU_DP2_P3_C: length 2.6
  BOTTOM w0.076: 38.62,54.57 38.62,54.57 38.45,54.57 38.33,54.69 37.85,54.69 37.76,54.6 UT1.AB21
  BOTTOM w0.088: 38.62,54.57 38.81,54.57 39.4,53.98 39.57,53.98 CT182.2
CPU_DP3_AUXN: length 1.2
  TOP w0.086: T1.1 130.14,76.98 v2(130.14,77.61)
  BOTTOM w0.086: v2(130.14,77.61) 129.84,77.3 UC1.G46
CPU_DP3_AUXP: length 1.1
  TOP w0.086: T2.1 128.89,78.34 v2(129.25,78.19)
  BOTTOM w0.086: v2(129.25,78.19) 129.49,77.95 UC1.F46
CPU_POPIRCOMP: length 11.1
  TOP w0.254: 146.48,59.95 146.48,60.14 146.16,60.46 v3(146.16,61.78)
  TOP w0.381: 146.48,59.95 v1(146.48,58.82) 146.48,57.81 148.17,56.12 148.17,55.3 149.06,54.41 RC88.1
  GND1 w0.254: v4(146.63,62.11) 146.55,62.11 146.22,61.78 v3(146.16,61.78)
  GND5 w0.254: v4(146.63,62.11) 146.98,62.46 v5(147.07,62.46)
CPU_XDP_PRDY#: length 60.1
  TOP w0.086: JXDP1.5 75.27,92.25 74.9,92.62 74.9,93.02 75.2,93.33 v3(75.66,93.33)
  GND1 w0.086: v3(75.66,93.33) 76.04,92.95 v4(76.04,92.8)
  IN4 w0.051: v2(123.3,83.28) 122.89,83.69 121.38,83.69 120.03,85.04 120.03,86.09 117.42,88.71 93.54,88.71 92.72,87.89 88.27,87.89 85.45,90.71 84.84,90.71 84.39,91.15 84.39,91.53 84.01,91.91 76.92,91.91 v4(76.04,92.8)
  BOTTOM w0.076: UC1.D56 124.01,79.7 123.93,79.97 123.93,80.08 123.85,80.36 123.81,80.52 123.79,80.56 123.79,80.81 123.83,80.9 123.83,81.11 123.79,81.18 123.79,81.55 123.94,81.7 123.94,82.15 123.3,82.8
  BOTTOM w0.086: v2(123.3,83.28) 123.3,82.8
CPU_XDP_PREQ#: length 58.2
  TOP w0.086: JXDP1.3 75.87,92.31 75.38,92.8 v2(75.35,92.8)
  IN4 w0.051: v2(119.78,84.1) 119.78,85.08 119.75,85.1 119.75,86.15 117.35,88.55 93.63,88.55 92.79,87.72 88.2,87.72 85.38,90.53 84.12,90.53 83.58,91.07 83.58,91.56 83.4,91.74 76.41,91.74 v2(75.35,92.8)
  BOTTOM w0.076: v2(119.78,84.1) 119.78,83.71 121.49,82 121.49,81.71 121.32,81.54 121.32,81.18 121.33,81.15 121.35,81.09 121.35,80.7 121.48,80.58 121.48,80.2 121.37,80.1 121.37,79.75 UC1.D61
  BOTTOM w0.086: RC138.1 75.21,92.65 v2(75.35,92.8)
CPU_XDP_TCLK: length 80.7
  TOP w0.086: JXDP1.57 59.67,90.63 60.04,90.26 v3(61.49,90.26)
  GND1 w0.086: v3(61.49,90.26) 61.49,90.33 v4(61.79,90.64)
  IN4 w0.051: v2(116.76,90.41) 116.3,90.86 114.72,90.86 114.39,91.19 94.13,91.19 92.15,89.21 88.99,89.21 85.66,92.54 77.26,92.54 76.14,93.66 71.88,93.66 71.09,92.87 71.09,92.54 70.36,91.81 65.66,91.81 65.14,91.3 64.08,91.3 63.67,91.7 62.43,91.7 61.64,90.92 61.64,90.79 v4(61.79,90.64)
  GND5 w0.086: v5(61.79,90) v4(61.79,90.64)
  BOTTOM w0.076: 120.34,84.01 120.34,83.38 121.65,82.07 121.65,81.64 121.48,81.47 121.48,81.22 121.48,81.21 121.57,81.03 UC1.B61
  BOTTOM w0.086: 120.34,84.01 120.34,84.39 119.17,85.56 RC328.2 119.14,85.86 118.74,86.27 118.74,87.05 118.58,87.21 117.52,87.21 116.76,87.97 v2(116.76,90.41) ; v5(61.79,90) 61.64,90.15 59.33,90.15 RC139.1
CPU_XDP_TDI: length 48.4
  TOP w0.086: UC8.6 85.63,88.72 RC134.1 85.09,89.46 85.06,89.49 v2(85.01,89.49)
  IN4 w0.051: v2(120.98,83.53) 120.74,83.3 119.75,83.3 119.4,83.65 119.4,86.01 117.23,88.17 93.78,88.17 92.94,87.33 88.08,87.33 85.92,89.49 v2(85.01,89.49)
  BOTTOM w0.076: v2(120.98,83.53) 120.98,83.21 122.01,82.18 122.01,80.5 121.96,80.45 121.96,80.22 122.31,79.87 UC1.D60
CPU_XDP_TDO: length 51.2
  TOP w0.086: v2(118.84,90.46) 118.84,91.12 117.14,92.82 116.07,92.82 115.28,93.61 v6(110.32,93.61) 108.54,93.61 105.67,90.74 105,90.74 103.02,88.76 94.36,88.76 92.01,86.41 88.87,86.41 88.19,87.08 86.86,87.08 RC135.1 86.03,87.22 UC8.3
  IN4 w0.051: v4(121.67,84.08) 121.66,84.08 120.79,84.94 120.79,86.01 120.54,86.27 120.54,88.67 118.84,90.37 v2(118.84,90.46)
  GND5 w0.086: v4(121.67,84.08) 121.64,84.05 121.53,84.05 121.49,84.09 120.84,84.09 v5(120.68,83.93)
  BOTTOM w0.076: 120.54,83.79 120.54,83.41 121.84,82.11 121.84,81.52 121.75,81.42 UC1.A61
  BOTTOM w0.086: v5(120.68,83.93) 120.54,83.79
CPU_XDP_TMS: length 50.4
  TOP w0.086: v2(83.18,91.07) 83.41,91.07 83.63,90.84 84.09,90.84 RC131.1 83.31,89.65 UC8.8
  IN4 w0.051: v2(83.18,91.07) 83.18,90.51 84.57,89.11 85.8,89.11 87.93,86.98 93.08,86.98 93.92,87.82 116.4,87.82 119.04,85.18 119.04,83.5 119.61,82.94 121.15,82.94 v2(121.52,83.31)
  BOTTOM w0.076: UC1.C60 122.19,80.47 122.19,82.18
  BOTTOM w0.086: v2(121.52,83.31) 121.43,83.22 121.43,83 122.19,82.24 122.19,82.18
CPU_XDP_TRST#: length 56.2
  TOP w0.086: UC8.11 81.78,87.72 81.63,87.56 81.63,87.28 81.54,87.19 81.05,87.19 80.96,87.28 80.96,88.17 CC308.1 RC136.1 80.5,87.26 81.04,86.71 v2(81.1,86.71)
  IN4 w0.051: v2(81.1,86.71) 81.13,86.68 81.13,86.67 81.6,86.19 92.8,86.19 94.07,87.46 112.59,87.46 113.3,86.75 116.96,86.75 118.69,85.03 118.69,83.36 119.46,82.58 121.54,82.58 122.12,83.16 v2(122.12,83.28)
  BOTTOM w0.076: v2(122.12,83.28) 122.12,82.72 122.37,82.47 122.37,81.18 UC1.B59 122.87,80.5 122.59,80.22 122.59,79.51 122.47,79.38 122.16,79.38 121.75,79.8 UC1.C61
CSI2_COMP: length 2.8
  TOP w0.086: v3(149.84,79.28) 149.52,78.97 RC3.1 148.59,78.77 v1(148.58,78.79)
  GND1 w0.086: v4(149.34,78.95) 149.5,78.95 v3(149.84,79.28)
  GND5 w0.086: v4(149.34,78.95) 149.25,78.95 v5(148.9,78.6)
CSIN_ISL9538: length 3.8
  TOP w0.203: PR910.2 52.06,34.92 52.09,34.95 ; 52.09,34.95 PC925.2 ; 52.09,34.95 52.09,35.17 51.82,35.44 51.82,35.96 PC927.1 52.39,35.98 52.43,35.94 PU901.14
CSIP_ISL9538: length 5.3
  TOP w0.203: PU901.15 52.85,35.54 52.65,35.33 52.65,34.53 52.14,34.02 PC925.1 52.09,32.94 51.83,32.69 ; 51.83,32.69 51.16,33.36 PR909.2 ; 51.83,32.69 PC926.1
CSON_ISL9538: length 6.2
  TOP w0.203: PU901.1 56.94,38.97 v1(57.65,39.68) 58.08,40.12 58.08,40.72 58.77,41.4 58.77,42 PC945.1 58.78,42.9 PR938.1
  TOP w0.254: PC946.1 58.82,43.01 PR938.1
CSOP_ISL9538: length 6.3
  TOP w0.203: PU901.2 56.54,39.18 57.75,40.39 57.75,40.93 v1(57.93,41.11) 58.08,41.26 58.08,41.77 57.86,41.99 57.86,42 PC945.2 57.86,42.01 57.85,42.02 57.85,42.63 57.55,42.93 PR937.1
  TOP w0.254: PC942.1 PR937.1
CV2_ON: length 75.7
  TOP w0.086: v2(259.76,47.1) 260.11,47.1 RE539.2
  IN2 w0.061: v4(201.36,36.76) 201.61,37.01 216.3,37.01 217.86,35.45 225.63,35.45 227.64,33.45 231.54,33.45 231.81,33.71 233.37,33.71 233.95,33.13 233.95,32.9 234.31,32.55 236.27,32.55 237.76,31.06 251.16,31.06 255.09,34.99 255.09,38.55 255.61,39.06 255.61,39.72 256.51,40.62 256.51,41.31 257.02,41.82 257.02,43.68 257.29,43.95 257.8,43.95 258.64,44.79 258.64,46.31 259.21,46.88 259.54,46.88 v2(259.76,47.1)
  GND5 w0.086: v5(201.34,36.15) 201.36,36.18 v4(201.36,36.76)
  BOTTOM w0.086: v5(201.34,36.15) 201.36,36.13 201.36,35.92 200.75,35.31 JUSH1.3
CV2_ON_R: length 27.6
  TOP w0.086: RE539.1 259.81,47.74 v2(259.76,47.68) ; UE1.H8 v2(265.36,58.64)
  GND1 w0.086: v4(257.62,42.88) 257.59,42.85 v3(257.59,42.19)
  IN2 w0.061: v2(265.36,58.64) 265.36,58.78 265.78,59.19 265.78,59.65 265.98,59.85 266.49,59.85 266.59,59.75 266.59,56.83 266.79,56.63 267.17,56.63 267.35,56.45 267.35,55.15 267.58,54.92 267.58,54.42 267.3,54.14 266.82,54.14 264.79,52.1 264.79,51.57 263.02,49.8 261.88,49.8 v2(259.76,47.68) 260.19,47.25 260.19,46.95 259.94,46.69 259.29,46.69 258.83,46.24 258.83,44.4 258.89,44.33 258.89,43.8 258.53,43.44 258.18,43.44 v4(257.62,42.88)
DAT_TP_SIO_I2C_CLK: length 129.7
  TOP w0.086: RZ22.2 CZ80.1 177.44,36 180.38,36 180.89,35.49 RZ349.2 180.73,34.96 180.38,34.62 180.38,33.76 180.82,33.32 180.82,33.31 v2(181.05,33.08) ; UE1.C12 268.2,63.01 v2(268.57,63.38)
  IN2 w0.061: v2(268.57,63.38) 268.98,63.79 269.54,63.79 271.09,62.24 271.09,59.11 272,58.2 272,56 270.43,54.43 270.43,53.43 269.88,52.88 269.88,51.02 269.6,50.75 268.32,50.75 264.25,46.68 263.53,46.68 261.99,45.13 261.99,43.81 258.52,40.34 258.52,39.8 256.6,37.88 256.6,33.25 252.64,29.29 229.01,29.29 228.54,29.76 226.69,29.76 224.37,32.08 216.82,32.08 215.84,33.06 209.68,33.06 207.46,30.85 201.47,30.85 201.05,31.27 196.58,31.27 195.28,32.57 192.9,32.57 192.3,31.97 182.16,31.97 v2(181.05,33.08)
DAT_TP_SIO_R: length 6.5
  TOP w0.086: RZ22.1 175.48,36.2 RZ18.2 175.48,35.77 v3(175.35,35.65)
  GND1 w0.086: v3(175.35,35.65) 174.9,35.65 v4(174.74,35.8)
  GND5 w0.086: v5(175.21,36) 174.95,36 v4(174.74,35.8)
  BOTTOM w0.086: CZ88.1 174.33,36.6 174.92,36 v5(175.21,36) 175.32,36.1 v1(176.13,36.1) 176.25,35.98 JKBTP1.13
DCIN1_EN: length 51.3
  TOP w0.086: v2(261.43,57.06) 261.79,57.41 UE1.K4
  IN4 w0.051: v4(258.54,25.71) 258.54,26.36 261.59,29.41 261.59,30.72 262.04,31.17 v4(262.04,34.22) ; v4(257.46,41.7) 256.72,42.44 256.72,43.61 257.18,44.07 257.68,44.07 258.35,44.74 258.35,45.36 258.23,45.47 258.23,46.79 257.57,47.45 257.57,51.79 258.55,52.76 258.55,53.96 258.45,54.06 258.45,54.96 259.65,56.16 260.49,56.16 261.4,57.06 v2(261.43,57.06)
  GND5 w0.086: v5(257,41.54) 257.15,41.7 v4(257.46,41.7) ; v4(262.04,34.22) v5(261.56,34.22) ; v5(257.92,25.92) 258.34,25.92 v4(258.54,25.71)
  BOTTOM w0.086: v5(261.56,34.22) 261.56,35.11 260.54,36.13 256,36.13 255.41,36.71 255.41,39.96 v5(257,41.54) ; v5(257.92,25.92) v1(252.09,25.92) 251.23,25.92 RE601.2
DCIN1_EN_R: length 1.5
  BOTTOM w0.086: RE600.1 58.37,87.91 58.36,87.91 PR1226.1
DCIN2_EN: length 293.2
  TOP w0.086: UE1.L12 268.62,56.18 268.62,54.49 270.5,52.61 v3(270.96,52.61)
  GND1 w0.086: v4(271.65,52.37) 271.2,52.37 v3(270.96,52.61)
  IN2 w0.061: v4(271.65,52.37) 271.65,53.27 273.84,55.47 273.84,60.5 274.84,61.49 274.84,64.61 271.1,68.35 267,68.35 263.62,71.73 255.48,71.73 255.08,72.12 254.2,72.12 253.73,71.64 249.39,71.64 246.72,68.97 v2(245.31,68.97)
  IN3 w0.061: v2(245.31,68.97) 245.31,67.25 244.71,66.65 244.71,65.56 243.21,64.05 241.37,64.05 240.22,62.91 237.42,62.91 236.6,63.73 231.31,63.73 230.67,63.09 228.37,63.09 227.07,61.8 227.07,60.58 226.31,59.81 226.31,53.35 222.08,49.13 214.71,49.13 210.87,45.29 201.52,45.29 201.27,45.29 200.39,46.17 192.24,46.17 190.28,48.13 188.38,48.13 186.76,49.76 185.24,49.76 179.31,55.69 179.31,57.44 175.92,60.83 175.92,67.34 173.64,69.62 173.64,78.48 174.01,78.85 174.01,79.16 174.01,79.16 174.01,80.16 174.01,80.17 174.01,82.74 174.01,83.54 173.41,84.15 172.5,84.15 170.68,85.96 166.19,85.96 164.86,87.29 163.45,87.29 162.48,88.25 157.01,88.25 156.93,88.17 147.38,88.17 147.21,88.35 140.85,88.35 139.21,86.7 131.25,86.7 129.64,88.3 125.82,88.3 125.01,89.11 106.12,89.11 105.48,88.47 104.4,88.47 103.04,87.12 86.99,87.12 86.27,87.84 80.71,87.84 79.34,89.21 66.43,89.21 65.29,88.07 60.34,88.07 v2(59.5,87.23)
  BOTTOM w0.086: v1(59.2,86.61) 59.5,86.91 v2(59.5,87.23) 59.53,87.26 RE600.2
DCIN2_EN_R: length 221.2
  TOP w0.086: PR1251.1 38.09,32.47 39.93,32.47 40.44,32.98 40.44,33.4 v1(41,33.96) 41.22,34.17 v2(41.57,34.17)
  IN4 w0.051: v4(249.67,25.73) 243.23,25.73 242.71,25.21 179.45,25.21 179.29,25.05 176.58,25.05 173.6,28.03 172.56,28.03 172.15,27.63 172.15,27.14 171.08,26.06 161.94,26.06 160.47,27.52 158.99,27.52 157.48,29.04 148.39,29.04 147.7,28.36 141.44,28.36 140.76,29.04 116.25,29.04 115.38,28.18 106.6,28.18 105.58,29.19 92.58,29.19 91.79,29.98 47.6,29.98 45.7,31.89 43.86,31.89 v2(41.57,34.17)
  GND5 w0.086: v4(249.67,25.73) 249.67,25.79 249.8,25.92 v5(250.28,25.92)
DCIN_ISL9538: length 13.8
  TOP w0.117: v1(65.11,32.6) 64.72,32.21 PR916.1
  TOP w0.508: PR916.1 62.99,31.78 PC931.2 61.68,31.78 60.62,32.84 v2(60.62,33.49)
  IN4 w0.508: v2(60.62,33.49) 60.62,33.68 60,34.3 58.62,34.3 57.93,33.61 54.5,33.61 54.4,33.71 v2(53.54,33.71)
DDR_A_CAA0: length 50.7
  IN2 w0.089: v2(98.59,36.31) 98.69,37.06 98.77,37.28 98.98,37.49 99.31,37.56 100.04,37.56 100.93,37.52 102.2,37.41 103.85,37.41 104.02,37.48 104.1,37.56 104.17,37.77 104.17,37.97 103.94,38.65 103.82,39.15 103.82,39.66 103.78,40.19 103.68,40.68 103.68,43.8 104.1,44.21 104.34,44.21 104.74,44.34 104.92,44.44 105.96,45.48 106.11,45.56 107.51,45.79 107.82,45.82 108.41,45.82 117.32,54.74 117.61,55.19 117.9,56.09 118.19,56.79 118.52,57.33 119.7,58.51 119.83,58.59 121.38,59.04 122.04,59.13 125.34,59.13 125.49,59.05 125.63,58.94 126.09,58.55 126.49,58.2 v2(127.2,57.54)
  BOTTOM w0.076: v2(98.59,36.31) UD1.R2 ; UC1.BA51 127.01,59.45 127.01,59.23 127.01,59.21 127,59.21 127,59.21 126.98,59.15 126.98,58.89 126.99,58.86 126.99,58.48 126.85,58.33 126.85,57.89 v2(127.2,57.54)
  BOTTOM w0.127: RD1.2 97.55,34.02 97.82,34.02 98.77,34.97 98.77,35.79 UD1.R2
DDR_A_CAA1: length 49.7
  IN2 w0.089: v2(99.23,37.13) 99.69,36.41 100.25,35.85 100.71,35.85 101,35.55 101,35.24 101.26,34.98 105.91,34.98 106.36,35.12 107.21,35.76 107.53,35.93 108.18,36.18 108.53,36.33 108.65,36.41 110.1,37.86 110.1,40.01 110.29,40.2 110.29,42.73 111.68,44.12 112.42,44.12 113.77,45.47 114.29,45.8 117.29,48.8 122.6,48.8 125.19,51.39 125.66,52.9 v2(126.1,53.33)
  BOTTOM w0.076: UC1.BB54 125.64,58.6 125.64,57.17 125.37,56.9 125.37,54.05 v2(126.1,53.33) ; UD1.P2 99.23,36.23 v2(99.23,37.13)
  BOTTOM w0.127: RD2.2 99.08,34.6 99.08,35.44 UD1.P2
DDR_A_CAA2: length 48.2
  IN2 w0.089: v2(99.97,35.42) 99.97,35.36 100.69,34.64 107.86,34.64 110.78,37.56 110.78,39.73 111.32,40.27 111.32,42.4 112.36,43.44 112.79,43.44 114.27,44.92 116.04,44.92 119.37,48.24 122.83,48.24 126.71,52.12 126.71,54.62 v2(127.2,55.12)
  BOTTOM w0.076: UC1.BA52 126.57,59.1 126.32,58.85 126.32,58.55 126.5,58.37 126.5,56.25 126.63,56.11 126.63,55.65 126.88,55.4 ; v2(99.97,35.42) 99.97,35.48 100.2,35.7 UD1.N2
  BOTTOM w0.127: v2(99.97,35.42) 99.95,35.39 99.95,35.36 99.81,35.22 99.81,33.75 99.28,33.22 RD3.2 ; v2(127.2,55.12) 127.16,55.12 126.88,55.4
DDR_A_CAA3: length 52.7
  IN2 w0.089: v2(100.52,36.33) 101.19,37 104.03,37 104.55,37.52 104.55,38.53 104.17,38.91 104.17,40.6 103.96,40.8 103.96,43.68 104.21,43.93 106.91,43.93 116.56,53.58 120.16,53.58 120.41,53.83 120.41,57.18 122.08,58.85 125.26,58.85 125.76,58.35 126.84,56.73 v2(127.2,56.33)
  BOTTOM w0.076: 99.51,35.42 99.62,35.53 99.62,35.56 99.85,35.8 99.85,36.37 UD1.N3 100.5,36.36 v2(100.52,36.33) ; v2(127.2,56.33) 126.77,56.77 126.77,57.69 126.68,57.77 126.68,58.4 126.83,58.55 126.83,58.83 126.82,58.86 126.82,59.18 126.83,59.21 126.83,59.48 126.81,59.53 126.67,59.67 UC1.AY52
  BOTTOM w0.127: RD4.2 98.33,33.22 99.42,34.31 99.42,35.33 99.51,35.42
DDR_A_CAA4: length 51.1
  IN2 w0.089: v2(126.07,56.63) 125.37,57.33 125.37,58.34 125.14,58.57 122.19,58.57 121.68,58.05 121.68,56.32 121.57,56.21 121,56.21 120.9,56.11 120.9,55.96 121,55.86 121.57,55.86 121.68,55.75 121.68,55.61 121.57,55.5 121,55.5 120.9,55.4 120.9,55.25 121,55.15 121.57,55.15 121.68,55.04 121.68,54.7 120.28,53.3 116.68,53.3 108.11,44.73 108.11,41.44 104.89,38.22 104.89,37.38 104.17,36.66 101.51,36.66 v2(101.16,36.31)
  BOTTOM w0.076: UC1.AW52 126.67,60.41 126.35,60.09 126.35,59.59 126.31,59.54 126.31,59.07 126.15,58.91 126.15,56.71 v2(126.07,56.63) ; 101,35.18 101,35.65 101.16,35.8 v2(101.16,36.31) UD1.M3
  BOTTOM w0.127: 101,35.18 101,34.8 100.23,34.03 RD5.2
DDR_A_CAA5: length 49.9
  IN2 w0.089: v2(124.73,55.58) 124.21,55.58 124.1,55.68 124.1,57.82 123.97,57.95 123.09,57.95 122.9,57.75 122.9,54.68 123,54.57 123.18,54.57 123.28,54.47 123.28,54.32 123.18,54.22 123,54.22 122.9,54.11 122.9,53.71 123,53.61 123.31,53.61 123.41,53.51 123.41,53.36 123.31,53.25 123,53.25 122.9,53.15 122.9,53 123,52.9 123.33,52.9 123.44,52.79 123.44,52.65 123.33,52.54 123,52.54 122.9,52.44 122.9,52.29 123,52.19 123.31,52.19 123.41,52.08 123.41,51.94 123.31,51.83 123,51.83 122.9,51.73 122.9,51.4 122.33,50.83 115.83,50.83 108.67,43.67 108.67,40.91 108.47,40.7 108.47,40.14 107.26,38.94 106.81,38.94 106.62,39.13 106.22,39.13 105.72,38.63 v2(105.72,37.89)
  BOTTOM w0.076: v2(124.73,55.58) 125.04,55.89 125.04,57.29 125.31,57.55 125.31,58.29 125.12,58.48 125.12,58.87 125.13,58.89 125.13,59.15 125.12,59.18 125.12,59.52 125.13,59.54 125.13,59.8 124.97,60.13 UC1.AY55 ; v2(105.72,37.89) 105.32,37.89 105.05,37.62 105.05,37.01 UD1.F3 105.05,36.42 105.05,35.79 104.82,35.57 104.77,35.57
  BOTTOM w0.127: 104.77,35.57 104.77,33.36 104.99,33.13 RD6.2
DDR_A_CAA6: length 49.5
  IN2 w0.089: v2(126.07,54.5) 125.89,54.5 125.8,54.59 125.8,54.82 125.7,54.92 125.53,54.92 125.44,54.83 125.44,53.22 124.8,52.57 124.8,51.39 122.48,49.08 115.98,49.08 114.28,47.38 114.28,47.25 114.32,47.2 114.32,47.08 114.2,46.95 114.07,46.95 114.02,47 113.9,47 113.23,46.33 113.23,46.18 113.46,45.96 113.46,45.81 113.35,45.71 113.21,45.71 112.98,45.93 112.83,45.93 112.73,45.83 112.73,45.68 112.96,45.45 112.96,45.31 112.85,45.2 112.7,45.2 112.48,45.43 112.33,45.43 110.02,43.11 110.02,40.32 109.83,40.13 109.83,39.05 109.77,39 109.47,39 109.31,38.84 109.31,38.67 109.83,38.16 109.83,37.97 109.63,37.78 109.5,37.78 108.97,38.31 108.78,38.31 108.48,38 108.48,37.84 109.01,37.31 109.01,37.16 108.56,36.71 108.35,36.71 107.92,37.14 107.71,37.14 105.98,35.42 v2(105.83,35.42)
  BOTTOM w0.076: UD1.E3 105.69,36.42 105.69,36.04 105.7,36.04 105.7,35.79 105.69,35.79 105.69,35.56 v2(105.83,35.42) ; UC1.AW54 125.44,60.54 125.75,60.23 125.75,59.57 125.97,59.36 125.97,57.03 125.7,56.76 125.7,55.86 125.93,55.63 126.25,55.63 126.55,55.33 126.55,55.2
  BOTTOM w0.127: RD7.2 106.9,34.35 v2(105.83,35.42) ; v2(126.07,54.5) 126.35,54.5 126.55,54.7 126.55,55.2
DDR_A_CAA7: length 48.1
  IN2 w0.089: v2(105.24,35.45) 105.26,35.45 105.65,35.85 105.93,35.85 109.55,39.47 109.55,40.24 109.74,40.43 109.74,43.23 116.27,49.77 116.54,49.77 116.64,49.66 116.64,49.47 116.75,49.36 116.9,49.36 117,49.47 117,49.66 117.1,49.77 117.25,49.77 117.36,49.66 117.36,49.47 117.46,49.36 117.61,49.36 117.71,49.47 117.71,49.66 117.82,49.77 117.96,49.77 118.07,49.66 118.07,49.47 118.17,49.36 118.32,49.36 118.42,49.47 118.42,49.66 118.53,49.77 118.67,49.77 118.78,49.66 118.78,49.47 118.88,49.36 119.03,49.36 119.13,49.47 119.13,49.66 119.24,49.77 119.38,49.77 119.49,49.66 119.49,49.47 119.59,49.36 119.74,49.36 119.84,49.47 119.84,49.66 119.95,49.77 120.1,49.77 120.2,49.66 120.2,49.47 120.3,49.36 120.45,49.36 120.56,49.47 120.56,49.66 120.66,49.77 120.81,49.77 120.91,49.66 120.91,49.47 121.02,49.36 121.16,49.36 121.27,49.47 121.27,49.66 121.37,49.77 121.52,49.77 121.62,49.66 121.62,49.47 121.73,49.36 121.87,49.36 121.98,49.47 121.98,49.66 122.08,49.77 122.77,49.77 124.52,51.51 124.52,52.68 125.16,53.33 125.16,56.56 125.25,56.65 125.58,56.65 125.67,56.56 125.67,55.32 125.77,55.22 v2(126.08,55.22)
  BOTTOM w0.076: v2(126.08,55.22) 125.54,55.76 125.54,56.83 125.8,57.1 125.8,59.09 UC1.BA54 ; v2(105.24,35.45) 105.4,35.6 UD1.E2
  BOTTOM w0.127: RD8.2 105.95,34.08 105.24,34.78 v2(105.24,35.45)
DDR_A_CAA8: length 48.4
  IN2 w0.089: v2(124.83,57.57) 124.47,57.57 124.38,57.66 124.38,58.07 124.22,58.23 122.98,58.23 122.62,57.86 122.62,51.51 122.22,51.11 118.7,51.11 118.59,51.22 118.59,51.95 118.49,52.05 118.34,52.05 118.24,51.95 118.24,51.22 118.13,51.11 117.99,51.11 117.88,51.22 117.88,51.95 117.78,52.05 117.63,52.05 117.53,51.95 117.53,51.22 117.42,51.11 117.28,51.11 117.17,51.22 117.17,51.95 117.07,52.05 116.92,52.05 116.82,51.95 116.82,51.22 116.71,51.11 116.57,51.11 116.46,51.22 116.46,51.95 116.36,52.05 116.21,52.05 116.11,51.95 116.11,51.22 116,51.11 115.71,51.11 108.39,43.79 108.39,41.02 108.19,40.82 108.19,40.25 107.55,39.62 107.12,39.62 v2(107.03,39.53)
  BOTTOM w0.076: UD1.D2 106.37,36.24 106.37,36.83 106.65,37.11 106.78,37.11 107.04,37.37 107.04,38.94 107.03,38.95 107.03,39.25 107.03,39.26 v2(107.03,39.53) ; v2(124.83,57.57) 124.6,57.81 124.6,58.29 124.64,58.33 124.64,58.86 124.63,58.89 124.63,59.15 124.64,59.17 124.65,59.2 124.65,59.44 UC1.BA55
  BOTTOM w0.127: UD1.D2 107.85,34.11 RD9.2
DDR_A_CAA9: length 49.5
  IN2 w0.089: v2(126.08,52.1) 126.08,51.89 122.72,48.52 117.41,48.52 117.27,48.38 117.27,48.23 117.87,47.63 117.87,47.48 117.77,47.38 117.62,47.38 117.01,47.98 116.87,47.98 116.76,47.88 116.76,47.73 117.23,47.26 117.23,47.12 117.12,47.01 116.98,47.01 116.51,47.48 116.36,47.48 116.26,47.37 116.26,47.23 116.7,46.79 116.7,46.64 116.6,46.53 116.45,46.53 116.01,46.97 115.86,46.97 115.76,46.87 115.76,46.72 116.2,46.28 116.2,46.14 116.09,46.03 115.95,46.03 115.51,46.47 115.36,46.47 115.25,46.37 115.25,46.22 115.69,45.78 115.69,45.63 115.59,45.53 115.44,45.53 115,45.97 114.86,45.97 114.75,45.86 114.75,45.72 115.01,45.45 115.01,45.31 114.91,45.2 114.76,45.2 114.5,45.47 114.35,45.47 114.02,45.13 113.82,45.13 112.54,43.84 111.8,43.84 110.57,42.62 110.57,40.08 110.43,39.94 110.43,37.7 108.24,35.51 v2(107.64,35.51)
  BOTTOM w0.076: 125.21,53.68 125.21,57.22 125.47,57.48 125.47,58.36 125.29,58.55 125.29,58.83 125.3,58.85 125.3,58.86 125.3,59.18 125.29,59.22 125.29,59.49 125.34,59.64 125.34,59.9 UC1.AY54 ; 107.77,34.83 107.7,34.9 107.7,35.45 v2(107.64,35.51) 107.11,35.51 UD1.C2
  BOTTOM w0.127: 107.77,34.83 108.8,33.8 RD10.2 ; v2(126.08,52.1) 125.21,52.98 125.21,53.68
DDR_A_CAB0: length 47
  IN1 w0.08: v2(129.28,61.49) 129.28,61.05 131.24,59.09 131.24,49.3 128.69,46.75 128.69,38.88 123.42,33.61 118.48,33.61 117.77,34.32 117.51,34.32 117.41,34.21 117.41,33.79 117.31,33.69 117.11,33.69 117.01,33.79 117.01,34.21 116.9,34.32 116,34.32 115.19,35.13 115.19,35.47 115.09,35.58 114.61,35.58 114.48,35.44 v2(114.23,35.44)
  BOTTOM w0.076: UC1.AU46 v2(129.28,61.49)
  BOTTOM w0.127: UD2.R2 114.23,35.68 v2(114.23,35.44) 114.23,33.18 RD11.2
DDR_A_CAB1: length 46.3
  IN1 w0.08: v2(129.24,62.11) 129.59,61.76 129.7,61.58 129.77,61.23 129.83,61.09 130.33,60.42 131.51,59.23 131.51,49.19 128.96,46.64 128.96,38.77 123.53,33.34 117.57,33.34 117.07,33.41 116.69,33.54 115.86,34.06 v2(114.78,35.14)
  BOTTOM w0.076: UC1.AU48 v2(129.24,62.11)
  BOTTOM w0.127: RD12.2 115.47,33.63 114.78,34.32 v2(114.78,35.14) 114.78,35.58 UD2.P2
