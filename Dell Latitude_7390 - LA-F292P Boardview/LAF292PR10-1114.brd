# Allegro board LAF292PR10-1114.brd (continued)
## Nets (continued)
GND: CA5.2 CA6.2 CA7.2 CA10.2 CA12.2 CA13.1 CA19.2 CA22.2 CA23.2 CA24.2 CA31.2 CA33.2 CA45.2 CA46.2 CA47.2 CA48.2 CA53.2 CA54.2 CA55.2 CA56.2 CA59.2 CA60.2 CA61.2 CA62.2 CA63.2 CA64.2 CA65.2 CA66.2 CA67.2 CA68.2 CA69.2 CA72.2 CC7.2 CC8.2 CC9.2 CC10.2 CC21.2 CC22.2 CC23.2 CC24.2 CC25.2 CC26.2 CC27.2 CC28.2 CC29.2 CC30.2 CC32.2 CC33.2 CC176.2 CC177.2 CC178.2 CC179.2 CC195.2 CC199.2 CC202.2 CC203.2 CC204.2 CC205.2 CC206.2 CC207.2 CC208.2 CC209.2 CC210.2 CC211.2 CC212.2 CC213.2 CC214.2 CC215.2 CC216.2 CC217.2 CC218.2 CC219.2 CC220.2 CC221.2 CC222.2 CC223.2 CC224.2 CC225.2 CC226.2 CC250.2 CC251.2 CC252.2 CC253.2 CC264.2 CC265.2 CC266.2 CC269.2 CC270.2 CC279.2 CC280.2 CC281.2 CC288.2 CC294.2 CC295.2 CC296.2 CC297.2 CC300.2 CC301.2 CC302.2 CC303.2 CC304.2 CC305.2 CC306.2 CC307.2 CC308.2 CC310.2 CC312.2 CC313.2 CC314.2 CC316.2 CC318.2 CC319.2 CC320.2 CC321.2 CC322.2 CC323.2 CC324.2 CC325.2 CC326.2 CC331.2 CC332.2 CC333.2 CC334.2 CC335.2 CC338.2 CC339.2 CC340.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD10.1 CD11.1 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD36.2 CD37.2 CD38.2 CD41.2 CD42.2 CD43.2 CD46.1 CD47.1 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD66.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD74.2 CD75.2 CD76.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD87.2 CD88.2 CD89.2 CD90.2 CD91.2 CD92.2 CD93.2 CD94.2 CD95.2 CD96.2 CD97.2 CD98.2 CD99.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CD110.2 CD111.2 CD112.2 CD113.2 CD114.2 CD115.2 CE3.2 CE4.2 CE8.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE19.2 CE20.2 CE21.2 CE22.2 CE23.2 CE25.2 CE28.2 CE29.2 CE30.2 CE31.2 CE32.2 CE36.2 CE38.2 CE40.2 CE47.2 CE52.2 CE53.2 CE54.2 CE57.2 CE59.2 CE60.2 CE61.2 CE62.2 CE63.2 CE64.2 CE65.2 CE66.2 CE500.2 CE501.2 CE502.2 CI1.2 CI3.2 CI6.2 CI7.2 CI14.2 CI17.2 CI19.2 CI31.2 CI32.2 CI33.2 CI34.2 CI43.2 CI44.2 CI45.2 CI46.2 CLP1.1 CLP2.1 CLP3.1 CLP4.1 CLP5.1 CLP6.1 CLP7.1 CLP8.1 CLP9.1 CLP10.1 CLP11.1 CLP12.1 CLP13.1 CLP14.1 CLP15.1 CLP16.1 CLP17.1 CLP18.1 CLP19.1 CLP20.1 CLP21.1 CLP22.1 CLP23.1 CLP24.1 CLP25.1 CLP26.1 CLP27.1 CLP28.1 CLP29.1 CLP30.1 CLP31.1 CLP32.1 CLP33.1 CLP34.1 CLP35.1 CLP36.1 CLP37.1 CLP38.1 CMOS1.2 CN60.2 CN61.2 CN62.2 CN63.2 CN64.2 CR1.2 CR2.2 CR3.2 CR4.2 CR5.2 CR6.2 CR8.2 CR9.2 CR10.2 CR15.2 CR17.1 CR18.1 CR19.1 CR20.1 CR21.2 CR25.2 CR26.2 CR29.2 CR30.2 CT1.2 CT20.2 CT21.2 CT25.2 CT26.2 CT27.2 CT28.2 CT29.2 CT30.2 CT31.2 CT32.2 CT33.2 CT34.2 CT35.2 CT36.2 CT37.2 CT38.2 CT39.2 CT40.2 CT41.2 CT42.2 CT43.2 CT44.2 CT45.2 CT46.2 CT47.2 CT48.2 CT49.2 CT50.2 CT51.2 CT52.2 CT53.2 CT54.2 CT55.2 CT56.2 CT57.2 CT59.2 CT60.2 CT61.2 CT62.2 CT63.2 CT64.2 CT67.2 CT68.2 CT69.2 CT70.2 CT71.2 CT72.2 CT73.2 CT74.2 CT75.2 CT76.2 CT77.2 CT78.2 CT82.2 CT83.2 CT84.2 CT85.2 CT86.2 CT87.2 CT88.2 CT89.2 CT90.2 CT91.2 CT92.2 CT93.2 CT94.2 CT99.2 CT100.2 CT101.2 CT102.2 CT142.2 CT143.2 CT144.2 CT145.2 CT147.2 CT148.2 CT149.2 CT150.2 CT151.2 CT152.2 CT153.2 CT154.2 CT155.2 CT158.2 CT163.2 CT164.2 CT165.2 CT166.2 CT167.2 CT189.2 CT190.2 CT191.2 CT192.2 CT205.2 CT237.2 CT238.2 CV11.2 CV12.2 CV14.2 CV15.2 CV16.2 CV17.2 CV18.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV24.2 CV25.2 CV39.2 CV40.2 CV41.2 CV54.2 CV55.2 CZ1.2 CZ2.2 CZ3.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ21.2 CZ23.2 CZ24.2 CZ25.2 CZ26.2 CZ27.2 CZ28.2 CZ29.2 CZ30.2 CZ31.2 CZ32.2 CZ33.2 CZ34.2 CZ35.2 CZ36.2 CZ37.2 CZ39.2 CZ40.2 CZ41.2 CZ50.2 CZ51.2 CZ52.2 CZ53.2 CZ54.2 CZ55.2 CZ56.2 CZ57.2 CZ58.2 CZ59.2 CZ60.2 CZ61.2 CZ62.2 CZ63.2 CZ64.2 CZ66.2 CZ67.2 CZ68.2 CZ69.2 CZ71.2 CZ72.2 CZ73.2 CZ75.2 CZ78.1 CZ80.2 CZ81.2 CZ82.2 CZ83.2 CZ84.2 CZ85.2 CZ86.2 CZ87.2 CZ88.2 CZ89.2 CZ90.2 CZ91.2 CZ92.2 CZ100.2 CZ101.2 CZ102.2 CZ103.2 CZ104.2 CZ105.2 CZ106.2 CZ109.2 CZ112.2 CZ113.2 CZ114.2 CZ115.2 CZ116.2 CZ117.2 CZ118.2 CZ119.2 CZ120.2 CZ121.2 CZ122.2 CZ124.2 CZ125.2 CZ126.2 CZ127.2 CZ128.2 CZ154.2 CZ155.2 CZ164.2 CZ165.2 CZ166.2 CZ167.2 CZ168.2 CZ169.2 CZ170.2 CZ180.2 CZ181.2 CZ182.2 CZ183.2 CZ184.2 CZ185.2 CZ186.2 CZ187.2 CZ188.2 CZ197.2 CZ198.2 CZ200.2 CZ300.2 CZ301.2 CZ302.2 CZ303.2 CZ304.2 CZ305.2 CZ306.2 DA1.1 DA2.1 DA3.1 DA6.1 DA7.1 DE1.2 DI1.3 DI2.1 DI4.3 DI5.1 DT4.1 DT5.2 DT6.2 DT9.2 DT10.2 DT13.2 DT14.2 DT17.2 DT18.2 DT21.1 DT22.2 DT23.2 DT26.2 DT27.2 DT30.2 DT31.2 DT34.2 DT35.2 DT41.3 DT42.3 DT43.3 DT44.3 DV4.1 H1.1(TP-1) H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H9.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H16.1(TP-1) H18.1(TP-1) H19.1(TP-1) H20.1(TP-1) H24.1(TP-1) H26.1(TP-1) H27.1(TP-1) H34.1(TP-1) JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19 JAPS1.20 JDEG1.10 JDEG1.11 JDEG1.12 JEDP1.1 JEDP1.3 JEDP1.10 JEDP1.18 JEDP1.19 JEDP1.20 JEDP1.22 JEDP1.23 JEDP1.28 JEDP1.39 JEDP1.41 JEDP1.42 JEDP1.43 JEDP1.44 JEDP1.45 JESPI.9 JESPI.11 JESPI.12 JFAN1.1 JFAN1.5 JFAN1.6 JHDMI1.2 JHDMI1.5 JHDMI1.8 JHDMI1.11 JHDMI1.17 JHDMI1.20 JHDMI1.21 JHDMI1.22 JHDMI1.23 JIR1.2 JIR1.3 JIR1.7 JIR1.8 JKBTP1.2 JKBTP1.3 JKBTP1.9 JKBTP1.15 JKBTP1.17 JKBTP1.20 JKBTP1.21 JKBTP1.22 JLED1.4 JLED1.7 JLED1.8 JNGFF1.1 JNGFF1.7 JNGFF1.18 JNGFF1.23 JNGFF1.24 JNGFF1.29 JNGFF1.30 JNGFF1.33 JNGFF1.36 JNGFF1.39 JNGFF1.45 JNGFF1.51 JNGFF1.57 JNGFF1.63 JNGFF1.69 JNGFF1.75 JNGFF1.76 JNGFF1.77 JNGFF2.3 JNGFF2.5 JNGFF2.11 JNGFF2.27 JNGFF2.33 JNGFF2.39 JNGFF2.45 JNGFF2.51 JNGFF2.57 JNGFF2.71 JNGFF2.73 JNGFF2.76 JNGFF2.77 JNGFF3.1 JNGFF3.3 JNGFF3.9 JNGFF3.15 JNGFF3.21 JNGFF3.27 JNGFF3.33 JNGFF3.39 JNGFF3.45 JNGFF3.51 JNGFF3.57 JNGFF3.71 JNGFF3.73 JNGFF3.75 JNGFF3.76 JNGFF3.77 JPWR1.6 JPWR1.7 JPWR1.8 JRTC1.2 JRTC1.3 JRTC1.4 JSAR1.4 JSAR1.5 JSAR1.6 JSD1.6 JSD1.10 JSD1.11 JSD1.12 JSD1.13 JSD1.14 JSD1.17 JSD1.20 JSD1.23 JSEN2.2 JSEN2.13 JSEN2.14 JSIM1.5 JSIM1.11 JSIM1.12 JSIM1.13 JSIM1.14 JSIM1.15 JSIM1.16 JSIM1.17 JSPI1.1 JSPI1.2 JSPI1.3 JSPI1.21 JSPI1.22 JSPK1.6 JSPK1.7 JSPK1.8 JTAG1.2 JTS1.4 JTS1.11 JTS1.12 JTUN1.7 JTUN1.8 JTUN1.9 JTUN1.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JUSBC1.1 JUSBC1.2 JUSBC1.3 JUSBC1.4 JUSBC1.5 JUSBC1.6 JUSBC1.A1 JUSBC1.A12 JUSBC1.B1 JUSBC1.B12 JUSBC2.1 JUSBC2.2 JUSBC2.3 JUSBC2.4 JUSBC2.5 JUSBC2.6 JUSBC2.A1 JUSBC2.A12 JUSBC2.B1 JUSBC2.B12 JUSH1.6 JUSH1.7 JUSH1.10 JUSH1.24 JUSH1.25 JUSH1.27 JUSH1.28 JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP1.61 JXDP1.62 JXDP1.63 LGA1.5 LGA1.6 LGA1.7 LGA1.8 PBATT1.7 PBATT1.8 PBATT1.9 PBATT1.10 PBATT1.11 PBATT1.12 PBATT1.13 PBATT1.14 PC1.2 PC2.1 PC3.2 PC100.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC128.2 PC129.2 PC130.2 PC131.2 PC132.2 PC133.2 PC134.2 PC135.2 PC136.2 PC137.2 PC138.2 PC139.2 PC140.2 PC150.2 PC151.2 PC161.2 PC162.2 PC163.2 PC164.2 PC200.2 PC201.2 PC202.2 PC203.2 PC204.2 PC206.2 PC207.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC214.2 PC216.2 PC217.2 PC218.2 PC219.2 PC221.2 PC222.2 PC223.2 PC301.2 PC302.2 PC303.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC401.2 PC402.2 PC403.2 PC404.2 PC406.2 PC407.2 PC408.2 PC409.2 PC410.2 PC411.2 PC412.2 PC413.2 PC415.2 PC417.2 PC418.2 PC419.2 PC420.2 PC421.2 PC422.2 PC424.2 PC427.2 PC501.2 PC502.2 PC504.2 PC505.2 PC506.2 PC513.2 PC514.2 PC516.2 PC601.2 PC602.2 PC603.2 PC604.2 PC605.1 PC606.2 PC608.2 PC612.2 PC613.1 PC614.1 PC616.1 PC618.1 PC619.1 PC621.1 PC622.2 PC625.1 PC628.2 PC629.1 PC631.2 PC636.1 PC641.2 PC643.2 PC644.2 PC645.2 PC647.1 PC649.2 PC651.1 PC652.2 PC654.1 PC656.2 PC657.2 PC658.2 PC659.2 PC660.2 PC661.2 PC662.2 PC664.2 PC665.2 PC669.2 PC670.2 PC672.2 PC673.2 PC674.2 PC675.2 PC677.2 PC678.2 PC682.2 PC683.2 PC684.2 PC685.2 PC686.2 PC687.2 PC688.2 PC689.2 PC690.2 PC691.2 PC692.2 PC693.2 PC694.2 PC695.2 PC696.2 PC697.2 PC902.2 PC903.2 PC904.2 PC905.2 PC906.2 PC909.2 PC911.2 PC913.2 PC914.2 PC915.2 PC916.2 PC917.2 PC918.2 PC919.2 PC920.2 PC926.2 PC927.2 PC928.2 PC929.2 PC931.1 PC932.1 PC933.2 PC935.2 PC936.2 PC937.1 PC938.2 PC939.2 PC940.2 PC941.2 PC942.2 PC943.2 PC944.2 PC946.2 PC947.2 PC949.1 PC950.1 PC951.2 PC952.2 PC955.2 PC956.2 PC957.2 PC958.2 PC959.2 PC960.2 PC961.2 PC962.2 PC963.2 PC986.2 PC987.2 PC988.2 PC989.2 PC990.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC1099.2 PC1126.2 PC1127.2 PC1128.2 PC1129.2 PC1132.2 PC1133.2 PC1134.2 PC1136.2 PC1137.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1143.2 PC1144.2 PC1145.2 PC1146.2 PC1147.2 PC1148.2 PC1149.2 PC1150.2 PC1151.2 PC1152.2 PC1153.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1201.2 PC1202.2 PC1203.2 PC1207.1 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1212.2 PC1213.2 PC1214.2 PC1215.2 PC1219.1 PC1220.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC1283.2 PC1284.2 PC1285.1 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1336.2 PC1337.2 PD1.1 PD2.1 PD906.2 PH601.1 PH603.1 PJP19.2 PQ614.5 PQ614.6 PQ614.7 PQ904.10 PQ905.10 PQ909.3 PQ1201.1 PQ1201.4 PQ1205.3 PQ1206.3 PQ1207.1 PQ1207.4 PQ1208.3 PQ1214.3 PQ1215.3 PQ1216.1 PQ1216.4 PQ1217.1 PQ1217.4 PQ1219.3 PQ1220.1 PQ1220.4 PQ1222.1 PQ1222.4 PQ1223.1 PQ1223.4 PQ1224.1 PQ1224.4 PQ1226.1 PQ1226.4 PQ1228.3 PR103.2 PR116.2 PR206.2 PR207.1 PR209.2 PR212.2 PR302.2 PR310.2 PR311.2 PR403.2 PR407.2 PR412.1 PR415.2 PR416.2 PR419.2 PR420.2 PR424.2 PR427.2 PR428.2 PR505.2 PR506.2 PR514.2 PR516.2 PR608.2 PR611.2 PR613.1 PR629.1 PR631.1 PR647.1 PR651.2 PR653.1 PR658.1 PR925.2 PR927.2 PR930.2 PR932.2 PR945.2 PR948.2 PR953.2 PR960.1 PR961.2 PR1201.2 PR1220.1 PR1224.1 PR1225.2 PR1227.2 PR1231.2 PR1234.2 PR1250.1 PR1257.1 PR1261.2 PR1262.2 PR1270.2 PR1285.1 PR1286.1 PU100.7 PU100.8 PU100.18 PU100.21 PU102.7 PU102.8 PU102.18 PU102.21 PU200.4 PU200.9 PU200.15 PU301.7 PU301.8 PU301.18 PU301.21 PU401.6 PU401.15 PU401.16 PU401.17 PU402.6 PU402.15 PU402.16 PU402.17 PU501.2 PU503.4 PU503.9 PU602.41 PU610.4 PU610.10 PU610.14 PU610.18 PU612.4 PU612.10 PU612.14 PU612.18 PU613.4 PU613.10 PU613.14 PU613.18 PU614.4 PU614.9 PU901.33 PU903.3 PU1201.4 PU1202.3 PU1203.3 QC6.3 QE2.1 QE2.4 QE12.3 QE17.3 QR1.3 QV2.3 QV4.3 QV6.3 QZ4.3 RA35.2 RA36.2 RA37.2 RA45.2 RA51.2 RA62.1 RC1.2 RC3.2 RC4.2 RC5.2 RC6.2 RC7.2 RC44.2 RC48.2 RC65.2 RC75.2 RC86.2 RC88.2 RC89.2 RC90.2 RC91.2 RC96.2 RC109.2 RC110.2 RC112.2 RC113.2 RC114.2 RC122.2 RC136.2 RC139.2 RC141.2 RC163.2 RC166.2 RC167.2 RC219.2 RC220.2 RC227.2 RC268.2 RC311.2 RC316.2 RC324.2 RC337.2 RC338.2 RC349.2 RC364.2 RC365.2 RC372.2 RC393.2 RC394.2 RC395.2 RC396.2 RC397.2 RC401.2 RC411.2 RC436.1 RC501.2 RC502.2 RC509.2 RC552.2 RC554.2 RC556.2 RC558.2 RD28.2 RD29.2 RD31.2 RD32.2 RD38.2 RD39.2 RD40.2 RD41.2 RD70.2 RD71.2 RD72.2 RD73.2 RD77.2 RD78.2 RE20.2 RE55.2 RE56.2 RE58.2 RE65.2 RE77.2 RE85.2 RE86.2 RE93.2 RE95.2 RE313.2 RE342.2 RE501.2 RE503.2 RE528.2 RE541.1 RI14.1 RPE10.5 RPE10.6 RPE10.7 RPE10.8 RR4.1 RT21.2 RT22.2 RT23.2 RT24.2 RT25.2 RT26.2 RT27.2 RT28.2 RT29.2 RT30.2 RT31.2 RT32.2 RT33.2 RT34.2 RT35.2 RT36.2 RT37.2 RT38.2 RT41.2 RT42.2 RT63.2 RT64.2 RT65.2 RT71.2 RT81.2 RT82.2 RT86.2 RT96.2 RT99.2 RT100.2 RT101.2 RT103.2 RT124.2 RT125.2 RT126.2 RT127.2 RT128.2 RT129.2 RT159.1 RT160.2 RT161.2 RT167.2 RT182.2 RT193.2 RT194.2 RT195.2 RT196.2 RT205.2 RT218.2 RT219.2 RT220.2 RT343.2 RT344.2 RT377.2 RT378.2 RT390.2 RT393.2 RT440.1 RT442.1 RT447.2 RT449.2 RV1.2 RV2.2 RV3.1 RV21.2 RV305.2 RZ10.1 RZ38.2 RZ40.1 RZ62.2 RZ122.2 RZ334.2 RZ511.2 ST1.1(TP-1) ST2.1(TP-1) SW1.4 SW1.5 SW3.1 SW3.3 UA1.49 UC1.A5 UC1.A67 UC1.A70 UC1.AA2 UC1.AA4 UC1.AA65 UC1.AA68 UC1.AB8 UC1.AB15 UC1.AB16 UC1.AB18 UC1.AB21 UC1.AD8 UC1.AD13 UC1.AD16 UC1.AD19 UC1.AD20 UC1.AD21 UC1.AD62 UC1.AE64 UC1.AE65 UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 UC1.AF1 UC1.AF2 UC1.AF4 UC1.AF10 UC1.AF15 UC1.AF17 UC1.AF63 UC1.AG16 UC1.AG17 UC1.AG18 UC1.AG19 UC1.AG20 UC1.AG21 UC1.AG71 UC1.AH6 UC1.AH13 UC1.AH63 UC1.AH64 UC1.AH67 UC1.AJ4 UC1.AJ15 UC1.AJ18 UC1.AJ20 UC1.AK8 UC1.AK11 UC1.AK16 UC1.AK18 UC1.AK21 UC1.AK22 UC1.AK27 UC1.AK63 UC1.AK68 UC1.AK69 UC1.AL2 UC1.AL4 UC1.AL28 UC1.AL32 UC1.AL35 UC1.AL38 UC1.AL45 UC1.AL48 UC1.AL52 UC1.AL55 UC1.AL58 UC1.AL64 UC1.AL65 UC1.AL66 UC1.AM8 UC1.AM13 UC1.AM21 UC1.AM25 UC1.AM27 UC1.AM43 UC1.AM45 UC1.AM46 UC1.AM55 UC1.AM60 UC1.AM61 UC1.AM68 UC1.AM71 UC1.AN20 UC1.AN23 UC1.AN28 UC1.AN30 UC1.AN32 UC1.AN33 UC1.AN35 UC1.AN37 UC1.AN38 UC1.AN40 UC1.AN42 UC1.AN58 UC1.AN63 UC1.AP10 UC1.AP18 UC1.AP20 UC1.AP23 UC1.AP28 UC1.AP32 UC1.AP35 UC1.AP38 UC1.AP42 UC1.AP58 UC1.AP63 UC1.AP68 UC1.AP70 UC1.AR5 UC1.AR8 UC1.AR11 UC1.AR15 UC1.AR16 UC1.AR20 UC1.AR23 UC1.AR28 UC1.AR35 UC1.AR42 UC1.AR43 UC1.AR45 UC1.AR46 UC1.AR48 UC1.AR50 UC1.AR52 UC1.AR53 UC1.AR55 UC1.AR58 UC1.AR63 UC1.AT2 UC1.AT4 UC1.AT20 UC1.AT23 UC1.AT28 UC1.AT35 UC1.AT42 UC1.AT56 UC1.AT58 UC1.AT63 UC1.AT68 UC1.AT71 UC1.AU10 UC1.AU15 UC1.AU20 UC1.AU32 UC1.AU38 UC1.AV1 UC1.AV68 UC1.AV69 UC1.AV70 UC1.AV71 UC1.AW6 UC1.AW8 UC1.AW10 UC1.AW12 UC1.AW14 UC1.AW16 UC1.AW18 UC1.AW21 UC1.AW23 UC1.AW26 UC1.AW28 UC1.AW30 UC1.AW32 UC1.AW34 UC1.AW36 UC1.AW38 UC1.AW41 UC1.AW43 UC1.AW45 UC1.AW47 UC1.AW49 UC1.AW51 UC1.AW53 UC1.AW55 UC1.AW57 UC1.AW60 UC1.AW62 UC1.AW64 UC1.AW66 UC1.AY3 UC1.AY66 UC1.AY71 UC1.B10 UC1.B14 UC1.B18 UC1.B22 UC1.B30 UC1.B34 UC1.B39 UC1.B44 UC1.B48 UC1.B53 UC1.B58 UC1.B62 UC1.B66 UC1.B71 UC1.BA1 UC1.BA2 UC1.BA6 UC1.BA10 UC1.BA14 UC1.BA18 UC1.BA23 UC1.BA28 UC1.BA32 UC1.BA36 UC1.BA41 UC1.BA45 UC1.BA49 UC1.BA53 UC1.BA57 UC1.BA62 UC1.BA66 UC1.BA71 UC1.BB6 UC1.BB18 UC1.BB26 UC1.BB30 UC1.BB34 UC1.BB38 UC1.BB43 UC1.BB55 UC1.BB60 UC1.BB64 UC1.BB67 UC1.BB70 UC1.C1 UC1.C5 UC1.C25 UC1.D6 UC1.D10 UC1.D11 UC1.D14 UC1.D18 UC1.D22 UC1.D25 UC1.D26 UC1.D30 UC1.D34 UC1.D39 UC1.D44 UC1.D45 UC1.D47 UC1.D48 UC1.D53 UC1.D58 UC1.D62 UC1.D66 UC1.D69 UC1.E6 UC1.E11 UC1.E15 UC1.E18 UC1.E21 UC1.E46 UC1.E50 UC1.E53 UC1.E56 UC1.E65 UC1.E71 UC1.F1 UC1.F2 UC1.F4 UC1.F8 UC1.F13 UC1.F22 UC1.F23 UC1.F27 UC1.F28 UC1.F32 UC1.F33 UC1.F35 UC1.F37 UC1.F38 UC1.F40 UC1.F42 UC1.F68 UC1.G5 UC1.G6 UC1.G10 UC1.G22 UC1.G43 UC1.G45 UC1.G48 UC1.G52 UC1.G55 UC1.G58 UC1.G60 UC1.G63 UC1.G66 UC1.H15 UC1.H18 UC1.H71 UC1.J8 UC1.J11 UC1.J13 UC1.J25 UC1.J28 UC1.J32 UC1.J35 UC1.J38 UC1.J42 UC1.K16 UC1.K18 UC1.K22 UC1.K61 UC1.K63 UC1.K64 UC1.K65 UC1.K66 UC1.K67 UC1.K68 UC1.K70 UC1.K71 UC1.L2 UC1.L4 UC1.L8 UC1.L11 UC1.L16 UC1.L17 UC1.L18 UC1.L20 UC1.N6 UC1.N10 UC1.N13 UC1.N19 UC1.N21 UC1.N65 UC1.N68 UC1.P17 UC1.P19 UC1.P20 UC1.P21 UC1.R6 UC1.R13 UC1.T2 UC1.T4 UC1.T15 UC1.T17 UC1.T18 UC1.T21 UC1.U10 UC1.U63 UC1.U64 UC1.U66 UC1.U67 UC1.U69 UC1.U70 UC1.V16 UC1.V17 UC1.V18 UC1.W6 UC1.W9 UC1.W13 UC1.Y17 UC1.Y19 UC1.Y20 UC1.Y21 UC5.4 UC6.4 UC7.3 UC8.7 UC8.15 UC12.3 UD1.B2 UD1.B5 UD1.B6 UD1.B12 UD1.C3 UD1.C5 UD1.C6 UD1.D3 UD1.D8 UD1.D12 UD1.E4 UD1.E5 UD1.E6 UD1.F4 UD1.F5 UD1.F6 UD1.F12 UD1.G3 UD1.G4 UD1.G6 UD1.G8 UD1.G9 UD1.H2 UD1.H10 UD1.J4 UD1.J12 UD1.K2 UD1.K10 UD1.L6 UD1.L8 UD1.L9 UD1.M4 UD1.M5 UD1.M6 UD1.M12 UD1.N4 UD1.N5 UD1.N6 UD1.P3 UD1.P8 UD1.P12 UD1.R4 UD1.R5 UD1.R6 UD1.T2 UD1.T3 UD1.T4 UD1.T5 UD1.T6 UD1.T12 UD2.B2 UD2.B5 UD2.B6 UD2.B12 UD2.C3 UD2.C5 UD2.C6 UD2.D3 UD2.D8 UD2.D12 UD2.E4 UD2.E5 UD2.E6 UD2.F4 UD2.F5 UD2.F6 UD2.F12 UD2.G3 UD2.G4 UD2.G6 UD2.G8 UD2.G9 UD2.H2 UD2.H10 UD2.J4 UD2.J12 UD2.K2 UD2.K10 UD2.L6 UD2.L8 UD2.L9 UD2.M4 UD2.M5 UD2.M6 UD2.M12 UD2.N4 UD2.N5 UD2.N6 UD2.P3 UD2.P8 UD2.P12 UD2.R4 UD2.R5 UD2.R6 UD2.T2 UD2.T3 UD2.T4 UD2.T5 UD2.T6 UD2.T12 UD3.B2 UD3.B5 UD3.B6 UD3.B12 UD3.C3 UD3.C5 UD3.C6 UD3.D3 UD3.D8 UD3.D12 UD3.E4 UD3.E5 UD3.E6 UD3.F4 UD3.F5 UD3.F6 UD3.F12 UD3.G3 UD3.G4 UD3.G6 UD3.G8 UD3.G9 UD3.H2 UD3.H10 UD3.J4 UD3.J12 UD3.K2 UD3.K10 UD3.L6 UD3.L8 UD3.L9 UD3.M4 UD3.M5 UD3.M6 UD3.M12 UD3.N4 UD3.N5 UD3.N6 UD3.P3 UD3.P8 UD3.P12 UD3.R4 UD3.R5 UD3.R6 UD3.T2 UD3.T3 UD3.T4 UD3.T5 UD3.T6 UD3.T12 UD4.B2 UD4.B5 UD4.B6 UD4.B12 UD4.C3 UD4.C5 UD4.C6 UD4.D3 UD4.D8 UD4.D12 UD4.E4 UD4.E5 UD4.E6 UD4.F4 UD4.F5 UD4.F6 UD4.F12 UD4.G3 UD4.G4 UD4.G6 UD4.G8 UD4.G9 UD4.H2 UD4.H10 UD4.J4 UD4.J12 UD4.K2 UD4.K10 UD4.L6 UD4.L8 UD4.L9 UD4.M4 UD4.M5 UD4.M6 UD4.M12 UD4.N4 UD4.N5 UD4.N6 UD4.P3 UD4.P8 UD4.P12 UD4.R4 UD4.R5 UD4.R6 UD4.T2 UD4.T3 UD4.T4 UD4.T5 UD4.T6 UD4.T12 UD5.3 UE1.A6 UE1.A13 UE1.C4 UE1.E6 UE1.H4 UE2.17 UE2.21 UE3.3 UE4.3 UE5.3 UE6.3 UE10.3 UI1.2 UI3.14 UI3.17 UR1.33 UT1.A1 UT1.A6 UT1.A8 UT1.A10 UT1.A12 UT1.A14 UT1.A16 UT1.A18 UT1.A20 UT1.A22 UT1.AA22 UT1.AA23 UT1.AB1 UT1.AB2 UT1.AB6 UT1.AB8 UT1.AB10 UT1.AB12 UT1.AB14 UT1.AB16 UT1.AB18 UT1.AB20 UT1.AB22 UT1.AC1 UT1.AC2 UT1.AC6 UT1.AC8 UT1.AC10 UT1.AC12 UT1.AC14 UT1.AC16 UT1.AC18 UT1.AC20 UT1.AC22 UT1.B1 UT1.B2 UT1.B6 UT1.B8 UT1.B10 UT1.B12 UT1.B14 UT1.B16 UT1.B18 UT1.B20 UT1.B22 UT1.C22 UT1.C23 UT1.D5 UT1.D6 UT1.D8 UT1.D9 UT1.D11 UT1.D12 UT1.D13 UT1.D15 UT1.D16 UT1.D18 UT1.E4 UT1.E5 UT1.E6 UT1.E8 UT1.E9 UT1.E11 UT1.E15 UT1.E16 UT1.E22 UT1.E23 UT1.F5 UT1.F6 UT1.F9 UT1.F16 UT1.F20 UT1.G22 UT1.G23 UT1.H1 UT1.H2 UT1.H5 UT1.H8 UT1.H12 UT1.H13 UT1.H15 UT1.H16 UT1.H20 UT1.J5 UT1.J8 UT1.J12 UT1.J13 UT1.J15 UT1.J18 UT1.J19 UT1.J20 UT1.J22 UT1.J23 UT1.K1 UT1.K2 UT1.L5 UT1.L13 UT1.L15 UT1.L20 UT1.L22 UT1.L23 UT1.M1 UT1.M2 UT1.M5 UT1.M11 UT1.M12 UT1.M19 UT1.M20 UT1.N5 UT1.N8 UT1.N9 UT1.N11 UT1.N12 UT1.N13 UT1.N15 UT1.N20 UT1.N22 UT1.N23 UT1.P1 UT1.P2 UT1.R5 UT1.R18 UT1.R19 UT1.R20 UT1.R22 UT1.R23 UT1.T1 UT1.T2 UT1.T5 UT1.T6 UT1.T8 UT1.T9 UT1.T13 UT1.T15 UT1.T16 UT1.T18 UT1.T20 UT1.U22 UT1.U23 UT1.V5 UT1.V6 UT1.V8 UT1.V9 UT1.V15 UT1.V16 UT1.V20 UT1.W5 UT1.W6 UT1.W8 UT1.W9 UT1.W13 UT1.W18 UT1.W20 UT1.W22 UT1.W23 UT1.Y9 UT1.Y13 UT1.Y20 UT2.4 UT5.A1 UT5.A6 UT5.A7 UT5.A8 UT5.B7 UT5.B8 UT5.D8 UT5.E5 UT5.E6 UT5.E7 UT5.E8 UT5.F5 UT5.F6 UT5.F7 UT5.F8 UT5.G5 UT5.G6 UT5.G7 UT5.G8 UT5.H4 UT5.H5 UT5.H8 UT5.L1 UT6.4 UT7.4 UT7.9 UT8.2 UT11.A1 UT11.A6 UT11.A7 UT11.A8 UT11.B7 UT11.B8 UT11.D8 UT11.E5 UT11.E6 UT11.E7 UT11.E8 UT11.F5 UT11.F6 UT11.F7 UT11.F8 UT11.G5 UT11.G6 UT11.G7 UT11.G8 UT11.H4 UT11.H5 UT11.H8 UT11.L1 UT12.2 UT32.2 UT33.2 UV2.2 UV24.2 UZ1.1 UZ2.11 UZ2.15 UZ3.11 UZ3.15 UZ4.11 UZ4.15 UZ5.11 UZ5.15 UZ6.3 UZ8.5 UZ8.9 UZ12.9 UZ12.16 UZ12.23 UZ12.32 UZ12.33 UZ19.5 UZ21.5 UZ26.5 UZ28.1 UZ29.2 UZ29.5 UZ29.11 UZ29.20 UZ29.21 UZ34.3 UZ35.3 UZ41.5 UZ41.9 YT1.2 YT1.4
GNDA: CA1.1 CA2.2 CA3.2 CA4.2 CA8.2 CA9.2 CA25.2 CA35.2 CA41.2 CA49.2 CA51.2 CA52.2 CA57.2 CA58.2 CA73.2 CA74.2 DA2.2 JHP1.5 JHP1.7 PJP19.1 RA35.1 RA36.1 RA37.1 RA44.2 UA1.18 UA1.37
VBAT1_ISL9538: PC950.2 PR940.2 PU901.31
VBUS1_ECOK: RE603.2 UE1.M6
VBUS1_ECOK_R: PR1221.2 PR1276.1 RE602.1
VBUS2_ECOK: RE602.2 UE1.N3
VBUS2_ECOK_R: PR1255.2 PR1275.1 RE603.1
VCC_GT: PC669.1 PR1300.2 PU612.3
VCC_GT_SENSE: PC639.1 PC651.2 PC653.1 PR648.1 RC161.1 UC1.J70
VCC_IA1: PC1335.1 PR688.2 PU610.3
VCC_IA2: PC677.1 PR691.2 PU613.3
VCCDSW_EN: CE66.1 RC445.1 UE1.M7
VCCDSW_EN_GPIO: DC1.2 QC6.2 RC431.1 RC445.2
VCCDSW_EN_Q: DC1.1 DC2.2 RC442.1
VCCIO_SENSE: PR422.2 RC165.1 UC1.AM23
VCCSA_B+: PC608.1 PC612.1 PJP603.1 PQ614.2 PQ614.3 PQ614.4 PQ614.10
VCCSENSE: PC617.1 PC618.2 PC620.1 PR622.1 RC140.1 UC1.E32
VCCST_PWRGD: CC301.1 RC71.1 RC78.1 RC123.1 RE308.1 UE4.4
VCCST_PWRGD_CPU: RC78.2 UC1.B65
VCCST_PWRGD_EC: RE308.2 RE552.2 UE1.K10
VCCSTG_EN: RZ120.1 RZ320.2 UZ19.4 UZ35.4
VDD_ISL9538: PC933.1 PR915.2 PR918.2 PR919.1 PU901.18
VDDP_ISL9538: PC932.2 PR915.1 PU901.8
VIN_1.8VALW: PC502.1 PJP501.2 PL502.2 PU501.4
VIN_1V_PRIM: PC412.1 PC413.1 PC417.1 PC418.1 PC421.1 PL406.2 PL408.2 PU402.10 PU402.11 PU402.12
VIN_1VS_VCCIO: PC403.1 PC404.1 PC408.1 PC409.1 PL405.2 PL407.2 PU401.10 PU401.11 PU401.12
VSS_GT_SENSE: PC653.2 PC654.2 PU602.18 RC163.1 UC1.J69
VSSIO_SENSE: PR412.2 RC167.1 UC1.AM22
VSSSENSE: PC619.2 PC620.2 PU602.6 RC141.1 UC1.E33
32KHZ_OUT: CE54.1 UE1.F3
+AC1_IN: PC1204.2 PC1205.1 PJP1201.2 PQ1200.1 PQ1200.2 PQ1200.3 PQ1202.1 PQ1202.2 PQ1202.3 PQ1225.3 PR1203.1 PR1206.1 PR1277.1 PR1287.1
+AC2_IN: PC1216.2 PC1217.1 PJP1202.2 PQ1210.1 PQ1210.2 PQ1210.3 PQ1211.1 PQ1211.2 PQ1211.3 PQ1227.3 PR1236.1 PR1237.1 PR1280.1 PR1288.1
+BL_PWR_SRC: CV11.1 CV15.1 CV24.1 CV25.1 JEDP1.12 JEDP1.13 JEDP1.14 QV1.1 QV1.2 QV1.5 QV1.6
+CHARGER_SRC: PC902.1 PC903.1 PC904.1 PC905.1 PC906.1 PC909.1 PC911.1 PC951.1 PC952.1 PJP901.2 PL901.2 PQ905.3 PQ905.4 PQ905.9
+COINCELL: JRTC1.1 PC2.2 PR2.1
+DCPRTC: CC214.1 UC1.BB10
+DDR_VREF_A_DQ: CD40.1 RD37.1 UC1.AY68
+DDR_VREF_B_DQ: CD67.1 RD76.1 UC1.BA67
+DDR_VREF_CA: CD39.1 RD36.1 UC1.AY67
+DV_12S: CR9.1 CR10.1 UR1.21
+EC_DEBUG_VCC: JDEG1.1 RE71.2
+EDP_VDD: PJP12.2 UV24.1
+LCDVDD: CV12.1 CV16.1 CV20.1 CV21.1 JEDP1.25 JEDP1.26 PJP12.1 RV7.2
+MIC2-VREFO-L: RA5.2 UA1.27
+MIC2-VREFO-R: RA6.2 UA1.28
+PBATT: PL1.2 PL2.2 PQ906.5 PR940.1
+PECI_VREF: CE25.1 RE59.2 UE1.J11
+PWR_SRC: CV13.2 CZ3.1 JIR1.5 JIR1.6 PC133.1 PC134.1 PC135.1 PC136.1 PC137.1 PC138.1 PC139.1 PC140.1 PC689.1 PC690.1 PC691.1 PC692.1 PC913.1 PC914.1 PC915.1 PC916.1 PC917.1 PC918.1 PC919.1 PC920.1 PC928.1 PC929.1 PC956.1 PC957.1 PC958.1 PC959.1 PC960.1 PC961.1 PC962.1 PC963.1 PC986.1 PC987.1 PC988.1 PC989.1 PC990.1 PD901.2 PJP100.1 PJP101.1 PJP202.1 PJP301.1 PJP601.2 PL602.2 PQ904.3 PQ904.4 PQ904.9 PR102.2 PR917.1 PR929.2 QV1.4 RV4.2 RZ85.1
+PWR_SRC_AC: PD906.1 PJP901.1 PL901.1 PR901.4
+PWR_SRC_R: CZ78.2 JUSH1.1 RZ85.2
+RREF: RR4.2 UR1.7
+RTC_CELL: PC3.1 PD3.1 QE15.3 RA55.2 RE31.1 RE32.2 RE324.2 RE507.2 RE508.2 RE551.2
+RTC_CELL_PCH: CC213.1 CC270.1 CE63.1 QE15.1 RC56.2 RC57.2 RC69.2 RE546.1 RE551.1 UC1.AK19 UC1.BB14
+RTC_CELL_VBAT: CE11.1 RE32.1 UE1.A2
+SD40_AV12: CR8.1 UR1.24
+SDC_IN: PC1206.1 PC1218.1 PD1202.1 PD1205.1 PQ1203.1 PQ1203.2 PQ1203.3 PQ1204.3 PQ1212.1 PQ1212.2 PQ1212.3 PQ1213.3 PR901.1 PR943.1 PR944.1 PR1202.2 PR1204.1 PR1235.2 PR1238.1
+SDREG2: CR15.1 UR1.14
+SIM_PWR: CZ37.1 CZ41.1 CZ304.1 JNGFF2.36 JSIM1.1 RZ335.1
+TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
+TBTA_LDO_BMC: CT71.1 UT5.E1
+TBTA_SENSE: RT397.2 UT5.A10 UT5.B10
+TBTA_VBUS: CT99.1 CT100.1 CT101.1 CT102.1 CT189.1 CT190.1 DT4.2 DT4.3 JUSBC1.A4 JUSBC1.A9 JUSBC1.B4 JUSBC1.B9 PC1201.1 PC1283.1 PL1201.1 PL1203.1
+TBTA_VBUS_1: CT82.1 CT94.1 PC1202.1 PC1203.1 PJP1201.1 PL1201.2 PL1203.2 PQ1200.5 PR1201.1 PR1215.1 RT397.1 UT5.H11 UT5.J10 UT5.J11 UT5.K11 UT8.1
+TBTB_LDO_BMC: CT147.1 UT11.E1
+TBTB_SENSE: RT398.2 UT11.A10 UT11.B10
+TBTB_VBUS: CT163.1 CT164.1 CT165.1 CT166.1 CT191.1 CT192.1 DT21.2 DT21.3 JUSBC2.A4 JUSBC2.A9 JUSBC2.B4 JUSBC2.B9 PC1213.1 PC1284.1 PL1202.1 PL1204.1
+TBTB_VBUS_1: CT151.1 CT167.1 PC1214.1 PC1215.1 PJP1202.1 PL1202.2 PL1204.2 PQ1210.5 PR1234.1 PR1252.1 RT398.1 UT11.H11 UT11.J10 UT11.J11 UT11.K11 UT12.1
+USB_EX2_PWR: CI1.1 CI3.1 CI45.1 CI46.1 JUSB2.1 UI1.1
+UZ12_TPM: CZ50.1 CZ75.1 RZ89.2 RZ367.2 UZ12.8
+UZ12_VHIO: CZ53.1 CZ54.1 CZ55.1 RZ365.1 RZ366.1 UZ12.14 UZ12.22
+VCHGR: PC935.1 PC936.1 PQ906.1 PQ906.2 PQ906.3 PR917.4
+VHDMI_IN: CV39.1 RV313.2 RV314.2 UV2.1
+VHDMI_VCC: CV40.1 CV41.1 JHDMI1.18 RV315.2 RV316.2 UV2.3
+VR_CAP: CE31.1 UE1.C10 UE1.J1
+VREFCA: CD10.2 CD11.2 CD46.2 CD47.2 RD34.2 RD36.2 RD38.1 UD1.H4 UD2.H4 UD3.H4 UD4.H4
+VREFDQ_A: CD20.1 CD21.1 RD35.2 RD37.2 RD39.1 UD1.J11 UD2.J11
+VREFDQ_B: CD53.1 CD54.1 RD75.2 RD76.2 RD77.1 UD3.J11 UD4.J11
+Z4012: PD3.2 PR2.2
AC1_DISC#: PR939.1 PR1273.1 RT72.2
AC1_DISC#_R: RT72.1 UT5.G11
AC2_DISC#: PR941.1 PR1274.1 RT168.2
AC2_DISC#_R: RT168.1 UT11.G11
AC_DIS: PQ909.2 PR927.1 RE83.1 UE1.H12
AC_DISC#: PC1285.2 PQ1221.3 PQ1221.6 PQ1222.3 PR1210.2 PR1243.2 PR1291.1 PR1292.1 UE1.E13
AC_PRESENT: RC243.1 UC1.AY15 UE1.K8
ACAV_IN: PR946.2 PR953.1 UE1.C7
ACAV_IN1: PQ909.1 PR918.1 PR925.1 PR928.1 PR942.1
ACC1_I2C0_SCL: JSEN2.3 RZ137.2
ACC1_I2C0_SDA: JSEN2.5 RZ140.2
ACC1_INT1: JSEN2.7 RZ143.2
ACC1_SA0: LGA1.3 RZ121.2 RZ122.1
ACIN_ISL9538: PC955.1 PR944.2 PR945.1 PU901.19
ACOK_ISL9538: PR928.2 PU901.24
ADP_ISL9538: PR943.2 PU901.16
ALS_I2C0_SCL: JSEN2.4 QZ14.1 RZ138.2
ALS_I2C0_SDA: JSEN2.6 QZ14.4 RZ141.2
ALS_INT#: JSEN2.9 RZ145.2
ALW_PWRGD_3V_5V: DC2.1 PR119.2 PR120.2 UZ6.2
ALWON: PR114.1 UE1.A5
AR_DET#: RC400.1 RC401.1 UC1.P4
AR_DP1_CTRL_CLK: QV3.1 RT13.1 RT125.1 UT1.Y2
AR_DP1_CTRL_DATA: QV3.4 RT12.1 RT124.1 UT1.Y1
AR_DP1_HPD: QV5.3 RV20.1 UT1.G1
AR_DP1_N0: CT201.2 CV32.1 UT1.R1
AR_DP1_N1: CT202.2 CV34.1 UT1.N1
AR_DP1_N2: CT203.2 CV36.1 UT1.L1
AR_DP1_N3: CT204.2 CV38.1 UT1.J1
AR_DP1_P0: CT201.1 CV31.1 UT1.R2
AR_DP1_P1: CT202.1 CV33.1 UT1.N2
AR_DP1_P2: CT203.1 CV35.1 UT1.L2
AR_DP1_P3: CT204.1 CV37.1 UT1.J2
AUD_HP_NB_SENSE: DA2.3 JHP1.6 RA60.2
AUD_HP_OUT_L: RA7.2 RA52.1
AUD_HP_OUT_L1: CA3.1 DA1.3 JHP1.1 RA52.2
AUD_HP_OUT_R: RA8.2 RA53.1
AUD_HP_OUT_R1: CA2.1 DA1.2 JHP1.2 RA53.2
AUD_PC_BEEP: CA27.2 CA28.2 UA1.32
AUD_PWR_EN: RC279.1 UC1.W8 UZ5.3 UZ5.5
AUD_SENSE_A: CA41.1 RA59.2 RA60.1 UA1.1
AUD_SENSE_B: RA61.2 UA1.48
AUX_EN_WOWL: DZ9.2 RZ70.1 UE1.D3
BAT1_LED#: RZ28.1 UE1.D10
BAT2_LED#: QZ2.1 RZ25.1 UE1.D11
BAT2_LED#_R: QZ2.3 QZ2.6 QZ3.2
BATT_WHITE#: JLED1.3 QZ3.3 RZ25.2
BATT_YELLOW#: JLED1.2 RZ28.2
BC_CLK_ECE1117: CZ87.1 JKBTP1.10 UE1.D13
BC_DAT_ECE1117: CZ86.1 JKBTP1.8 RE365.1 UE1.D12
BC_INT#_ECE1117: CZ85.1 JKBTP1.7 UE1.E2
BCM5882_ALERT#: JUSH1.13 RE532.1 UE1.G10
BEEP: RA13.2 UE1.H11
BEEP_R: CA28.1 CA62.1 RA13.1 RA45.1
BGATE_ISL9538: PC937.2 PQ906.4 PU901.32
BIA_PWM: DV1.1 LV1.2 RV1.1
BIA_PWM_EC: DV1.2 UE1.N1
BL_PWR_SRC_ON: CV13.1 CV14.1 QV1.3 RV4.1 RV5.1
BOARD_ID: CE40.1 RE79.2 UE1.J13
BOOT1_ISL9538: PR914.1 PU901.12
BOOT2_ISL9538: PC934.2 PU901.4
BREATH_LED#: RZ32.1 UE1.C11
BREATH_WHITE_LED_SNIFF#: JPWR1.5 RZ32.2
BST_3V: PR100.1 PU100.1
BST_5V: PR111.1 PU102.1
BST_+1VALWP: PR304.1 PU301.1
BST_+1VALWP_C: PC304.1 PR304.2
BT_RADIO_DIS#: DZ2.1 RE11.1 UE1.C2
BT_RADIO_DIS#_R: DZ2.2 JNGFF1.54
CAM_MIC_CBL_DET#: JEDP1.9 RPC5.3 UC1.AB11
CFG0: JXDP1.9 RC113.1 RC126.1 UC1.E68
CFG1: JXDP1.11 RC112.1 UC1.B67
CFG2: JXDP1.15 UC1.D65
CFG3: JXDP1.17 RC110.1 RC121.2 UC1.D67
CFG4: JXDP1.27 RC109.1 UC1.E70
CFG5: JXDP1.29 UC1.C68
CFG6: JXDP1.33 UC1.D68
CFG7: JXDP1.35 UC1.C67
CFG8: JXDP1.10 UC1.F71
CFG9: JXDP1.12 UC1.G69
CFG10: JXDP1.16 UC1.F70
CFG11: JXDP1.18 UC1.G68
CFG12: JXDP1.28 UC1.H70
CFG13: JXDP1.30 UC1.G71
CFG14: JXDP1.34 UC1.H69
CFG15: JXDP1.36 UC1.G70
CFG16: JXDP1.6 UC1.E63
CFG17: JXDP1.4 UC1.F63
CFG18: JXDP1.24 UC1.E66
CFG19: JXDP1.22 UC1.F66
CFG_RCOMP: RC114.1 UC1.E60
CLK_ITPXDP_N: RC297.1 UC1.F43
CLK_ITPXDP_N_R: JXDP1.42 RC297.2
CLK_ITPXDP_P: RC298.1 UC1.E43
CLK_ITPXDP_P_R: JXDP1.40 RC298.2
CLK_PCIE_N0: JNGFF2.53 UC1.D42
CLK_PCIE_N1: JNGFF1.49 UC1.B42
CLK_PCIE_N3: JNGFF3.53 UC1.D40
CLK_PCIE_N5: UC1.E40 UT1.T19
CLK_PCIE_P0: JNGFF2.55 UC1.C42
CLK_PCIE_P1: JNGFF1.47 UC1.A42
CLK_PCIE_P3: JNGFF3.55 UC1.C40
CLK_PCIE_P5: UC1.E38 UT1.V19
CLK_TP_SIO_I2C_DAT: CZ81.1 RZ23.2 RZ348.2 UE1.E10
CLK_TP_SIO_R: CZ89.1 JKBTP1.14 RZ19.2 RZ23.1
CLKREQ_PCIE#0: JNGFF2.52 RC373.2
CLKREQ_PCIE#0_R: RC189.1 RC373.1 UC1.AR10
CLKREQ_PCIE#1: JNGFF1.53 RC374.2
CLKREQ_PCIE#1_R: RC47.1 RC374.1 UC1.AT7
CLKREQ_PCIE#2_R: RC50.1 RT454.2 RT456.1 UC1.AT8
CLKREQ_PCIE#3: JNGFF3.52 RC376.2
CLKREQ_PCIE#3_R: RC59.1 RC376.1 UC1.AT10
CLKREQ_PCIE#4_R: RC51.1 UC1.AU8
CLKREQ_PCIE#5: RC378.2 UT1.AC5
CLKREQ_PCIE#5_R: RC190.1 RC378.1 UC1.AU7
CLKRUN#: RC27.1 UC1.AW11
CMOUT: PQ1222.5 PQ1222.6 PQ1228.2 PR951.1
COMP_GT: PC636.2 PR639.2 PU602.16
COMP_ISL9538: PC943.1 PR934.1 PU901.28
COMP_VSA: PC628.1 PR630.1 PU602.24
CONTACTLESS_DET#: DZ8.2 RC278.1 UC1.W11
CONTACTLESS_DET#_R: DZ8.1 JUSH1.23
CORE_VID0: PR408.1 UC1.AN11
CORE_VID1: PR411.1 UC1.AN13
CPU_B+: PC606.1 PC656.1 PC657.1 PC658.1 PC659.1 PC660.1 PC672.1 PC673.1 PC682.1 PC683.1 PC684.1 PC686.1 PC688.1 PC693.1 PC694.1 PC695.1 PC696.1 PC697.1 PJP601.1 PJP602.2 PJP603.2 PL602.1 PR603.2 PU610.8 PU610.9 PU613.8 PU613.9
CPU_DP1_AUXN: CT19.1 UC1.G50
CPU_DP1_AUXN_C: CT19.2 UT1.W11
CPU_DP1_AUXP: CT18.1 UC1.F50
CPU_DP1_AUXP_C: CT18.2 UT1.Y11
CPU_DP1_CTRL_CLK: RC175.1 RT341.1 UC1.L13
CPU_DP1_CTRL_DATA: RC178.1 RT342.1 UC1.L12
CPU_DP1_HPD: RT24.1 UC1.L9 UT1.AA2
CPU_DP1_N0: CT11.1 UC1.E55
CPU_DP1_N0_C: CT11.2 UT1.AC7
CPU_DP1_N1: CT13.1 UC1.E58
CPU_DP1_N1_C: CT13.2 UT1.AC9
CPU_DP1_N2: CT15.1 UC1.F53
CPU_DP1_N2_C: CT15.2 UT1.AC11
CPU_DP1_N3: CT17.1 UC1.F56
CPU_DP1_N3_C: CT17.2 UT1.AC13
CPU_DP1_P0: CT10.1 UC1.F55
CPU_DP1_P0_C: CT10.2 UT1.AB7
CPU_DP1_P1: CT12.1 UC1.F58
CPU_DP1_P1_C: CT12.2 UT1.AB9
CPU_DP1_P2: CT14.1 UC1.G53
CPU_DP1_P2_C: CT14.2 UT1.AB11
CPU_DP1_P3: CT16.1 UC1.G56
CPU_DP1_P3_C: CT16.2 UT1.AB13
CPU_DP2_AUXN: CT184.1 UC1.E48
CPU_DP2_AUXN_C: CT184.2 UT1.W12
CPU_DP2_AUXP: CT178.1 UC1.F48
CPU_DP2_AUXP_C: CT178.2 UT1.Y12
CPU_DP2_CTRL_CLK: RC176.1 UC1.N7
CPU_DP2_CTRL_DATA: RC177.1 UC1.N8
CPU_DP2_HPD: RT29.1 UC1.L7 UT1.Y6
CPU_DP2_N0: CT187.1 UC1.C50
CPU_DP2_N0_C: CT187.2 UT1.AC15
CPU_DP2_N1: CT180.1 UC1.C52
CPU_DP2_N1_C: CT180.2 UT1.AC17
CPU_DP2_N2: CT179.1 UC1.A50
CPU_DP2_N2_C: CT179.2 UT1.AC19
CPU_DP2_N3: CT181.1 UC1.D51
CPU_DP2_N3_C: CT181.2 UT1.AC21
CPU_DP2_P0: CT186.1 UC1.D50
CPU_DP2_P0_C: CT186.2 UT1.AB15
CPU_DP2_P1: CT183.1 UC1.D52
CPU_DP2_P1_C: CT183.2 UT1.AB17
CPU_DP2_P2: CT185.1 UC1.B50
CPU_DP2_P2_C: CT185.2 UT1.AB19
CPU_DP2_P3: CT182.1 UC1.C51
CPU_DP2_P3_C: CT182.2 UT1.AB21
CPU_DP3_AUXN: T1.1(TP-1) UC1.G46
CPU_DP3_AUXP: T2.1(TP-1) UC1.F46
CPU_POPIRCOMP: RC88.1 UC1.AT16
CPU_XDP_PRDY#: JXDP1.5 UC1.D56
CPU_XDP_PREQ#: JXDP1.3 RC138.1 UC1.D61
CPU_XDP_TCLK: JXDP1.57 RC139.1 RC328.2 UC1.B61
CPU_XDP_TDI: RC134.1 UC1.D60 UC8.6
CPU_XDP_TDO: RC135.1 UC1.A61 UC8.3
CPU_XDP_TMS: RC131.1 UC1.C60 UC8.8
CPU_XDP_TRST#: CC308.1 RC136.1 UC1.B59 UC1.C61 UC8.11
CSI2_COMP: RC3.1 UC1.E13
CSIN_ISL9538: PC925.2 PC927.1 PR910.2 PU901.14
CSIP_ISL9538: PC925.1 PC926.1 PR909.2 PU901.15
CSON_ISL9538: PC945.1 PC946.1 PR938.1 PU901.1
CSOP_ISL9538: PC942.1 PC945.2 PR937.1 PU901.2
CV2_ON: JUSH1.3 RE539.2
CV2_ON_R: RE539.1 RPE10.1 UE1.H8
DAT_TP_SIO_I2C_CLK: CZ80.1 RZ22.2 RZ349.2 UE1.C12
DAT_TP_SIO_R: CZ88.1 JKBTP1.13 RZ18.2 RZ22.1
DCIN1_EN: RE601.2 UE1.K4
DCIN1_EN_R: PR1226.1 RE600.1
DCIN2_EN: RE600.2 UE1.L12
DCIN2_EN_R: PR1251.1 RE601.1
DCIN_ISL9538: PC931.2 PR916.1 PU901.17
DDR_A_CAA0: RD1.2 UC1.BA51 UD1.R2
DDR_A_CAA1: RD2.2 UC1.BB54 UD1.P2
DDR_A_CAA2: RD3.2 UC1.BA52 UD1.N2
DDR_A_CAA3: RD4.2 UC1.AY52 UD1.N3
DDR_A_CAA4: RD5.2 UC1.AW52 UD1.M3
DDR_A_CAA5: RD6.2 UC1.AY55 UD1.F3
DDR_A_CAA6: RD7.2 UC1.AW54 UD1.E3
DDR_A_CAA7: RD8.2 UC1.BA54 UD1.E2
DDR_A_CAA8: RD9.2 UC1.BA55 UD1.D2
DDR_A_CAA9: RD10.2 UC1.AY54 UD1.C2
DDR_A_CAB0: RD11.2 UC1.AU46 UD2.R2
DDR_A_CAB1: RD12.2 UC1.AU48 UD2.P2
DDR_A_CAB2: RD13.2 UC1.AT46 UD2.N2
DDR_A_CAB3: RD14.2 UC1.AU50 UD2.N3
DDR_A_CAB4: RD15.2 UC1.AU52 UD2.M3
DDR_A_CAB5: RD16.2 UC1.AY51 UD2.F3
DDR_A_CAB6: RD17.2 UC1.AT48 UD2.E3
DDR_A_CAB7: RD18.2 UC1.AT50 UD2.E2
DDR_A_CAB8: RD19.2 UC1.BB50 UD2.D2
DDR_A_CAB9: RD20.2 UC1.AY50 UD2.C2
DDR_A_CKE0: RD24.1 UC1.BA56 UD1.K3
DDR_A_CKE1: RD25.1 UC1.BB56 UD1.K4
DDR_A_CKE2: RD79.1 UC1.AW56 UD2.K3
DDR_A_CKE3: RD80.1 UC1.AY56 UD2.K4
DDR_A_CLK0: RD27.1 UC1.AT53 UD1.J3
DDR_A_CLK1: RD33.1 UC1.AT55 UD2.J3
DDR_A_CLK#0: RD26.1 UC1.AU53 UD1.J2
DDR_A_CLK#1: RD30.1 UC1.AU55 UD2.J2
DDR_A_CS#0: RD21.1 UC1.AU45 UD1.L3 UD2.L3
DDR_A_CS#1: RD22.1 UC1.AU43 UD1.L4 UD2.L4
DDR_A_D0: UC1.AL71 UD1.M8
DDR_A_D1: UC1.AL68 UD1.M9
DDR_A_D2: UC1.AN68 UD1.N11
DDR_A_D3: UC1.AN69 UD1.P9
DDR_A_D4: UC1.AL70 UD1.M10
DDR_A_D5: UC1.AL69 UD1.N10
DDR_A_D6: UC1.AN70 UD1.M11
DDR_A_D7: UC1.AN71 UD1.N9
DDR_A_D8: UC1.AR70 UD1.R8
DDR_A_D9: UC1.AR68 UD1.T8
DDR_A_D10: UC1.AU71 UD1.R11
DDR_A_D11: UC1.AU68 UD1.R10
DDR_A_D12: UC1.AR71 UD1.T9
DDR_A_D13: UC1.AR69 UD1.R9
DDR_A_D14: UC1.AU70 UD1.T10
DDR_A_D15: UC1.AU69 UD1.T11
DDR_A_D16: UC1.AF65 UD1.C11
DDR_A_D17: UC1.AF64 UD1.B11
DDR_A_D18: UC1.AK65 UD1.C8
DDR_A_D19: UC1.AK64 UD1.B8
DDR_A_D20: UC1.AF66 UD1.C10
DDR_A_D21: UC1.AF67 UD1.B10
DDR_A_D22: UC1.AK67 UD1.C9
DDR_A_D23: UC1.AK66 UD1.B9
DDR_A_D24: UC1.AF70 UD1.D9
DDR_A_D25: UC1.AF68 UD1.E9
DDR_A_D26: UC1.AH71 UD1.F11
DDR_A_D27: UC1.AH68 UD1.E11
DDR_A_D28: UC1.AF71 UD1.F10
DDR_A_D29: UC1.AF69 UD1.E10
DDR_A_D30: UC1.AH70 UD1.F9
DDR_A_D31: UC1.AH69 UD1.F8
DDR_A_D32: UC1.BB65 UD2.M8
DDR_A_D33: UC1.AW65 UD2.M10
DDR_A_D34: UC1.AW63 UD2.N11
DDR_A_D35: UC1.AY63 UD2.M11
DDR_A_D36: UC1.BA65 UD2.N9
DDR_A_D37: UC1.AY65 UD2.P9
DDR_A_D38: UC1.BA63 UD2.N10
DDR_A_D39: UC1.BB63 UD2.M9
DDR_A_D40: UC1.BA61 UD2.F9
DDR_A_D41: UC1.AW61 UD2.E9
DDR_A_D42: UC1.BB59 UD2.F11
DDR_A_D43: UC1.AW59 UD2.F10
DDR_A_D44: UC1.BB61 UD2.F8
DDR_A_D45: UC1.AY61 UD2.D9
DDR_A_D46: UC1.BA59 UD2.E11
DDR_A_D47: UC1.AY59 UD2.E10
DDR_A_D48: UC1.AT66 UD2.T9
DDR_A_D49: UC1.AU66 UD2.R9
DDR_A_D50: UC1.AP65 UD2.R11
DDR_A_D51: UC1.AN65 UD2.R10
DDR_A_D52: UC1.AN66 UD2.T8
DDR_A_D53: UC1.AP66 UD2.R8
DDR_A_D54: UC1.AT65 UD2.T11
DDR_A_D55: UC1.AU65 UD2.T10
DDR_A_D56: UC1.AT61 UD2.C9
DDR_A_D57: UC1.AU61 UD2.B8
DDR_A_D58: UC1.AP60 UD2.B11
DDR_A_D59: UC1.AN60 UD2.B10
DDR_A_D60: UC1.AN61 UD2.C8
DDR_A_D61: UC1.AP61 UD2.B9
DDR_A_D62: UC1.AT60 UD2.C10
DDR_A_D63: UC1.AU60 UD2.C11
DDR_A_DQS0: UC1.AM69 UD1.L10
DDR_A_DQS1: UC1.AT70 UD1.P10
DDR_A_DQS2: UC1.AH65 UD1.D10
DDR_A_DQS3: UC1.AG70 UD1.G10
DDR_A_DQS4: UC1.AY64 UD2.L10
DDR_A_DQS5: UC1.BA60 UD2.G10
DDR_A_DQS6: UC1.AR65 UD2.P10
DDR_A_DQS7: UC1.AR60 UD2.D10
DDR_A_DQS#0: UC1.AM70 UD1.L11
DDR_A_DQS#1: UC1.AT69 UD1.P11
DDR_A_DQS#2: UC1.AH66 UD1.D11
DDR_A_DQS#3: UC1.AG69 UD1.G11
DDR_A_DQS#4: UC1.BA64 UD2.L11
DDR_A_DQS#5: UC1.AY60 UD2.G11
DDR_A_DQS#6: UC1.AR66 UD2.P11
DDR_A_DQS#7: UC1.AR61 UD2.D11
DDR_A_ODT0: RD23.1 UC1.AT45 UD1.J8 UD2.J8
DDR_B_CAA0: RD42.2 UC1.AY48 UD3.R2
DDR_B_CAA1: RD43.2 UC1.AP50 UD3.P2
DDR_B_CAA2: RD44.2 UC1.BA48 UD3.N2
DDR_B_CAA3: RD45.2 UC1.BB48 UD3.N3
DDR_B_CAA4: RD46.2 UC1.AP48 UD3.M3
DDR_B_CAA5: RD47.2 UC1.AP52 UD3.F3
DDR_B_CAA6: RD48.2 UC1.AN50 UD3.E3
DDR_B_CAA7: RD49.2 UC1.AN48 UD3.E2
DDR_B_CAA8: RD50.2 UC1.AN53 UD3.D2
DDR_B_CAA9: RD51.2 UC1.AN52 UD3.C2
DDR_B_CAB0: RD52.2 UC1.BA43 UD4.R2
DDR_B_CAB1: RD53.2 UC1.AY43 UD4.P2
DDR_B_CAB2: RD54.2 UC1.AY44 UD4.N2
DDR_B_CAB3: RD55.2 UC1.AW44 UD4.N3
DDR_B_CAB4: RD56.2 UC1.BB44 UD4.M3
DDR_B_CAB5: RD57.2 UC1.AY47 UD4.F3
DDR_B_CAB6: RD58.2 UC1.BA44 UD4.E3
DDR_B_CAB7: RD59.2 UC1.AW46 UD4.E2
DDR_B_CAB8: RD60.2 UC1.AY46 UD4.D2
DDR_B_CAB9: RD61.2 UC1.BA46 UD4.C2
DDR_B_CKE0: RD65.1 UC1.AN56 UD3.K3
DDR_B_CKE1: RD66.1 UC1.AP55 UD3.K4
DDR_B_CKE2: RD81.1 UC1.AN55 UD4.K3
DDR_B_CKE3: RD82.1 UC1.AP53 UD4.K4
DDR_B_CLK0: RD68.1 UC1.AP45 UD3.J3
DDR_B_CLK1: RD74.1 UC1.AP46 UD4.J3
DDR_B_CLK#0: RD67.1 UC1.AN45 UD3.J2
DDR_B_CLK#1: RD69.1 UC1.AN46 UD4.J2
DDR_B_CS#0: RD62.1 UC1.BB42 UD3.L3 UD4.L3
DDR_B_CS#1: RD63.1 UC1.AY42 UD3.L4 UD4.L4
DDR_B_D0: UC1.AY39 UD3.T9
DDR_B_D1: UC1.AW39 UD3.R8
DDR_B_D2: UC1.AY37 UD3.T10
DDR_B_D3: UC1.AW37 UD3.T8
DDR_B_D4: UC1.BB39 UD3.T11
DDR_B_D5: UC1.BA39 UD3.R10
DDR_B_D6: UC1.BA37 UD3.R9
DDR_B_D7: UC1.BB37 UD3.R11
DDR_B_D8: UC1.AY35 UD3.N10
DDR_B_D9: UC1.AW35 UD3.N11
DDR_B_D10: UC1.AY33 UD3.M9
DDR_B_D11: UC1.AW33 UD3.N9
DDR_B_D12: UC1.BB35 UD3.M10
DDR_B_D13: UC1.BA35 UD3.M11
DDR_B_D14: UC1.BA33 UD3.M8
DDR_B_D15: UC1.BB33 UD3.P9
DDR_B_D16: UC1.AU40 UD3.E10
DDR_B_D17: UC1.AT40 UD3.F8
DDR_B_D18: UC1.AT37 UD3.F11
DDR_B_D19: UC1.AU37 UD3.F10
DDR_B_D20: UC1.AR40 UD3.E9
DDR_B_D21: UC1.AP40 UD3.F9
DDR_B_D22: UC1.AP37 UD3.D9
DDR_B_D23: UC1.AR37 UD3.E11
DDR_B_D24: UC1.AT33 UD4.T9
DDR_B_D25: UC1.AU33 UD4.R8
DDR_B_D26: UC1.AU30 UD4.T10
DDR_B_D27: UC1.AT30 UD4.T11
DDR_B_D28: UC1.AR33 UD4.R9
DDR_B_D29: UC1.AP33 UD4.T8
DDR_B_D30: UC1.AR30 UD4.R11
DDR_B_D31: UC1.AP30 UD4.R10
DDR_B_D32: UC1.AY31 UD3.B9
DDR_B_D33: UC1.AW31 UD3.C11
DDR_B_D34: UC1.AY29 UD3.C9
DDR_B_D35: UC1.AW29 UD3.B10
DDR_B_D36: UC1.BB31 UD3.B8
DDR_B_D37: UC1.BA31 UD3.C8
DDR_B_D38: UC1.BA29 UD3.C10
DDR_B_D39: UC1.BB29 UD3.B11
DDR_B_D40: UC1.AY27 UD4.M10
DDR_B_D41: UC1.AW27 UD4.M8
DDR_B_D42: UC1.AY25 UD4.M9
DDR_B_D43: UC1.AW25 UD4.N10
DDR_B_D44: UC1.BB27 UD4.P9
DDR_B_D45: UC1.BA27 UD4.N9
DDR_B_D46: UC1.BA25 UD4.N11
DDR_B_D47: UC1.BB25 UD4.M11
DDR_B_D48: UC1.AU27 UD4.D9
DDR_B_D49: UC1.AT27 UD4.F9
DDR_B_D50: UC1.AT25 UD4.F10
DDR_B_D51: UC1.AU25 UD4.F11
DDR_B_D52: UC1.AP27 UD4.E9
DDR_B_D53: UC1.AN27 UD4.F8
DDR_B_D54: UC1.AN25 UD4.E11
DDR_B_D55: UC1.AP25 UD4.E10
DDR_B_D56: UC1.AT22 UD4.C9
DDR_B_D57: UC1.AU22 UD4.C11
DDR_B_D58: UC1.AU21 UD4.B11
DDR_B_D59: UC1.AT21 UD4.B10
DDR_B_D60: UC1.AN22 UD4.C8
DDR_B_D61: UC1.AP22 UD4.B9
DDR_B_D62: UC1.AP21 UD4.B8
DDR_B_D63: UC1.AN21 UD4.C10
DDR_B_DQS0: UC1.AY38 UD3.P10
DDR_B_DQS1: UC1.BA34 UD3.L10
DDR_B_DQS2: UC1.AR38 UD3.G10
DDR_B_DQS3: UC1.AR32 UD4.P10
DDR_B_DQS4: UC1.AY30 UD3.D10
DDR_B_DQS5: UC1.BA26 UD4.L10
DDR_B_DQS6: UC1.AR27 UD4.G10
DDR_B_DQS7: UC1.AR21 UD4.D10
DDR_B_DQS#0: UC1.BA38 UD3.P11
DDR_B_DQS#1: UC1.AY34 UD3.L11
DDR_B_DQS#2: UC1.AT38 UD3.G11
DDR_B_DQS#3: UC1.AT32 UD4.P11
DDR_B_DQS#4: UC1.BA30 UD3.D11
DDR_B_DQS#5: UC1.AY26 UD4.L11
DDR_B_DQS#6: UC1.AR25 UD4.G11
DDR_B_DQS#7: UC1.AR22 UD4.D11
DDR_B_ODT0: RD64.1 UC1.BA42 UD3.J8 UD4.J8
DDR_VTT_CTRL: UC1.AW67 UD5.2
DDR_XDP_WAN_SMBCLK: JXDP1.53 QC2.1 RC319.1
DDR_XDP_WAN_SMBDAT: JXDP1.51 QC2.4 RC318.1
DEBUG_TX: JDEG1.9 RE30.2 RE74.2
DISP_ON: DV2.1 JEDP1.17 RV2.1
DISPLAY_HPD_EC#: QV6.1 RV312.2 UE1.L11
DMIC0: CA6.1 JEDP1.2 RA62.2 UA1.5
DMIC_CLK0: CA5.1 CA54.1 JEDP1.4 RA14.1
DMIC_CLK_CODEC: RA14.2 UA1.6
DPSNK0_DDC_CLK: RT14.1 RT126.1 RT341.2 UT1.Y5
DPSNK0_DDC_DATA: RT15.1 RT127.1 RT342.2 UT1.R4
DPSNK1_DDC_CLK: RT128.1 RT336.1 UT1.Y8
DPSNK_RBIAS: RT38.1 UT1.Y18
EC_FPM_EN: JUSH1.5 UE1.D6
EDP_AUXN: CV1.1 UC1.E45
EDP_AUXN_C: CV1.2 JEDP1.29
EDP_AUXP: CV2.1 UC1.F45
EDP_AUXP_C: CV2.2 JEDP1.30
EDP_BIA_PWM: DV1.3 UC1.R11
EDP_COMP: RC2.1 UC1.E52
EDP_HPD: JEDP1.21 RC1.1 RV7.1 UC1.L10
EDP_TXN0: CV4.1 UC1.C47
EDP_TXN0_C: CV4.2 JEDP1.32
EDP_TXN1: CV6.1 UC1.D46
EDP_TXN1_C: CV6.2 JEDP1.34
EDP_TXN2: CV8.1 UC1.A45
EDP_TXN2_C: CV8.2 JEDP1.36
EDP_TXN3: CV10.1 UC1.A47
EDP_TXN3_C: CV10.2 JEDP1.38
EDP_TXP0: CV3.1 UC1.C46
EDP_TXP0_C: CV3.2 JEDP1.31
EDP_TXP1: CV5.1 UC1.C45
EDP_TXP1_C: CV5.2 JEDP1.33
EDP_TXP2: CV7.1 UC1.B45
EDP_TXP2_C: CV7.2 JEDP1.35
EDP_TXP3: CV9.1 UC1.B47
EDP_TXP3_C: CV9.2 JEDP1.37
EDRAM_OPIO_RCOMP: RC90.1 UC1.H66
EMMC_RCOMP: RC4.1 UC1.AT1
EN_1.0V_PRIM_COREP: PC411.1 PR406.2 PR407.1 PU402.13
EN_1.8V: PC513.1 PR513.2 PR514.1 PU503.5
EN_1.8VALW: PC505.1 PR504.2 PR505.1 PU501.1
EN_1VS_VCCIO: PC402.1 PR402.2 PR403.1 PU401.13
EN_+1VALWP: PR302.1 PR312.2 PU301.11
EN_INVPWR: QV2.2 RE55.1 UE1.B2
EN_LCDPWR: DV3.1 RV3.2 UV24.4
EN_PD_HV_1: PQ1224.5 PR1219.1 PR1232.2 PR1254.1 PR1285.2 PR1293.1 RT70.2
EN_PD_HV_1#: PQ1224.2 PQ1224.3 PR1278.2
EN_PD_HV_1_R: RT70.1 UT5.C2
EN_PD_HV_2: PQ1226.5 PR1217.1 PR1245.1 PR1269.2 PR1286.2 PR1294.1 RT166.2
EN_PD_HV_2#: PQ1226.2 PQ1226.3 PR1281.2
EN_PD_HV_2_R: RT166.1 UT11.C2
ENLDO_3V5V: PR102.1 PR103.1 PU100.11 PU102.11
ENVDD_PCH: DV3.3 UC1.U13
EOPIO_RCOMP: RC91.1 UC1.H65
ESPI_ALERT#: RC21.1 UC1.AY11 UE1.H7
ESPI_CLK: RC16.1 UC1.AW9
ESPI_CLK_5105: CC316.1 JESPI.10 RC16.2 RE350.1 UE1.G7
ESPI_CS#: JESPI.7 UC1.BA12 UE1.H6
ESPI_IO0: JESPI.3 RC366.2 UE1.K5
ESPI_IO0_R: RC366.1 UC1.AY13
ESPI_IO1: JESPI.4 RC367.2 UE1.L4
ESPI_IO1_R: RC367.1 UC1.BA13
ESPI_IO2: JESPI.5 RC368.2 UE1.G6
ESPI_IO2_R: RC368.1 UC1.BB13
ESPI_IO3: JESPI.6 RC369.2 UE1.L5
ESPI_IO3_R: RC369.1 UC1.AY12
ESPI_RESET#: RE560.2 UC1.BA11 UE1.K6
EXPANDER_ALERT#: T267.1(TP-1) UE2.7
FB_1.8VALW: PC503.2 PR501.2 PR506.1 PU501.6
FB_+1VALWP: PR306.2 PR308.2 PR311.1 PU301.14
FB_GT: PR645.2 PR648.2 PR650.1 PU602.17
FB_VSA: PR646.1 PR649.1 PR652.1 PU602.25
FCCM_GT: PR1299.1 PU602.21
FCCM_IA: PR659.1 PR671.1 PU602.11
FCCM_VSA: PR679.2 PU602.29
FIVR_EN: RC217.1 RC218.1 RC219.1
FIVR_EN_R: JXDP1.45 RC126.2 RC132.1 RC217.2
GPP_B22: RC184.1 UC1.AN5
GPP_B23: RC317.1 UC1.AM7
GPP_C5: RC25.1 UC1.W1
GPS_DISABLE#: DZ6.1 RE12.1 UE1.H5
GPU_B+: PC664.1 PC665.1 PC674.1 PC675.1 PC687.1 PJP602.1 PU612.8 PU612.9
GT_SNUB: PC670.1 PR669.2
GT_SW: PL612.4 PR669.1 PU612.11 PU612.12
H_CATERR#: RC79.1 UC1.D63
H_CPU_SVIDALRT#: RC153.1 UC1.B63
H_CPUPWRGD: CC300.1 RC77.2 UC1.A68
H_CPUPWRGD_R: RC77.1 T9.1(TP-1)
H_THERMTRIP#: CC312.1 QE4.3 RC80.1 UC1.C63
H_VCCST_PWRGD_XDP: CC307.1 JXDP1.39 RC123.2 RC124.2
HDA_BIT_CLK: RC93.2 UC1.AY22
HDA_BIT_CLK_R: CC27.1 RA17.1 RC93.1 UA1.8
HDA_RST#: CC331.1 RC95.2 UC1.AW22
HDA_RST#_R: RA50.1 RC95.1
HDA_SDIN0: CC332.1 RA9.1 UC1.BA21
HDA_SDIN0_R: RA9.2 UA1.10
HDA_SDOUT: CC333.1 RC94.2 RC187.1 RC223.2 UC1.BB22
HDA_SDOUT_R: CC334.1 RC94.1 UA1.11
HDA_SYNC: RC92.2 UC1.BA22
HDA_SYNC_R: RC92.1 UA1.9
HDD_FALL_INT: RC370.1 UC1.BB11
HDMI_CEC: JHDMI1.13 RV19.1
HDMI_CLKN: CV38.2 LV12.2 LV38.1 RV17.1
HDMI_CLKP: CV37.2 LV12.1 LV37.1 RV16.1
HDMI_CTRL_CLK: JHDMI1.15 QV3.6 RV316.1
HDMI_CTRL_DATA: JHDMI1.16 QV3.3 RV315.1
HDMI_L_CLKN: JHDMI1.12 LV12.3 LV38.2 RV35.1
HDMI_L_CLKP: JHDMI1.10 LV12.4 LV37.2 RV35.2
HDMI_L_TX_N0: JHDMI1.9 LV9.3 LV36.2 RV32.1
HDMI_L_TX_N1: JHDMI1.6 LV6.3 LV34.2 RV29.1
HDMI_L_TX_N2: JHDMI1.3 LV3.3 LV32.2 RV26.1
HDMI_L_TX_P0: JHDMI1.7 LV9.4 LV35.2 RV32.2
HDMI_L_TX_P1: JHDMI1.4 LV6.4 LV33.2 RV29.2
HDMI_L_TX_P2: JHDMI1.1 LV3.4 LV31.2 RV26.2
HDMI_OB: QV4.1 RV10.2 RV11.2 RV12.2 RV13.2 RV14.2 RV15.2 RV16.2 RV17.2
HDMI_RD_HPD: JHDMI1.19 QV5.1 QV6.2 RV21.1
HDMI_TX_N0: CV36.2 LV9.2 LV36.1 RV15.1
HDMI_TX_N1: CV34.2 LV6.2 LV34.1 RV13.1
HDMI_TX_N2: CV32.2 LV3.2 LV32.1 RV11.1
HDMI_TX_P0: CV35.2 LV9.1 LV35.1 RV14.1
HDMI_TX_P1: CV33.2 LV6.1 LV33.1 RV12.1
HDMI_TX_P2: CV31.2 LV3.1 LV31.1 RV10.1
HOST_DEBUG_TX: JDEG1.8 RE73.2 RE306.2 RZ132.1 UE1.G11
HOST_SD_WP#: QR1.2 RC292.1 UC1.W10
HP_OUT_L: CA43.2 CA74.1 RA7.1 UA1.26
HP_OUT_R: CA44.2 CA73.1 RA8.1 UA1.25
HV_GATE1_A: RT64.1 UT5.B9
HV_GATE1_B: RT160.1 UT11.B9
HV_GATE2_A: RT65.1 UT5.A9
HV_GATE2_B: RT161.1 UT11.A9
HW_ACAVIN_NB: T266.1(TP-1) UE1.N6
HW_GPS_DISABLE#_R: DZ6.2 JNGFF2.26
I2C1_SCK_TP: RZ21.2 RZ29.1 UC1.U9
I2C1_SCK_TP_R: JKBTP1.19 RZ29.2 RZ117.2 RZ349.1
I2C1_SDA_TP: RZ20.2 RZ26.1 UC1.U8
I2C1_SDA_TP_R: JKBTP1.18 RZ26.2 RZ116.2 RZ348.1
I2C2_ALS_CLK: QC4.4 RC511.2 UC1.AH10
I2C2_ALS_SDA: QC4.1 RC510.2 UC1.AH9
I2C2_SCL_ALS: JSEN2.12 QC4.3 RC513.2
I2C2_SDA_ALS: JSEN2.11 QC4.6 RC512.2
I_ADP: PR935.2 UE1.B11
I_BATT: PR947.2 RE64.2
I_BATT_R: CE3.1 RE64.1 UE1.J4
I_SYS: PR620.1 PR936.2 RE312.2
I_SYS_R: CE4.1 RE312.1 RE313.1 UE1.J5
IA1N: PL610.2 PR666.1 PR677.1
IA1P: PL610.3 PR667.2 PR668.1
IA2N: PL613.2 PR670.2 PR673.1
IA2P: PL613.3 PR674.2 PR675.1
IA_SNUB1: PC662.1 PR663.2
IA_SNUB2: PC678.1 PR676.2
IA_SW1: PL610.4 PR663.1 PU610.11 PU610.12
IA_SW2: PL613.4 PR676.1 PU613.11 PU613.12
ILIM_SEL: RI13.1 UI3.4
ILMT_+1VALWP: PR307.2 PR310.1 PU301.13
ILMT_DDR: PR205.1 PR207.2 PU200.17
IMON_GT: PC625.2 PR629.2 PU602.14
IMON_VSA: PC643.1 PR651.1 PU602.23
IMVP_VR_ON: PR616.1 RE304.1 UE3.4 UE4.2
IMVP_VR_ON_EC: RE304.2 RPE10.2 UE1.N7 UE3.1
INT_SPK_L+: CA22.1 LA6.1 UA1.42
INT_SPK_L-: CA23.1 LA7.1 UA1.43
INT_SPK_R+: CA19.1 LA8.1 UA1.45
INT_SPK_R-: CA24.1 LA9.1 UA1.44
INT_SPKR_L+: DA6.2 JSPK1.1 LA6.2
INT_SPKR_L-: DA6.3 JSPK1.2 LA7.2
INT_SPKR_R+: DA7.2 JSPK1.3 LA8.2
INT_SPKR_R-: DA7.3 JSPK1.4 LA9.2
INTRUDER#: RC69.1 UC1.AP16
IR_CAM_DET#: JIR1.1 RC345.1 UC1.H5
ISEN1_IA: PC635.2 PR634.1 PR668.2 PR670.1 PU602.9
ISEN2_IA: PC638.2 PR615.1 PR675.2 PR677.2 PU602.10
ISH_GP0: DZ100.1 RZ143.1 RZ505.1
ISH_GP0_D: DZ100.2 RC365.1 RZ501.1 UC1.AY8
ISH_GP1: DZ101.1 LGA1.12 RZ506.1
ISH_GP1_D: DZ101.2 RC364.1 RZ502.1 UC1.BA8
ISH_GP2: DZ102.1 RZ507.1
ISH_GP2_D: DZ102.2 RC501.1 RZ503.1 UC1.BB7
ISH_GP3: DZ103.1 RZ145.1 RZ508.1
ISH_GP3_D: DZ103.2 RC502.1 RZ504.1 UC1.BA7
ISH_I2C0_SCL: LGA1.1 QZ10.4 RC359.1 RZ137.1 UC1.N3
ISH_I2C0_SDA: LGA1.4 QZ10.1 RC358.1 RZ140.1 UC1.M4
ISH_I2C1_SCL: RC361.1 RE517.2 RZ138.1 UC1.N2
ISH_I2C1_SCL_EC: RE517.1 RPE12.1 UE1.F7
ISH_I2C1_SDA: RC360.1 RE516.2 RZ141.1 UC1.N1
ISH_I2C1_SDA_EC: RE516.1 RPE12.2 UE1.B6
ISH_I2C2_SCL: RC362.1 RZ76.1 UC1.AD12
ISH_I2C2_SCL_R: JNGFF2.40 RZ76.2
ISH_I2C2_SDA: RC363.1 RZ77.1 UC1.AD11
ISH_I2C2_SDA_R: JNGFF2.42 RZ77.2
ISH_UART0_CTS#: RZ80.1 UC1.U4
ISH_UART0_CTS#_R: JNGFF1.62 RZ80.2
ISH_UART0_RTS#: RZ81.1 UC1.U3
ISH_UART0_RTS#_R: JNGFF1.64 RZ81.2
ISH_UART0_RXD: RZ78.1 UC1.U1
ISH_UART0_RXD_R: JNGFF1.58 RZ78.2
ISH_UART0_TXD: RZ79.1 UC1.U2
ISH_UART0_TXD_R: JNGFF1.60 RZ79.2
ISUMN_GT: PC642.2 PC645.1 PC646.2 PH605.2 PL612.2 PR640.2 PR644.2 PR656.2
ISUMN_IA: PC624.2 PC626.2 PC635.1 PC638.1 PC641.1 PH602.2 PR632.1 PR633.2 PR638.1 PR666.2 PR673.2
ISUMN_VSA: PC633.2 PC637.2 PC644.1 PH604.2 PL614.2 PR636.2 PR641.2 PR643.1
ISUMP_GT: PC642.1 PC646.1 PR653.2 PR656.1 PR657.1 PR661.2 PU602.19
ISUMP_IA: PC624.1 PC626.1 PR628.1 PR633.1 PR658.2 PR667.1 PR674.1 PU602.7
ISUMP_VSA: PC633.1 PC637.1 PR624.2 PR642.1 PR643.2 PU602.27
ITP_PMODE: JXDP1.46 RC115.1 UC1.E8
JTAG_CLK: JDEG1.4 RPE7.3 UE1.C8
JTAG_RST#: CE30.1 JTAG1.1 RE63.1 RE65.1 UE1.G13
JTAG_TDI: JDEG1.2 RPE7.1 UE1.E9
JTAG_TDO: JDEG1.5 RPE7.4 UE1.F6
JTAG_TMS: JDEG1.3 RPE7.2 UE1.C5
KB_DET#: CZ84.1 JKBTP1.1 RC288.1 UC1.D8
LAN_WAKE#: RC323.1 UC1.AM15 UE1.L3
LCD_CBL_DET#: JEDP1.40 RC287.1 UC1.AC3
LCD_TST: JEDP1.24 RE20.1 UE1.M2
LCD_VCC_TEST_EN: DV3.2 UE1.E1
LED_MASK#: RE21.1 UE1.A12
LG1_ISL9538: PQ905.8 PU901.9
LG2_ISL9538: PQ904.8 PU901.7
LID_CL#: DZ104.1 RE26.1 RZ514.1 UZ1.3
LID_CL#_NB_C: RC504.2 UC1.AW7
LID_CL#_NB_D: DZ104.2 RC504.1 RZ512.1
LID_CL#_TAB_C: RC505.2 UC1.AP13
LID_CL#_TAB_D: DZ105.2 RC505.1 RZ513.1
LID_CL_SIO#: CE8.1 RE25.2 RE26.2 UE1.N11
LID_CL_SIO_TAB#: DZ105.1 RE5.1 RZ515.1 UE1.E12 UZ28.3
LINE1_L: CA43.1 UA1.34
LINE1_R: CA44.1 UA1.33
LOM_CABLE_DETECT#: RE505.1 UE1.D2
LPSA_PROTECT#: PR1230.2 PT1.1(TP-1)
LPSB_PROTECT#: PR1266.2 PT2.1(TP-1)
LPSS_UART2_RXD: RC330.1 RC402.1 UC1.AD1
LPSS_UART2_TXD: RC331.1 RC403.1 UC1.AD2
LX1_ISL9538: PC930.2 PL902.1 PQ905.2 PQ905.5 PQ905.6 PQ905.7 PR923.1 PU901.10
LX2_ISL9538: PL902.2 PQ904.2 PQ904.5 PQ904.6 PQ904.7 PR921.1 PR924.1 PU901.6
LX_1.8VALW: PL501.1 PR502.1 PU501.3
LX_1V_PRIM: PL404.1 PR409.1 PU402.2 PU402.3
LX_1VS_VCCIO: PL402.1 PR405.1 PU401.2 PU401.3
LX_3V: PC102.2 PL100.1 PR106.1 PU100.6 PU100.19 PU100.20
LX_5V: PC114.2 PL101.1 PR112.1 PU102.6 PU102.19 PU102.20
LX_DDR: PC205.2 PL201.1 PR202.1 PU200.11
M2_DEVSLP: JNGFF3.38 RN37.2 UC1.J3
M2280_PCIE_SATA#: JNGFF3.69 RPC4.1 UC1.G4
M3042_DEVSLP: JNGFF2.38 UC1.J2
M3042_PCIE#_SATA: RC551.1 RC552.1 UC1.H3 UE1.J12
MASK_SATA_LED#: QZ2.5 UE1.L6
ME_FWP: RC221.2 SW1.3 UE1.G12
ME_FWP_SW: RC221.1 RC223.1 SW1.2
ME_RESET#: RC225.1 RC227.1 UC12.2
ME_SUS_PWR_ACK: RC74.1 RC444.1 UE1.B13
ME_SUS_PWR_ACK_R: RC444.2 UC1.AR13
MEC_XTAL1: CE28.1 UE1.A1 YE1.1
MEC_XTAL2: CE29.1 RE290.2 YE1.2
MEC_XTAL2_R: RE290.1 UE1.A3
MEM_CONFIG0: RC388.2 RC393.1 UC1.AP2
MEM_CONFIG1: RC389.2 RC394.1 UC1.AP1
MEM_CONFIG2: RC390.2 RC395.1 UC1.AP3
MEM_CONFIG3: RC391.2 RC396.1 UC1.AN3
MEM_CONFIG4: RC392.2 RC397.1 UC1.AN1
MEM_INTERLEAVED: RC371.1 RC372.1 UC1.P2
MEM_SMBCLK: CC320.1 QC2.6 RC12.1 UC1.R7
MEM_SMBDATA: QC2.3 RC14.1 UC1.R8
MPHYP_PWR_EN: RC387.1 UC1.AM10
MSCLK: JDEG1.6 RE30.1 RE72.2 UE1.H10
MSDATA: JDEG1.7 RE75.2 RE86.1 UE1.G9
MUX1_FLIP_SEL_R: RT69.1 UT5.B2
MUX2_FLIP_SEL_R: RT165.1 UT11.B2
MW_1: RE550.1 UE2.10
MW_2: RE518.1 UE2.11
NB_MODE#: QC3.1 RC507.2 RC508.1 UE1.J8
NB_MODE#_D: QC3.3 RC349.1 RC506.2 RC508.2 RC509.1 UC1.AY7
NB_MUTE#: DA8.1 RA48.1 UE1.A4
NGFF_CONFIG_0: JNGFF2.21 RPE9.3 UE1.N9
NGFF_CONFIG_1: JNGFF2.69 RE562.1 UE1.M10 UZ29.9
NGFF_CONFIG_2: JNGFF2.75 RPE9.2 UE1.N10
NGFF_CONFIG_3: JNGFF2.1 RPE9.4 UE1.F4
NRB_BIT: RC186.1 UC1.AR7
NTC_GT: PR635.2 PU602.15
NVME_LED#: JNGFF3.10 RN100.1
ONE_DIMM#: RC267.1 RC268.1 UC1.AP7
OTG_ID1: RT74.1 UT5.E10
OTG_ID2: RT170.1 UT11.E10
OTGEN/CMIN: PR919.2 PR960.2 PU901.20
P_SENSOR_ACK#_R: Q1.3 RZ326.2 RZ344.2
P_SENSOR_ACT#_EC: RE509.2 UE1.F13
PANEL_BKEN_EC: DV2.2 UE1.J9
PANEL_BKLEN: DV2.3 UC1.R12
PANEL_SIZE_DET: JEDP1.27 RC503.1 UC1.D7
PBAT_CHARGER_SMBCLK: PD2.3 PR922.1 PRP1.3 RE43.1 UE1.N2
PBAT_CHARGER_SMBDAT: PD1.2 PR920.1 PRP1.2 RE37.1 UE1.M3
PBAT_PRES#: PD1.3 PR1.2 PR931.1 PRP1.1 UE1.F9
PBAT_PRES#_C: PBATT1.6 PRP1.8
PBAT_SMBCLK_C: PBATT1.4 PRP1.6
PBAT_SMBDAT_C: PBATT1.5 PRP1.7
PBATT+_C: PBATT1.1 PBATT1.2 PBATT1.3 PC1.1 PL1.1 PL2.1
PCH_3.3V_TS_EN: RC282.1 RV306.1 UC1.AP5
PCH_ALW_ON: RPE10.3 RZ65.1 UE1.M8
PCH_BATLOW#: RC72.1 UC1.AU13
PCH_CL_CLK1: JNGFF1.42 UC1.G3
PCH_CL_DATA1: JNGFF1.40 UC1.G2
PCH_CL_RST1#: JNGFF1.38 UC1.G1
PCH_DPWROK: CC266.1 RC215.1 RC220.1 RE536.1 UC1.BB20
PCH_DPWROK_EC: RE536.2 UE1.F8
PCH_JTAG_TCK: JXDP1.55 RC86.1 UC1.B56
PCH_JTAG_TDI: CC304.1 RC81.1 RC229.2 UC1.D59
PCH_JTAG_TDO: CC303.1 RC82.1 RC230.2 UC1.A56
PCH_JTAG_TMS: RC130.1 RC228.2 UC1.C59
PCH_PCIE_WAKE#: RC67.1 RE274.2 RT422.2 RT445.1 UC1.BB15 UE1.L1
PCH_PLTRST#: RC60.1 RC244.1 UC1.AN10 UC7.1 UC7.2
PCH_PLTRST#_5105: RE340.1 UE1.K1 UE6.4
PCH_PLTRST#_AND: CZ61.1 JNGFF1.52 JNGFF1.66 JNGFF2.50 JNGFF3.50 JTS1.2 RC65.1 RC325.1 RT419.2 RT446.1 RZ114.1 UC7.4
PCH_PLTRST#_EC: RC244.2 RE375.2 UE6.2
PCH_POPIRCOMP: RC89.1 UC1.AU16
PCH_PRIM_EN: PR312.1 PR406.1 PR504.1 RC441.2 RC442.2 RZ64.1 UZ34.1
PCH_PWROK: PR614.1 RC411.1 UC1.BA20
PCH_RSMRST#: RE342.1 UE1.M5 UZ6.1
PCH_RSMRST#_AND: RC75.1 RC124.1 RC215.2 UC1.AY17 UZ6.4
PCH_RTCRST#: CC25.1 CMOS1.1 JAPS1.9 RC57.1 RE94.2 UC1.AM16
PCH_RTCX1: CC23.1 RC54.2 UC1.AM18 YC2.1
PCH_RTCX2: RC54.1 RC296.1 UC1.AM20
PCH_RTCX2_R: CC26.1 RC296.2 YC2.2
PCH_SMB_ALERT#: RC23.1 UC1.R10
PCH_SPI_CLK: JSPI1.13 RC35.2 UC1.AV2
PCH_SPI_CLK_0_R: RC29.1 RPC1.7 UC5.6
PCH_SPI_CLK_1_R: RC28.1 RC408.2 UC6.6
PCH_SPI_CLK_2_R: RZ60.2 RZ63.2 UZ12.19
PCH_SPI_CLK_R1: JSPI1.14 RC35.1 RC408.1 RPC1.2 RZ60.1
PCH_SPI_CS#0: JSPI1.11 RC36.2 UC1.AU3
PCH_SPI_CS#0_R1: JSPI1.12 RC36.1 RC37.1
PCH_SPI_CS#0_R2: RC37.2 UC5.1
PCH_SPI_CS#1: JSPI1.19 RC32.2 UC1.AU2
PCH_SPI_CS#1_R1: JSPI1.20 RC32.1 RC42.1
PCH_SPI_CS#1_R2: RC42.2 UC6.1
PCH_SPI_CS#2: RZ61.1 UC1.AU1
PCH_SPI_CS#2_R: RZ61.2 UZ12.20
PCH_SPI_D0: JSPI1.17 RC10.2 RC33.2 UC1.AV3
PCH_SPI_D0_0_R: RPC1.8 UC5.5
PCH_SPI_D0_1_R: RC409.2 UC6.5
PCH_SPI_D0_2_R: RZ59.2 UZ12.21
PCH_SPI_D0_R1: JSPI1.18 RC33.1 RC409.1 RPC1.1 RZ59.1
PCH_SPI_D1: JSPI1.15 RC34.2 UC1.AW3
PCH_SPI_D1_0_R: RPC1.6 UC5.2
PCH_SPI_D1_1_R: RC410.2 UC6.2
PCH_SPI_D1_2_R: RZ58.2 UZ12.24
PCH_SPI_D1_R1: JSPI1.16 RC34.1 RC410.1 RPC1.3 RZ58.1
PCH_SPI_D2: JSPI1.9 RC11.2 RC38.2 UC1.AW2
PCH_SPI_D2_0_R: RC39.2 UC5.3
PCH_SPI_D2_1_R: RC43.2 UC6.3
PCH_SPI_D2_R1: JSPI1.10 RC30.1 RC38.1 RC39.1 RC43.1
PCH_SPI_D3: JSPI1.7 RC40.2 UC1.AU4
PCH_SPI_D3_0_R: RPC1.5 UC5.7
