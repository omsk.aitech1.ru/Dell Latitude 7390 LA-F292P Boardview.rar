# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_TBT_LC: length 17
  TOP w0.203: 35.25,63.56 34.56,62.87 CT41.1 34.56,60.97 v2(34.64,60.89)
  TOP w0.254: v3(38.88,65.36) 38.75,65.36 v1(38.52,65.59) 38.17,65.95 RT8.2 RT5.2 36.49,65.95 35.76,65.21 RT6.2 35.76,64.5 35.27,64.02 RT7.2 35.25,63.56
  GND1 w0.254: v4(39.36,65.34) 38.9,65.34 v3(38.88,65.36)
  IN3 w0.254: v4(42.41,69.43) 42.79,69.05 42.79,66.85 41.27,65.34 v4(39.36,65.34)
  GND5 w0.254: v4(42.41,69.43) 42.89,69.91 v5(42.96,69.91)
  BOTTOM w0.203: v2(34.64,60.89) 34.64,60.89 34.64,60.89 34.33,61.2 UT1.R6
+3.3V_TBT_S0: length 15.2
  TOP w0.356: v2(34.65,58.28) 34.54,58.17 CT67.1
  IN4 w0.508: 31.46,53.48 28.75,53.48 27.45,52.18 24.36,52.18 v4(22.84,53.7) ; v2(34.65,58.28) 34.39,58.28 33.85,57.74
  GND5 w0.508: v5(23.54,53.87) v4(22.84,53.7)
  BOTTOM w0.203: UT1.R13 v2(34.65,58.28)
  BOTTOM w0.508: LT2.1 21.3,53.87 CT69.1 v5(23.54,53.87)
+3.3V_TBT_SX: length 50.5
  TOP w0.254: v3(38.89,65.92) 38.19,66.61 RT371.2
  TOP w0.381: CT42.1 30.2,60.78 v2(30.1,60.88)
  TOP w0.508: RT371.2 v1(37.12,67.14) v3(36.61,67.65) ; v3(32.2,65.69) 32.2,64.86 RT17.2
  GND1 w0.254: v3(38.89,65.92) 39.28,65.92 v4(39.36,66)
  GND1 w0.508: v4(36.62,68.44) 36.62,68.44 36.62,68.28 36.61,68.27 v3(36.61,67.65) ; v3(32.2,65.69) v4(32.2,64.56)
  IN1 w0.508: v2(23.16,81.62) 25.44,81.62 28.03,79.03 28.03,77.96 28.01,77.94 28.01,75.99 28.36,75.63 28.36,74.05 30.01,72.4 30.01,70.22 29.56,69.76 29.56,68.23 v4(30.01,67.78) 30.79,67.78 31.34,67.23 31.34,65.57 32.2,64.7 v4(32.2,64.56) 31.96,64.32 30.38,64.32 30.02,63.96 30.02,63.14 30.77,62.39 30.77,61.52 30.13,60.88 v2(30.1,60.88)
  IN4 w0.508: v4(36.62,68.44) 36.62,65.57 35.76,64.7 32.34,64.7 v4(32.2,64.56)
  GND5 w0.254: 39.36,66 39.36,66 39.46,66 39.92,65.54 v5(39.92,65.49)
  GND5 w0.508: v5(38.37,65.87) 38.5,66 v4(39.36,66) ; v4(36.62,68.44) 36.57,68.38 v5(36.57,67.95) ; v5(30.68,67.78) v4(30.01,67.78)
  BOTTOM w0.254: v2(30.1,60.88) 30.43,60.56 UT1.F8
  BOTTOM w0.508: v5(36.57,67.95) 36.59,67.95 37.08,68.44 RT18.2 RT19.2 ; RT372.2 v5(30.68,67.78)
+3.3V_TBTA_FLASH: length 54.2
  TOP w0.508: RT76.2 34.92,74.38 v3(34.62,74.67) ; v3(36.87,89.64) 37.63,88.88 RT67.2 ; RT221.2 37.3,74.42 37.99,73.73 v1(37.99,73.17) 37.99,72.42 38.24,72.17 38.24,71.37 38.02,71.14 CT84.1 38.36,70.7 v3(38.6,70.46)
  GND1 w0.508: v3(36.87,89.64) 36.68,89.83 v4(35.66,89.83) ; v3(34.74,73.24) 34.69,73.29 v4(34.69,73.9) 34.62,73.96 v3(34.62,74.67) ; v3(38.6,70.46) 39.13,70.46 v4(39.34,70.66)
  IN2 w0.508: v2(40.48,82.76) v4(38.22,82.76) 36.39,82.76 33.88,80.25 33.57,80.25 33.04,79.71 33.04,76.11 33.42,75.73 33.42,74.84 34.36,73.9 v4(34.69,73.9) 34.69,73.64 33.67,72.63 33.67,72.09 33.72,72.04 33.72,71.54 33.67,71.49 33.67,71.48 33.34,71.15 32.07,71.15 v4(31.56,70.65)
  IN3 w0.508: v4(39.34,70.66) 38.75,70.66 35.88,73.53 35.06,73.53 v4(34.69,73.9)
  IN4 w0.508: v4(35.66,89.83) 35.52,89.83 34.97,89.28 34.97,86.68 35.37,86.27 35.37,84.44 37.05,82.76 v4(38.22,82.76)
  GND5 w0.203: v4(31.56,70.65) 31.56,70.68 v5(31.22,71.03)
  GND5 w0.508: v5(38.33,70.46) 38.34,70.46 39.13,70.46 v4(39.34,70.66)
  BOTTOM w0.254: RT95.2 26.48,71.08 v2(26.67,71.27)
  BOTTOM w0.508: RT66.2 RT107.2 RT106.2 37.81,69.94 v5(38.33,70.46) ; v2(40.48,82.76) 40.65,82.94 41.37,82.94 RT10.1
+3.3V_TBTB_FLASH: length 55.8
  TOP w0.127: v2(24.96,37.91) 25.1,37.91 25.65,38.45 v1(25.65,38.59)
  TOP w0.508: RT199.2 RT200.2 24.73,38.74 24.96,38.52 v2(24.96,37.91)
  GND1 w0.254: v4(25.28,44.39) 25.52,44.15 v3(25.7,44.15) ; v3(28.24,43.9) 28.18,43.84 v4(28.18,43.39)
  GND1 w0.305: v3(24.6,42.63) v4(24.6,43.11)
  IN3 w0.508: v4(37.52,46.1) 37.52,43.37 38.18,42.7 38.18,41.1 35.26,38.18 33.29,38.18 32.39,37.28 28.34,37.28 27.77,37.85 v2(26.94,37.85) 26.89,37.91 v2(24.96,37.91)
  IN4 w0.381: v4(37.52,46.1) 41.08,49.66 41.08,51.38 v4(39.9,52.56)
  GND5 w0.254: v5(26.23,44.62) 26.09,44.62 25.86,44.39 v4(25.28,44.39)
  GND5 w0.381: v4(25.14,46.87) 24.96,46.69 v5(24.63,46.69)
  GND5 w0.508: v5(37.85,46.46) 37.85,46.43 v4(37.52,46.1) ; v5(40.02,51.79) 40.01,51.8 40.01,52.45 v4(39.9,52.56)
  BOTTOM w0.381: v5(37.85,46.46) 38.17,46.78 39.01,46.78 39.44,47.21 39.44,48.56 40.96,50.08 43.02,50.08 RT51.2
  BOTTOM w0.508: UT6.8 39.79,45.18 39.25,44.64 CT70.1 39.25,43.18 RT50.2 38.29,42.91 37.6,43.61 37.6,46.2 37.85,46.45 v5(37.85,46.46) ; RT52.2 40.03,51.78 v5(40.02,51.79) ; v2(26.94,37.85) 26.94,38.58 RT162.2 RT163.2
+3.3V_TP: length 20.9
  TOP w0.102: v1(184.03,34.91) 183.76,34.91 v2(183.42,34.57)
  TOP w0.254: RZ18.1 174.57,36.18
  TOP w0.508: RZ117.1 182.81,34.08 RZ21.1 182.97,35.01 v2(183.42,34.57) ; RZ116.1 RZ20.1
  IN1 w0.254: v2(183.42,34.57) 182.64,35.34 176.62,35.34 175.68,36.28 173.65,36.28 v2(173.13,35.76)
  GND5 w0.508: v2(173.97,35.75) 173.97,36.06 174.48,36.57 v5(175.18,36.57)
  BOTTOM w0.254: JKBTP1.12 176.75,36.14 175.98,36.92 CZ90.1
  BOTTOM w0.356: CZ83.1 175.49,36.92 CZ90.1
+3.3V_TSP: length 17.3
  TOP w0.076: RV311.2 v1(192,40.73)
  TOP w0.508: v2(191.62,39.06) 192,39.44 RV311.2
  GND1 w0.508: v3(187.37,38.39) 187.37,38.85 v4(187.04,39.18)
  IN4 w0.508: v4(187.04,39.18) 187.04,38.39 188.92,36.51 v4(191.23,36.51)
  GND5 w0.381: v5(192.11,37.02) 192,37.12 191.61,37.12 191.23,36.74 v4(191.23,36.51)
  GND5 w0.508: v5(186.96,38.54) 186.96,39.1 v4(187.04,39.18)
  BOTTOM w0.356: v5(186.96,38.54) 186.95,38.53 CV19.1
  BOTTOM w0.381: RV99.2 192.21,37.55 192.66,38.01 192.66,38.82 192.32,39.16 191.72,39.16 v2(191.62,39.06)
  BOTTOM w0.508: JTS1.1 186.7,39.96 186.12,39.38 CV19.1 CV18.1
+3.3V_TSP_UZ41: length 1.1
  TOP w0.127: RZ516.1 v6(187.37,36.33)
+3.3V_VCCHDA: length 2.9
  TOP w0.254: 145.66,66.93 145.65,66.94 145.16,66.94 v2(145.03,67.07) ; 145.66,66.93 145.66,66.94 145.83,67.12 145.83,67.64 CC313.1 145.47,67.67 LC1.2 ; 145.66,66.93 CC324.1
  BOTTOM w0.254: v2(145.03,67.07) 145.03,67.04 UC1.AJ19
+3.3V_VDD_PIC: length 236.4
  TOP w0.203: v3(64.94,34.71) 64.94,34.68 PR950.2
  TOP w0.254: v3(64.94,34.71) 64.94,34.83 65.36,35.25 PU903.5 ; PR1278.1 39.05,82.06 41.95,82.06 42.72,82.83 43.06,82.83 43.35,83.11 43.35,84.67 42.71,85.3 42.71,87.05 41.9,87.87 40.07,87.87 v2(39.08,88.86) ; PU1203.5 45.68,31.79 46.4,31.07 v3(46.5,31.07) 46.5,31.71 45.59,32.62 PR1283.1
  TOP w0.305: PC1207.2 67.53,85.33 PU1202.5
  TOP w0.381: v2(39.03,36.66) 39.36,36.33 PR1253.1 ; QT2.5 27.82,36.69 26.89,36.69 v2(26.87,36.66) 26.74,36.79 QT2.2
  TOP w0.508: v2(47.52,35.65) 47.64,35.52 PR1281.1 ; RT389.1 36.39,25.54 36.58,25.73 36.58,28.69 CT91.1 37.68,29.61 38.4,30.34 v6(39.03,30.34) 39.13,30.44 v2(39.97,30.44) 39.97,30.76 40.34,31.12 PR1258.1 ; v2(61.38,80.81) 61.66,81.1 PR1205.2 ; v3(66.29,84.84) PR1284.1 67.38,85.43 PC1207.2 ; PR1216.1 44.19,89.75 44,89.93 43.28,89.93 42.8,89.45 39.81,89.45 ; v2(37.39,41.84) 37.75,42.2 PR1239.2
  GND1 w0.508: v3(46.5,31.07) v4(45.69,31.07) ; v4(66.21,83.91) 66.21,84.06 66.29,84.13 v3(66.29,84.84) ; v3(64.94,34.71) 64.32,35.33 v4(64.32,35.38) ; v3(48.79,43.02) 48.79,43.48 48.92,43.61 v4(48.92,43.68)
  IN1 w0.508: v2(10.71,60.99) 10.71,57.97 13.78,54.9 13.78,52.87 14.5,52.16 14.5,49.62 18.43,45.68 18.43,42.2 19.27,41.36 19.27,39.92 v2(21.24,37.96)
  IN2 w0.508: v2(39.08,88.86) 36.75,88.86 36.24,88.36 35.64,88.36 34.78,87.5 26.25,87.5 v2(23.41,84.67) 23.41,84.23 20.5,81.32 20.06,81.32 16.98,78.24 16.98,76.21 15.03,74.25 12.36,74.25 8.6,70.49 8.6,66.15 10.91,63.84 10.91,61.2 v2(10.71,60.99) ; v2(37.39,41.84) 36.56,41.01 36.56,38.9 38.79,36.66 v2(39.03,36.66) 39.93,36.66 41.71,34.88 42.46,34.88 43.05,34.3 44.01,34.3 44.57,33.74 47.03,33.74 47.67,34.37 47.67,35.49 v2(47.52,35.65)
  IN3 w0.508: v2(48.58,91.04) 48.02,90.48 48.02,89.07 49.13,87.97 52.04,87.97 v4(53.38,86.62) ; v4(48.92,43.68) 48.92,42.45 48.18,41.71 48.18,38.44 48.79,37.83 48.79,37.07 47.52,35.8 v2(47.52,35.65)
  IN4 w0.508: v2(39.03,36.66) 39.01,36.66 34.56,32.22 31.36,32.22 29.05,34.53 25.54,34.53 24.12,35.95 22.78,35.95 21.59,37.13 21.59,37.6 v2(21.24,37.96) ; v4(45.69,31.07) 45.59,31.17 40.37,31.17 39.97,30.78 v2(39.97,30.44) ; v4(66.21,83.91) 65.41,83.1 65.41,82.8 64.18,81.57 62.13,81.57 v2(61.38,80.81)
  GND5 w0.508: v5(40.52,90.89) 40.24,90.89 v4(39.64,90.29) ; v5(46.22,31.58) 46.19,31.58 v4(45.69,31.07) ; v4(64.32,35.38) v5(64.32,34.43) ; v5(54.02,85.68) 53.38,86.32 v4(53.38,86.62)
  BOTTOM w0.381: PR1213.2 v2(48.58,91.04)
  BOTTOM w0.508: v5(54.02,85.68) 54.04,85.68 54.55,85.18 PR1228.1 55.21,84.9 55.72,84.39 57.8,84.39 v2(61.38,80.81) ; v5(64.32,34.43) 61.4,31.5 46.3,31.5 v5(46.22,31.58) 45.99,31.81 45.99,32.83 47.64,34.48 47.64,35.52 v2(47.52,35.65)
+3.3V_VDD_PIC_PDA: length 38.8
  IN1 w0.508: v4(29.41,78.16) 29.91,78.67 30.83,78.67 33.27,81.11 33.27,83.8 35.15,85.68 35.15,87.64 35.88,88.38 v4(35.88,89.16)
  IN2 w0.508: v2(41.83,90.79) 41.18,91.44 37.43,91.44 36.39,90.39 36.39,89.67 36.39,89.67 v4(35.88,89.16)
  IN4 w0.508: v4(34.18,68.79) 34.18,70.49 33.49,71.18 32.86,71.18 32.75,71.29 31.21,71.29 30.72,70.8 v4(30.72,70.52) 29.99,71.25 29.99,72.43 28.58,73.84 28.58,75.71 27.98,76.31 27.98,77.48 28.67,78.16 v4(29.41,78.16)
  GND5 w0.381: v4(34.18,68.79) 34.18,68.85 34.56,69.23 v5(34.73,69.23) ; v5(30.72,71.03) v4(30.72,70.52)
  vias: v1(42.35,90.14) v2(41.8,90.15)
+3.3V_VDD_PIC_PDB: length 7.5
  TOP w0.508: v2(25.01,45.3) 24.92,45.39 v1(24.36,45.39) 23.89,44.92 23.89,41.89 v2(22.71,40.71)
  BOTTOM w0.203: UT11.H1 25.79,45.12 25.6,45.32 24.93,45.32 24.93,45.3 v2(25.01,45.3)
+3.3V_WLAN: length 2.2
  TOP w0.102: 240.47,54.8 240.54,54.72 v6(240.54,53.65)
  TOP w0.127: 228.06,35 228.06,34.77 v6(227.46,34.17)
  vias: v2(227.73,35.24) v2(228.31,35.24) v2(228.53,34.15) v2(229.11,34.15) v2(237.46,37.4) v2(238.04,37.42) v2(238.63,37.42) v2(239.21,37.42) v2(242.13,37.78) v2(242.36,56.35) v2(242.56,37.37) v2(242.87,56.73) v6(239.88,37.68)
+3.3V_WLAN_UZ2:
  vias: v1(232.53,36.99)
+3.3V_WWAN: length 306.7
  TOP w0.203: CZ154.1 232.05,62.03 231.74,61.73 UZ29.1 ; UZ29.10 224.42,61.73 224.29,61.86 CZ155.1
  TOP w0.254: v2(227.81,63.58) 227.73,63.58 227.48,63.32 UZ29.6
  TOP w0.381: QZ13.2 QZ13.5 230.15,47.29 RZ351.2
  TOP w0.508: CZ155.1 v2(223.69,61.25) ; v2(230.2,63.72) 230.2,63.47 231.13,62.54 CZ154.1 ; RZ351.2 230.26,47.39 v2(230.81,47.39) 231.3,47.39 233.04,49.13 RZ350.2
  IN3 w0.381: v4(43.2,78.01) 43.76,77.45 43.76,62.33 42.1,60.68 42.1,52.58 42.84,51.85 42.84,47.79 43.08,47.55 43.08,45.47 40.17,42.56 40.17,39.45 41.15,38.47 41.15,36.26 42.4,35.01 43.76,35.01 v4(43.81,35.06)
  IN3 w0.508: v4(234.76,34.15) 231.41,34.15 230.45,33.18 227.79,33.18 227.05,33.92 226.12,33.92 224.78,32.57 210.05,32.57 208.05,30.58 197.55,30.58 195.94,28.96 182.49,28.96 179.92,31.53 175.82,31.53 174.69,30.4 v4(171.39,30.4)
  IN4 w0.381: v2(33.95,88.88) 33.88,88.88 33.84,88.83 33.62,88.83 33.14,88.35 33.14,87.27 v2(34.02,86.39) 34.76,85.65 34.76,84.18 37.84,81.11 41.7,81.11 42.16,80.65 42.16,79.05 v4(43.2,78.01) ; v4(43.81,35.06) 43.93,35.06 45.36,36.49 50.33,36.49 51.48,35.34 53.38,35.34 54.03,35.99 58.81,35.99 59.94,37.12 63.26,37.12 66.26,40.12 75.43,40.12 78.26,42.95 85.71,42.95 87.52,41.14 87.52,39.84 88.83,38.53 88.83,34.12 91.53,31.42 92.24,31.42 93.04,30.62 109.36,30.62 110.1,29.88 140.8,29.88 141.7,28.98 147.44,28.98 148.35,29.88 157.68,29.88 v4(158.55,29)
  GND5 w0.508: v5(235.2,34.98) 235.2,34.58 v4(234.76,34.15)
  BOTTOM w0.381: RZ331.2 33.97,86.34 v2(34.02,86.39) ; RZ332.2 v2(33.95,88.88)
  BOTTOM w0.508: v5(235.2,34.98) 235.2,37.2 233.72,38.67 233.72,39.23 233.19,39.76 233.19,43.07 230.63,45.63 230.63,47.21 v2(230.81,47.39) 230.81,47.41 230.69,47.53 230.69,49 ; 230.69,49 228.24,49 v2(228.24,49.01) ; 230.69,49 232.84,49 233.49,48.35 234.76,48.35 235.5,49.08 CZ164.1 234.89,49.49 234.4,49 JSAR1.1
  vias: v2(213.91,44.66) v2(214.24,45.2) v2(214.6,44.66) v2(214.88,45.2) v2(215.21,44.66) v2(215.49,45.2) v2(228.49,69.2) v2(231.44,89.24) v2(231.44,88.6) v2(231.82,70.19) v2(232.07,89.24) v2(232.2,69.68) v2(238.17,65.83) v2(238.8,65.83) v2(239.43,65.83) v6(213.14,45.35) v6(213.25,41.58) v6(214.23,43.43)
+3.3V_WWAN_AUX: length 9.7
  BOTTOM w0.381: CZ187.1 32.09,87.23 v1(31.36,86.5) 31.11,86.24 29.2,86.24 28.06,85.1 28.06,83.45 28.5,83.01 JTUN1.2
  BOTTOM w0.508: RZ332.1 CZ181.1 32.45,87.95 CZ187.1
+3.3V_WWAN_MAIN: length 9.3
  BOTTOM w0.254: JTUN1.1 29.3,82.99 28.62,83.68 28.62,84.97 29.35,85.71 31.36,85.71 31.62,85.45 31.62,84.94 31.87,84.69 CZ186.1 32.45,85.28 CZ180.1 RZ331.1
+3.3V_WWAN_UZ4:
  vias: v6(206.8,40.79)
+5V_ALW: length 342.3
  TOP w0.203: UZ2.4 234.23,33.33 v2(234.41,33.16) ; 248.48,28.63 248.48,31.15 250.79,33.46 UZ5.4 ; v3(203.52,38.01) 203.48,38.05 UZ4.4 ; v3(23.28,31.33) 23.16,31.45 UZ3.4
  TOP w0.254: UI3.8 270.97,71.65 v2(270.71,71.38) 270.47,71.62 UI3.7 ; v3(76.01,80.07) 77.35,80.07 77.69,80.41 78.59,80.41 v2(79.27,79.73) ; 203.5,36.03 205.24,36.03 206.22,37.01 210.23,37.01 215.09,41.87 220.39,41.87 220.75,42.23 UZ8.4 ; v3(68.34,76.84) 67.96,77.22 67.1,77.22 66.69,76.82 PR602.2 ; v3(194.59,36.96) 193.58,37.98 CZ64.1 ; v2(191.71,30.67) 191.71,30.81 191.14,31.37 187.33,31.37 185.76,32.95 185.76,34.27 184.49,35.54 183.62,35.54 183.37,35.8 183.37,39.14 183.9,39.67 UZ41.4
  TOP w0.305: v2(162.16,93.6) 162.02,93.46 UZ21.3
  TOP w0.508: v2(170.69,30.48) 170.69,31.66 PL407.1 ; v2(89.15,70.59) 88.99,70.75 PR686.1 88.99,72.1 88.25,72.84 85.55,72.84 v2(84.86,73.53) ; v3(244.92,31.81) 244.92,30.77 247.06,28.63 248.61,28.63 249.84,27.4 250.6,27.4 252.04,25.97 v2(259.07,25.97) ; v2(165.17,94.34) 165.17,93.02 167.54,90.65 171.77,90.65 173.18,89.25 173.18,85.08 176.16,82.1 v6(176.16,76.65) 176.16,75.85 v2(175.4,75.09) 173.44,73.14 173.44,67.6 178.59,62.46 178.59,60.76 180.39,58.96 180.39,55.8 177.84,53.26 177.84,45.34 175.73,43.24 174.18,43.24 170.68,39.74 170.68,37.85 170.76,37.78 v2(170.76,37.17) ; PR1300.1 90.92,64.35 PR691.1 89.73,65.38 v2(89.57,65.54) ; v2(265.02,42.17) 264.88,42.04 RA54.2 ; DT1.2 27.71,31.68 v3(27.68,31.71)
  GND1 w0.203: v4(23.88,31.42) 23.79,31.33 v3(23.28,31.33)
  GND1 w0.254: v3(26.5,79.08) v4(26,79.08) ; v3(76.01,80.07) 75.99,80.1 v4(75.99,81.29) ; v4(68.82,76.79) 68.78,76.79 68.78,76.79 68.72,76.84 v3(68.34,76.84)
  GND1 w0.508: v3(194.59,36.96) 194.14,36.51 v4(194.12,36.51) ; v3(201.69,37.92) 201.67,37.94 v4(201.67,38.41) ; v3(244.92,31.81) 244.92,32.14 v4(244.75,32.32) ; v3(203.52,38.01) 203.5,37.98 v4(202.63,37.98) ; v4(28.14,31.91) 27.93,31.71 v3(27.68,31.71) ; v3(92.54,47.51) v4(92.02,47.51)
  IN1 w0.254: v4(75.99,81.29) 75.86,81.16 71.16,81.16 70.63,80.63 70.63,79.43 69.56,78.37 69.56,77.12 69.23,76.79 v4(68.82,76.79)
  IN1 w0.508: v4(23.88,31.42) 23.14,31.42 21.4,33.16 21.4,36.69 21.94,37.22 21.94,39.35 21.39,39.9 21.39,45.37 20.74,46.01 20.74,46.67 20.17,47.25 19.36,47.25 19.04,47.57 19.04,49.01 19.75,49.72 19.75,56.14 19.25,56.65 v4(19.25,56.68) ; v4(244.75,32.32) 244.75,32.22 244.2,31.67 236.48,31.67 235.65,32.5 235.07,32.5 v2(234.41,33.16) ; v4(229.89,53.3) 229.89,53.83 229.89,56.57 229.25,57.21 229.25,57.21 228.34,57.21 227.88,57.67 227.88,59.17 231.82,63.1 v4(233.04,63.1)
  IN2 w0.508: v4(171.39,81.56) 171.39,79.88 175.4,75.87 v2(175.4,75.09) ; v2(94.32,58.67) 94.32,57.07 94.02,56.78 94.02,54.85 92.02,52.84 v4(92.02,47.51) ; v2(165.17,94.34) 162.9,94.34 v2(162.16,93.6)
  IN3 w0.254: v2(79.27,79.73) 84.24,79.73 84.86,79.11 v2(84.86,73.53)
  IN3 w0.508: v4(202.63,37.98) 202.2,38.41 v4(201.67,38.41) 201.66,38.41 200.85,38.41 200.12,37.68 197.13,37.68 195.76,36.31 194.33,36.31 v4(194.12,36.51) ; v2(31.92,28.46) 30.78,27.31 30.78,26.63 v4(30.14,25.99) ; v2(89.15,70.59) 89.57,70.18 v2(89.57,65.54) 89.57,64.28 90.78,63.07 92.95,63.07 94.32,61.71 v2(94.32,58.67)
  IN4 w0.508: v4(86.03,49.96) 86.84,49.96 87.47,49.34 88.41,49.34 90.24,47.51 v4(92.02,47.51)
  GND5 w0.254: v5(29.61,26.07) 30.07,26.07 v4(30.14,25.99) ; v5(76.17,81.8) 76.04,81.67 76.04,81.34 v4(75.99,81.29)
  GND5 w0.508: v5(171.45,80.9) 171.45,81.51 v4(171.39,81.56) ; v5(85.51,50.1) 85.9,50.1 v4(86.03,49.96) ; v5(229.89,52.66) v4(229.89,53.3) ; v4(19.25,56.68) 19.25,56.65 19.56,56.33 v5(19.56,56.22) ; v4(233.04,63.1) 233.14,63 v5(234,63) ; v5(194.12,35.72) v4(194.12,36.51)
  BOTTOM w0.203: PR615.2 74.75,82.07 PR634.2
  BOTTOM w0.254: v5(76.17,81.8) 75.89,82.07 PR615.2 ; JUSH1.18 193.25,35.34 193.63,35.72 v5(194.12,35.72)
  BOTTOM w0.305: PC661.1 89.79,70.61 90.26,71.07 PU610.15 ; PU612.15 94.23,59.28 PC1337.1
  BOTTOM w0.508: PC661.1 89.48,70.27 v2(89.15,70.59) ; JPWR1.1 v2(297.5,25.97) ; v5(229.89,52.66) 229.89,50.79 228.86,49.77 228.08,49.77 227.57,49.25 227.57,48.53 228.49,47.61 228.49,46.87 232.55,42.8 232.55,39.5 233.09,38.96 233.09,38.41 234.56,36.93 234.56,33.31 v2(234.41,33.16) ; PC1337.1 94.32,59.24 v2(94.32,58.67) 94.32,57.97 PR1298.1 ; JSEN2.10 v5(234,63) ; PR688.1 v2(84.86,73.53) ; PL408.1 162.26,36.24 v2(161.9,36.6)
  vias: v2(17.23,26.97) v2(17.82,26.95) v2(17.94,26.15) v2(18.37,26.72) v2(18.52,26.15) v2(18.86,27.05) v2(26.64,77.61) v2(26.92,75.23) v2(27.1,75.79) v2(27.25,77.61) v2(27.52,75.36) v2(33.29,41.97) v2(33.32,41.36) v2(33.34,40.78) v2(33.88,41.97) v2(33.9,41.39) v2(33.93,40.78) v2(45.89,68.67) v2(45.89,68.03) v2(45.89,67.4) v2(45.89,66.76) v2(45.87,66.1) v2(45.87,65.47) v2(45.89,64.8) v2(46.53,68.65) v2(46.52,68.03) v2(46.52,67.4) v2(47.16,68.67) v2(47.16,68.03) v2(47.16,67.4) v2(47.79,68.67) v2(47.79,68.03) v2(47.79,67.4) v2(201.29,28.03) v2(201.9,28.03) v2(202.48,28.03) v2(203.07,28.03) v2(267.05,76.87) v2(267.38,77.35) v2(267.84,76.18) v2(268.17,75.7) v3(26.51,79.46) v3(26.51,78.7) v4(42.18,36.74) v4(42.56,36.28) v4(42.77,36.92) v4(42.84,35.75) v4(43.15,36.28) v4(43.35,36.92) v4(43.48,35.75) v4(43.73,36.28) v4(43.93,36.89) v4(44.37,36.28) v6(20.53,28.41) v6(202.48,36.85)
+5V_ALW2:
  vias: v2(54.44,69.8)
+5V_ALW_PDA: length 0.9
  GND5 w0.381: v5(30.72,75.53) 31.14,75.95 v4(31.14,76.23)
  vias: v1(35.17,78.71) v2(33.8,76.54) v2(34.41,76.51) v2(34.99,76.49) v3(34.05,77.96) v3(34.05,77.58) v3(34.43,77.96) v3(34.43,77.58) v3(34.82,77.96) v3(34.82,77.58) v4(33.82,77.12) v4(34.46,77.1) v4(35.07,77.1) v5(32.72,76.03) v5(32.81,76.41) v5(33.19,76.41) v5(33.22,76.03) v5(33.72,76.03) v5(34.22,76.03)
+5V_ALW_PDB: length 0.6
  GND5 w0.254: v4(31.18,44.74) 30.79,45.12 v5(30.73,45.12)
  vias: v1(32.49,41.3) v2(31.46,40.67) v2(31.84,40.17) v2(32.12,40.73) v2(32.5,40.17) v2(32.76,40.73) v2(33.11,40.17)
+5V_ALWP: length 18
  TOP w0.127: v2(54.78,70.82) v6(55.25,71.29)
  IN1 w0.254: v2(54.78,70.82) 54.91,70.82 55.54,70.19 55.54,62.32 54.65,61.43 v2(49.19,61.43)
  BOTTOM w0.203: v2(54.78,70.82) PR117.2
  BOTTOM w0.254: v2(54.78,70.82) 54.58,70.63 PU102.14
  vias: v2(45.89,63.86) v2(45.89,63.23) v2(45.89,62.59) v2(46.3,62.16) v2(46.5,62.72) v2(47.08,62.95) v2(47.08,62.32) v2(47.72,62.95) v2(47.72,62.32) v2(48.35,62.95) v2(48.35,62.32) v2(48.99,62.95) v2(48.99,62.32) v2(49.62,62.95) v2(49.62,62.32)
+5V_PD_VDD:
  vias: v6(29.68,25.56)
+5V_RUN: length 347.3
  TOP w0.356: v3(192.31,38.18) 192.31,37.74 192.56,37.49 CZ71.1
  TOP w0.508: v2(249.34,75.65) 249.41,75.71 RZ370.1 ; v2(174.94,70.01) 174.94,70.99 CE32.1 176.32,71.82 176.32,70.95 DE1.1 176.7,69.17 177.89,67.98 v2(177.89,67.06)
  GND1 w0.508: v3(192.31,38.18) 192.75,38.18 v4(192.83,38.26)
  IN1 w0.508: v2(236.67,37.45) 236.39,37.45 231.24,42.6 v2(231.24,45.92)
  IN2 w0.508: v2(199.73,38.31) 199.71,38.3 199.71,37.58 198.54,36.4 197.36,36.4 196.65,35.69 185.67,35.69 184.7,36.66 v4(180.36,36.66) ; v2(188.59,50.05) 187.89,50.05 187.14,50.79 185.35,50.79 180.09,56.06 180.09,59.19 178.6,60.69 178.6,64.59 177.89,65.29 177.89,67.06 v2(177.89,67.06)
  IN3 w0.508: v4(22.01,40.67) 21.86,40.52 21.86,39.78 27.85,33.79 30.46,33.79 31.95,32.3 34.88,32.3 38.44,35.86 40.75,35.86 42.31,34.3 43.98,34.3 44.86,33.42 51.6,33.42 52.59,34.4 53.85,34.4 54.63,33.63 56.09,33.63 57.93,35.47 57.93,37.84 60.15,40.06 62.17,40.06 67.48,45.37 74.26,45.37 75.17,44.46 77.35,44.46 78.75,45.86 79.44,45.86 79.75,45.55 84.83,45.55 85.9,44.47 87.86,44.47 89.76,42.58 89.76,37.02 92.25,34.53 95.52,34.53 97.58,32.47 117.39,32.47 117.77,32.85 163.01,32.85 ; v2(201.18,32.2) 200.38,31.4 197.48,31.4 195.98,29.9 182.45,29.9 179.97,32.39 176.15,32.39
  IN4 w0.381: v4(22.01,40.67) 21.35,41.33 19.54,41.33 18.28,42.59 18.28,50.22 17.95,50.55 17.95,51.8 18.48,52.33 v4(18.74,52.33)
  IN4 w0.508: v2(231.24,45.92) 237.65,52.33 237.65,57.61 247.02,66.97 247.02,68.97 249.92,71.88 249.92,73.73 249.05,74.6 249.05,75.36 v2(249.34,75.65)
  GND5 w0.381: v5(18.74,52.82) v4(18.74,52.33) ; v5(179.87,37.17) 179.98,37.17 180.36,36.79 v4(180.36,36.66)
  GND5 w0.508: v5(192.78,37.49) 192.79,37.5 192.79,37.71 192.83,37.75 v4(192.83,38.26) ; v5(238.35,34.27) 238.8,33.82 v4(238.8,33.49)
  BOTTOM w0.254: v5(179.87,37.17) 179.87,37.07 180.59,36.35 180.59,35.66 180.25,35.32 JKBTP1.5 ; JUSH1.20 192.25,35.52 192.57,35.85 192.57,37.29 v5(192.78,37.49)
  BOTTOM w0.381: v5(18.74,52.82) 18.76,52.79 19.5,52.79 19.91,53.2 19.91,53.48 RV314.1
  BOTTOM w0.508: v2(236.67,37.45) 236.67,36.38 238.35,34.71 v5(238.35,34.27) ; v2(188.59,50.05) 188.59,50.25 188.99,50.66 189.5,50.66 189.86,50.3 189.86,50.07 191.38,48.55 193.57,48.55 197.08,45.03 v2(197.08,43.16) ; JFAN1.4 167.84,68.13 167.99,67.98 172.91,67.98 v2(174.94,70.01)
  vias: v2(201.44,33.13) v2(201.83,32.24) v2(202.1,33.13) v2(251.53,34.76) v2(252.02,35.18) v2(252.46,35.56) v2(252.87,35.98) v4(236.77,33.49) v4(237.41,33.49) v4(238.04,33.49) v6(200.79,38.95)
+5V_RUN_AUDIO: length 0.6
  TOP w0.102: v2(271.82,46.06) v6(271.82,46.71)
  vias: v2(257.37,37.72) v2(257.37,37.13) v2(257.37,36.55) v2(257.93,37.4) v2(257.93,36.76) v2(270.81,45.4) v2(270.78,44.81) v2(271.29,45.75) v2(271.85,45.42)
+5V_RUN_CHG: length 1.4
  TOP w0.086: QZ4.1 250.8,75.27 RZ370.2
+5V_RUN_PVDD_L:
  vias: v6(266.41,44.1)
+5V_TBT_VBUS: length 2.1
  TOP w0.508: DT2.2 29,33.46 30.04,34.5 v1(30.04,34.77)
+5V_TBTA_VBUS_D: length 4.3
  TOP w0.508: v1(25.6,29.78) 25.6,30.5 DT3.2 23.92,32.18 v2(23.92,32.24)
  BOTTOM w0.508: v2(23.92,32.24) 23.61,32.24 23.29,32.56 UT8.3
+5V_TBTB_VBUS_D: length 6
  TOP w0.508: v1(27.02,29.65) 26.83,29.84 DT38.2 26.83,31.77 27.6,32.55 v3(27.98,32.55)
  GND1 w0.508: v4(28.74,32.57) 28.72,32.55 v3(27.98,32.55)
  GND5 w0.508: v4(28.74,32.57) 29,32.57 v5(29.35,32.93)
  BOTTOM w0.508: v5(29.35,32.93) 30.06,32.93 UT12.3
+5V_USB_CHG_PWR: length 1.8
  IN2 w0.508: JUSB1.1 288.46,66
  IN4 w0.508: JUSB1.1 288.46,66
  vias: v2(271.57,75.78) v2(271.75,75.2) v2(272.15,75.63) v2(272.32,75.05) v2(272.89,74.89) v2(272.99,74.31) v2(287.32,59.27) v2(287.32,58.63) v2(287.32,58) v2(287.44,57.36) v2(288.08,57.36) v2(288.71,57.36) v2(291.76,56.85) v2(291.89,56.09) v2(292.52,56.09) v2(293.16,56.09) v2(293.79,56.09) v2(294.05,56.85) v6(290.21,57.07)
+VCC1V8A_TBTA_LDO: length 4.4
  TOP w0.127: v1(29.08,72.7) 28.54,72.17 CT73.1
  TOP w0.254: v2(28.49,70.43) 28.52,70.43 28.66,70.57 28.67,70.57 28.95,70.85 28.95,70.86 28.97,70.88 28.97,71.29 CT73.1
  BOTTOM w0.254: v2(28.49,70.43) 29.13,70.43 UT5.K1
+VCC1V8A_TBTB_LDO: length 1.8
  GND1 w0.203: v4(27.14,46.08) 26.87,45.81 v3(26.61,45.81)
  GND5 w0.229: v4(27.14,46.08) 26.85,46.36 v5(26.48,46.36)
  BOTTOM w0.229: UT11.K1 26.44,46.34 26.46,46.34 v5(26.48,46.36)
+VCC1V8D_TBTA_LDO: length 3.7
  TOP w0.102: CT72.1 35.43,71.46 v1(35.62,71.65)
  TOP w0.254: RT97.1 CT72.1 34.71,70.77 v2(34.76,70.72)
  BOTTOM w0.254: UT5.A2 34.76,70.98 v2(34.76,70.72)
+VCC1V8D_TBTB_LDO: length 6
  TOP w0.254: v3(25.26,41.08) 25.26,41.08 25.24,41.1 25.24,41.56 25.37,41.69 25.37,41.69 25.67,42 RT191.1
  GND1 w0.254: v3(25.26,41.08) 25.26,41.08 25.26,40.94 v4(25.55,40.66)
  GND5 w0.254: v4(25.55,40.66) 25.71,40.66 25.97,40.91 v5(25.97,40.92)
  BOTTOM w0.254: UT11.A2 26.71,41.62 26,40.92 v5(25.97,40.92) 25.44,40.92 v1(24.93,40.41) 24.03,39.5 CT148.1
+VCC3V3_ANA_PCIE: length 1.1
  TOP w0.305: v2(32.05,56.98) 32.05,56.99 CT63.1
  BOTTOM w0.254: UT1.L16 v2(32.05,56.98)
+VCC3V3_ANA_USB2: length 1.1
  TOP w0.305: v2(31.4,56.98) 31.4,57.6 CT64.1
  BOTTOM w0.254: v2(31.4,56.98) 31.4,56.98 UT1.J16
+VCC_1P8: length 1.1
  BOTTOM w0.254: UC1.U12 149.5,72.21 v2(149.83,71.89) 150.15,72.21 UC1.U11
  vias: v1(150.64,72.17)
+VCC_CORE: length 42.6
  TOP w0.254: v2(137.47,66.33) 137.61,66.18 PC1031.1 137.63,65.71 PC1038.1 137.17,64.7 PC1032.1 ; PC1051.1 137.04,78.05
  GND1 w0.254: v3(134.33,64.94) 134.07,64.94 133.82,65.2 v2(133.82,66.4) ; v4(136.01,81.95) v3(136.01,81.47) ; v4(134.64,81.72) 134.54,81.62 v3(134.15,81.62)
  IN1 w0.457: v2(132.55,67.73) 131.59,68.69 v2(131.59,68.83)
  GND5 w0.254: v4(136.01,81.95) 135.94,81.88 v5(135.94,81) ; v5(133.77,81.37) 134.33,81.37 134.64,81.67 v4(134.64,81.72)
  BOTTOM w0.102: 138.22,77.3 UC1.G32 137.93,77.01
  BOTTOM w0.127: 131.53,76.07 UC1.K43 131.53,76.7 ; 135.19,76.68 UC1.K37 ; UC1.K37 134.89,76.37 ; UC1.K37 135.19,76.07 ; 137.47,65.22 UC1.AL33 ; UC1.AL33 137.13,65.54 ; UC1.AL33 137.47,65.88 ; UC1.AL33 137.77,65.54 ; UC1.AK38 134.27,66.35 ; UC1.AK38 134.27,65.66 ; UC1.AK38 133.95,66 ; UC1.AK35 135.97,66 v2(135.64,66.33) 135.32,66 UC1.AK37 ; UC1.AK35 136.1,66.32 ; UC1.AK35 136.1,65.64 ; UC1.AK35 136.23,66 v2(136.55,66.32) 136.87,66 UC1.AK33 ; 136.1,76.07 UC1.K35 ; UC1.K35 136.1,76.74 ; UC1.K35 136.39,76.37 ; UC1.AL37 135.64,65.23 ; UC1.AL37 135.64,65.84 ; UC1.AL37 135.92,65.54 ; UC1.AL37 135.32,65.54 ; 135.19,65.65 UC1.AK37 ; UC1.AK37 135.19,66.33 ; 138.55,77.3 UC1.G30 138.84,77.59 ; 132.44,76.72 UC1.K42 132.44,76.07 ; 134.27,77.01 UC1.G38 134.56,77.3 ; UC1.J33 136.56,77.14 ; UC1.J33 136.25,76.84 ; UC1.J33 136.86,76.84 ; UC1.J33 136.56,76.51 ; UC1.K38 134.56,76.37 ; UC1.K38 134.27,76.72 ; UC1.K38 134.27,76.07 ; 133.64,66 UC1.AK40 133.36,66.37 ; 138.08,76.84 UC1.J30 ; UC1.J30 138.39,77.16 ; UC1.J30 138.39,76.53 ; 137.01,65.64 UC1.AK33 ; UC1.AK33 137.01,66.35 ; UC1.AK33 137.15,66 v2(137.47,66.33) ; 132.44,77.01 UC1.G42 132.73,77.3 ; 136.72,77.3 UC1.G33 137.01,77.01 ; 136.39,77.3 UC1.G35 136.1,77.01 ; 134.14,65.54 UC1.AL40 133.81,65.89 ; 135.19,77.01 UC1.G37 134.89,77.3 ; UC1.J37 134.73,77.14 ; UC1.J37 134.73,76.53 ; UC1.J37 135.03,76.84 ; UC1.J37 134.42,76.84 ; UC1.J40 v2(132.9,76.11) ; UC1.J40 132.9,77.14 ; UC1.J40 132.59,76.84 ; UC1.J40 133.2,76.84 ; UC1.K33 136.72,76.37 ; UC1.K33 137.01,76.07 ; UC1.K33 137.01,76.7 ; 133.36,77.01 UC1.G40 133.06,77.3 ; 133.36,76.07 UC1.K40 133.36,76.68
  BOTTOM w0.152: UC1.A44 130.98,81.88 v2(131.1,82)
  BOTTOM w0.203: UC1.A30 138.42,81.62 v2(138.4,81.64)
  BOTTOM w0.254: v5(133.77,81.37) 133.77,81.34 133.46,81.03 UC1.A39 ; v2(132.91,78.21) v2(132.91,77.61)
  BOTTOM w0.508: v2(138.4,81.64) 138.25,81.79 138.25,83.43 140,85.18 140,85.98 139.64,86.34 RC140.2
  vias: v2(98.7,71.55) v2(98.7,70.96) v2(98.7,70.38) v2(98.7,69.8) v2(98.7,69.21) v2(98.67,64.74) v2(99.28,71.55) v2(99.28,70.96) v2(99.28,70.38) v2(99.28,69.8) v2(99.28,69.21) v2(99.26,64.74) v2(99.5,68.58) v2(99.5,67.99) v2(99.5,67.41) v2(99.5,66.82) v2(99.5,66.24) v2(100.09,70.42) v2(100.16,72.83) v2(100.21,68.1) v2(100.79,68.1) v2(101.26,70.42) v2(101.43,72.83) v2(101.38,68.1) v2(101.54,75.33) v2(101.54,74.75) v2(101.91,80.45) v2(101.91,79.87) v2(101.96,68.1) v2(102.13,75.33) v2(102.13,74.75) v2(102.49,80.45) v2(102.49,79.87) v2(102.54,68.1) v2(102.63,71.47) v2(102.62,70.06) v2(102.62,69.48) v2(102.71,75.33) v2(102.71,74.75) v2(102.71,74.16) v2(102.71,73.58) v2(102.71,73) v2(103.13,68.1) v2(103.22,71.47) v2(103.21,70.06) v2(103.21,69.48) v2(103.29,75.33) v2(103.29,74.75) v2(103.29,74.16) v2(103.29,73.58) v2(103.29,73) v2(103.79,72.28) v2(103.79,71.7) v2(103.79,71.12) v2(103.79,70.53) v2(103.79,69.95) v2(103.79,69.36) v2(103.79,68.78) v2(103.88,76.97) v2(103.88,76.39) v2(103.88,75.8) v2(103.88,75.22) v2(103.88,74.63) v2(103.88,74.05) v2(103.88,73.47) v2(103.88,72.88) v2(104.37,72.28) v2(104.37,71.7) v2(104.37,71.12) v2(104.37,70.53) v2(104.37,69.95) v2(104.37,69.36) v2(104.37,68.78) v2(104.46,76.97) v2(104.46,76.39) v2(104.46,75.8) v2(104.46,75.22) v2(104.46,74.63) v2(104.46,74.05) v2(104.46,73.47) v2(104.46,72.88) v2(131.53,75.72) v2(131.61,70.01) v2(131.59,69.43) v2(131.94,75.28) v2(132.28,69.12) v2(132.45,75.73) v2(132.76,73.9) v2(132.9,75.34) v2(132.9,71.44) v2(133.34,75.73) v2(133.47,69.1) v2(133.8,75.34) v2(133.82,67.12) v2(134,73.9) v2(134.07,71.46) v2(134.24,75.73) v2(134.3,66.73) v2(134.64,69.12) v2(134.71,77.63) v2(134.73,76.1) v2(134.71,75.32) v2(134.73,66.33) v2(134.76,67.13) v2(135.21,75.72) v2(135.22,73.9) v2(135.2,66.73) v2(135.29,71.46) v2(135.66,75.31) v2(135.67,67.14) v2(135.72,64.73) v2(135.86,69.12) v2(136.09,66.71) v2(136.15,75.72) v2(136.42,73.88) v2(136.54,71.5) v2(136.54,67.14) v2(136.61,77.61) v2(136.6,76.12) v2(136.57,75.29) v2(137.04,75.71) v2(136.97,66.73) v2(137.05,69.15) v2(137.64,73.89) v2(137.8,71.54) v2(138.19,70.29) v2(138.32,71.84) v2(138.37,77.61) v2(138.39,76.15) v2(138.4,69.69) v2(138.86,73.87) v6(100.91,74.76)
+VCC_CORE_G0: length 1.5
  TOP w0.254: T122.1 138.15,75.64 v2(137.93,75.43)
  BOTTOM w0.127: UC1.K32 v2(137.93,75.43)
+VCC_CORE_G1: length 1.6
  TOP w0.254: v2(137.93,67.04) 137.7,66.82 T123.1
  BOTTOM w0.127: v2(137.93,67.04) UC1.AK32
+VCC_GT: length 39.2
  TOP w0.508: RC437.1 128.82,86.49 127.45,85.12 v3(127.45,83.98)
  GND1 w0.508: v3(127.45,83.98) 127.45,83.57 v4(127.3,83.42)
  IN1 w0.457: v2(112.21,74.07) 112.21,73.52 ; v2(110.86,74.1) 110.86,73.57
  IN3 w0.508: v2(123.55,81.86) 123.53,81.84 v2(121.09,81.84) 119.83,81.84 119.43,82.24 119.03,82.24 v2(118.61,81.82)
  IN4 w0.508: v4(127.3,83.42) 126.48,82.61 124.3,82.61 v2(123.55,81.86)
  BOTTOM w0.127: 121.18,75.34 UC1.L62 ; UC1.L62 121.18,75.94 ; UC1.L62 121.55,75.64 ; UC1.L62 120.82,75.64 ; UC1.Y62 121.18,70.76 ; UC1.Y62 121.18,71.36 ; UC1.Y62 120.87,71.06 ; UC1.Y62 121.47,71.06 ; UC1.T62 121.18,72.59 ; UC1.T62 121.18,73.18 ; UC1.T62 120.85,72.89 ; UC1.T62 121.48,72.89 ; UC1.K55 125.13,76.69 ; UC1.K55 125.13,75.96 ; UC1.K55 125.42,76.37 ; UC1.K55 124.83,76.37 ; 120.71,74.87 UC1.L63 ; UC1.L63 121.06,75.18 ; UC1.L63 120.4,75.18 ; 123.01,76.37 UC1.K58 ; UC1.K58 123.59,76.37 ; UC1.K58 123.3,76.66 ; UC1.K58 123.3,76.03 ; UC1.J53 125.91,76.84 ; UC1.J53 125.58,76.53 ; UC1.J53 125.26,76.84 ; UC1.K60 122.68,76.37 ; UC1.K60 122.38,76.69 ; UC1.K60 122.09,76.37 ; UC1.K60 122.38,76.01 ; 120.71,70.28 UC1.AA63 ; UC1.AA63 120.4,70.61 ; UC1.AA63 120.71,70.9 ; UC1.AA63 121.01,70.61 ; UC1.K53 126.04,76.07 ; UC1.K53 126.04,76.66 ; UC1.K53 125.75,76.37 ; 123.21,76.84 UC1.J58 ; UC1.J58 122.84,76.53 ; UC1.J58 122.5,76.84 ; 123.42,76.84 UC1.J56 ; UC1.J56 123.76,76.53 ; UC1.J56 124.1,76.84 ; 124.67,76.53 UC1.J55 ; UC1.J55 124.34,76.84 ; UC1.J55 125,76.84 ; 121.01,73.35 UC1.R63 ; UC1.R63 120.37,73.35 ; UC1.R63 120.71,73.69 ; UC1.R63 120.71,73.04 ; 121.18,74.42 UC1.M62 ; UC1.M62 120.85,74.72 ; UC1.M62 121.18,75.01 ; UC1.M62 121.47,74.72 ; UC1.W63 120.71,71.26 ; UC1.W63 120.4,71.52 ; UC1.W63 121.04,71.52 ; 124.21,75.99 UC1.K56 ; UC1.K56 124.21,76.69 ; UC1.K56 123.92,76.37 ; UC1.K56 124.51,76.37 ; 121.93,76.53 UC1.J60 122.28,76.84 ; 120.71,73.93 UC1.N63 ; UC1.N63 121,74.26 ; UC1.N63 120.71,74.56 ; UC1.N63 120.4,74.26
  BOTTOM w0.203: v2(121.09,81.84) 121.07,81.83 UC1.A62 ; UC1.A66 118.59,81.81 v2(118.61,81.82) ; v2(123.55,81.86) UC1.A58
  vias: v2(101.91,55.95) v2(101.91,55.37) v2(101.91,54.78) v2(102.49,55.95) v2(102.49,55.37) v2(102.49,54.78) v2(103.08,55.95) v2(103.08,55.37) v2(103.08,54.78) v2(103.66,55.95) v2(103.66,55.37) v2(103.66,54.78) v2(104.25,55.95) v2(104.25,55.37) v2(104.25,54.78) v2(104.66,60.13) v2(105.08,60.55) v2(105.49,60.96) v2(105.9,62.58) v2(105.9,62) v2(105.9,61.41) v2(106.48,71.99) v2(106.52,70.71) v2(106.48,62.58) v2(106.48,62) v2(106.48,61.41) v2(106.72,73.49) v2(107.12,71.99) v2(107.08,67.2) v2(107.07,62.58) v2(107.07,62) v2(107.07,61.41) v2(107.15,70.71) v2(107.36,73.49) v2(107.71,67.2) v2(107.65,62.58) v2(107.65,62) v2(107.65,61.41) v2(107.75,71.99) v2(107.79,70.71) v2(107.99,73.49) v2(108.35,67.2) v2(108.39,71.99) v2(108.42,70.71) v2(108.98,67.2) v2(109.32,72.75) v2(110.16,70.37) v2(110.52,72.72) v2(111.37,70.37) v2(111.73,72.73) v2(112.58,70.33) v2(112.94,72.74) v2(113.76,70.33) v2(114.14,72.74) v2(114.97,70.36) v2(115.83,73.81) v2(115.8,71.06) v2(115.86,72.88) v2(116.48,74.72) v2(116.49,73.8) v2(116.48,72.89) v2(116.48,71.06) v2(117.13,73.81) v2(117.13,70.15) v2(117.16,71.08) v2(117.78,74.72) v2(117.78,72.89) v2(117.78,71.98) v2(117.78,71.06) v2(118.43,73.81) v2(118.43,71.06) v2(118.43,70.15) v2(119.08,74.72) v2(119.11,73.8) v2(119.08,72.89) v2(119.08,71.06) v2(119.75,75.66) v2(119.73,71.98) v2(119.75,71.1) v2(120.36,74.71) v2(120.41,73.78) v2(120.36,72.88) v2(120.38,71.08) v2(120.44,70.14) v2(121.45,75.17) v2(121.47,73.35) v2(121.91,76.11) v2(121.86,71.01) v2(122.39,75.7) v2(122.84,76.13) v2(122.83,68.74) v2(122.85,75.27) v2(122.85,73.34) v2(123.28,75.73) v2(123.34,71.01) v2(123.74,75.29) v2(123.76,76.11) v2(124.08,73.34) v2(124.09,68.54) v2(124.22,75.7) v2(124.55,71) v2(124.71,76.1) v2(124.73,75.24) v2(124.71,68.53) v2(125.16,75.65) v2(125.3,70.98) v2(125.36,73.33) v2(125.62,76.13) v2(125.79,75.44) v6(103.15,64.11)
+VCC_GT_+VCC_CORE: length 37.1
  TOP w0.254: v2(128.31,76.15) 128.1,76.15 127.57,76.67 PC1331.1
  TOP w0.381: v2(129.23,76.14) 128.77,76.6 PC1330.1 ; PC1332.1 126.38,76.27 v2(126.5,76.15)
  IN1 w0.457: v2(130.65,66.76) 130.94,67.05 v2(131.24,67.05)
  IN1 w0.508: v2(128.59,81.97) 127.98,81.97 127.78,81.77 v2(126.03,81.77)
  IN4 w0.203: 126.94,76.56 127.42,77.05 127.55,77.05 127.87,77.37 127.87,78.43 127.27,79.03 127.27,78.95 126.94,78.62 126.94,77.47 126.53,77.06 126.53,76.62
  IN4 w0.508: v2(126.03,81.77) 126.03,80.53 127.27,79.28 127.27,79.03
  BOTTOM w0.127: UC1.AK46 129.7,66.29 ; UC1.AK46 129.99,66 ; UC1.AK46 129.41,66 ; UC1.AK46 129.7,65.71 ; UC1.AM50 128.16,65.06 ; UC1.AM50 127.87,65.36 ; UC1.AM50 127.58,65.06 ; UC1.AK45 130.61,66.29 ; UC1.AK45 130.32,66 ; UC1.AK45 130.61,65.71 ; UC1.AK45 130.91,66 ; UC1.AK43 131.53,66.29 ; UC1.AK43 131.82,66 ; UC1.AK43 131.24,66 ; UC1.AK43 131.53,65.71 ; 127.87,65.71 UC1.AK50 ; UC1.AK50 128.16,66 ; UC1.AK50 127.87,66.29 ; UC1.AK50 127.58,66 ; UC1.AL46 130.45,65.54 ; UC1.AL46 130.16,65.83 ; UC1.AL46 129.86,65.54 ; UC1.AL46 130.16,65.24 ; UC1.K50 128.16,76.37 ; UC1.K50 127.87,76.69 ; UC1.K50 127.87,75.98 ; 128.49,65.06 UC1.AM48 ; UC1.AM48 128.78,65.36 ; UC1.AM48 129.08,65.06 ; 128.03,65.54 UC1.AL50 ; UC1.AL50 128.33,65.83 ; UC1.AL50 128.33,65.24 ; UC1.AL50 128.62,65.54 ; UC1.J48 128.33,76.53 ; UC1.J48 128.65,76.84 ; UC1.J48 127.99,76.84 ; 130.52,76.84 UC1.J45 ; UC1.J45 129.83,76.84 ; UC1.J45 130.16,76.53 ; 126.5,76.53 UC1.J52 126.84,76.84 ; UC1.J46 129.6,76.84 ; UC1.J46 128.93,76.84 ; UC1.J46 129.24,76.53 ; UC1.AK48 129.08,66 ; UC1.AK48 128.49,66 ; UC1.AK48 128.78,65.71 ; UC1.AK48 128.78,66.29 ; 131.99,65.24 UC1.AL43 ; UC1.AL43 131.69,65.54 ; UC1.AL43 131.99,65.83 ; UC1.AL43 132.28,65.54 ; UC1.K48 129.08,76.37 ; UC1.K48 128.49,76.37 ; UC1.K48 128.78,75.98 ; UC1.K48 128.78,76.74 ; 127.07,76.84 UC1.J50 ; UC1.J50 127.41,76.54 ; UC1.J50 127.75,76.84 ; 127.25,65.06 UC1.AM52 126.96,65.36 ; 131.07,76.53 UC1.J43 130.77,76.84 ; 132.44,65.71 UC1.AK42 ; UC1.AK42 132.44,66.29 ; UC1.AK42 132.15,66
  BOTTOM w0.152: UC1.A53 v2(126.03,81.77) ; UC1.A48 128.51,81.89 v2(128.59,81.97)
  vias: v1(127.32,69.74) v2(125.14,67.14) v2(125.77,67.14) v2(126.15,67.78) v2(126.41,67.14) v2(126.5,75.29) v2(126.94,66.73) v2(126.97,75.72) v2(127.39,75.29) v2(127.37,67.16) v2(127.43,66.35) v2(127.6,73.06) v2(127.6,72.45) v2(127.86,75.72) v2(127.88,66.76) v2(128.01,70.52) v2(128.01,69.78) v2(128.01,69.02) v2(128.31,75.29) v2(128.31,67.22) v2(128.35,66.34) v2(128.57,67.78) v2(128.78,75.72) v2(128.8,66.76) v2(129.24,75.28) v2(129.23,67.19) v2(129.25,66.35) v2(129.71,75.71) v2(129.71,66.75) v2(130.14,76.14) v2(130.15,75.28) v2(130.14,67.18) v2(130.2,66.37) v2(130.62,75.71) v2(131.06,76.15) v2(131.07,75.29) v2(131.11,66.38)
+VCC_GTUS: length 9.9
  BOTTOM w0.127: 125.75,66 UC1.AK53 ; UC1.AK53 126.33,66 ; UC1.AK53 126.04,66.29 ; UC1.AK53 126.04,65.71 ; UC1.AK60 122.68,66 ; UC1.AK60 122.38,66.29 ; UC1.AK60 122.38,65.71 ; UC1.AK60 122.09,66 ; 124.38,65.54 UC1.AL56 ; UC1.AL56 124.96,65.54 ; UC1.AL56 124.67,65.83 ; 124.51,66 UC1.AK56 124.21,65.71 ; 126.5,65.83 UC1.AL53 ; UC1.AL53 126.21,65.54 ; UC1.AL53 126.5,65.24 ; UC1.AM58 123.3,65.36 ; UC1.AM58 123.01,65.06 ; UC1.AM58 123.59,65.06 ; 126.33,65.06 UC1.AM53 126.04,65.36 ; 122.55,65.54 UC1.AL60 ; UC1.AL60 123.13,65.54 ; UC1.AL60 122.84,65.24 ; UC1.AL60 122.84,65.83 ; 123.01,66 UC1.AK58 ; UC1.AK58 123.3,66.29 ; UC1.AK58 123.3,65.71 ; UC1.AK58 123.59,66 ; 125.13,65.71 UC1.AK55 ; UC1.AK55 125.42,66 ; UC1.AK55 125.13,66.29 ; 123.92,65.06 UC1.AM56 124.21,65.36
+VCC_SA: length 14.4
  TOP w0.508: v3(145.71,79.56) 145.71,79.31 RC168.1
  GND1 w0.508: v3(145.71,79.56) v4(145.71,78.95)
  BOTTOM w0.127: UC1.J23 142.04,77.16 ; UC1.J23 141.74,76.84 ; UC1.J23 142.35,76.84 ; UC1.J23 142.04,76.53 ; UC1.AK25 141.89,66 ; UC1.AK25 141.59,66.31 ; UC1.AK25 141.28,66 ; UC1.G25 141.88,77.3 ; UC1.G25 141.29,77.3 ; UC1.G25 141.59,77.01 ; UC1.G25 141.59,77.59 ; 139.76,76.07 UC1.K28 ; UC1.K28 140.05,76.37 ; UC1.K28 139.76,76.68 ; 142.65,76.84 UC1.J22 142.96,76.53 ; 139.46,77.3 UC1.G28 ; UC1.G28 139.76,77.01 ; UC1.G28 140.05,77.3 ; UC1.G28 139.76,77.59 ; 140.67,76.68 UC1.K27 ; UC1.K27 140.67,76.07 ; UC1.K27 140.38,76.37 ; UC1.G27 140.96,77.3 ; UC1.G27 140.67,77.01 ; UC1.G27 140.38,77.3 ; 142.5,77.01 UC1.G23 142.21,77.3 ; 142.5,76.68 UC1.K23 ; UC1.K23 142.2,76.37 ; UC1.K23 142.79,76.37 ; UC1.K23 142.5,76.07 ; 142.5,66.31 UC1.AK23 142.2,66 ; UC1.K25 141.59,76.07 ; UC1.K25 141.89,76.37 ; UC1.K25 141.59,76.68 ; 138.84,76.07 UC1.K30 138.84,76.68 ; UC1.J27 140.52,76.84 ; UC1.J27 140.21,77.16 ; UC1.J27 140.21,76.53 ; UC1.J27 139.91,76.84
  vias: v2(97.46,52.28) v2(97.46,51.7) v2(97.46,50.28) v2(98.05,52.28) v2(98.05,51.7) v2(98.05,50.28) v2(98.63,52.28) v2(98.63,51.7) v2(98.63,50.28) v2(99.22,52.28) v2(99.22,51.7) v2(99.8,50.28) v2(100.39,50.28) v2(100.97,50.28) v2(140.23,77.6) v2(140.21,76.13) v2(140.27,72.36) v2(140.35,73.54) v2(140.69,71.17) v2(140.73,69.96) v2(141.47,66.98) v2(141.92,74.62) v2(141.94,73.79) v2(141.95,72.59) v2(142.04,77.56) v2(142.13,71.59) v2(142.07,66.99) v6(142.46,76.73)
+VCC_SFR_OC: length 43.9
  TOP w0.102: v3(94.4,43.81) v6(95.47,43.81)
  TOP w0.508: CC288.1 CC322.1 v2(142.65,66.93) ; RZ119.2 93.76,43.81 v3(94.4,43.81) 94.4,44.15 93.75,44.81 UZ26.6
  GND1 w0.508: v4(93.92,44.71) 93.92,44.29 v3(94.4,43.81)
  IN1 w0.508: v4(95.89,48.48) 94.75,48.48 93.69,47.43 93.69,44.94 v4(93.92,44.71)
  IN2 w0.508: v4(95.89,48.48) 97.2,48.48 98.1,49.39 106.21,49.39 109.64,52.82 110.25,52.82 113.83,56.4 113.83,61.3 116.88,64.35
  BOTTOM w0.203: v2(142.65,66.93) 142.65,66.92 142.96,66.61 UC1.AL23
+VDD_IO: length 100.8
  TOP w0.254: v2(276.1,88.07) 276.1,88.63 CZ170.1 275.3,88.67 274.87,89.1 LGA1.10 ; v2(256.49,26.62) 255.94,27.16 255.11,27.16 254.96,27.01 RZ510.2 RZ509.2 ; v2(269.74,83.09) 269.74,85.61 268.83,86.52 268.83,88.98 269.08,89.23 v2(270.46,89.23) 270.97,88.72 RZ121.1 271.51,88.59 271.51,88.6 LGA1.2
  IN1 w0.254: v2(270.46,89.23) 270.46,89.28 271.75,90.57 275.11,90.57 276.1,89.58 v2(276.1,88.07)
  IN4 w0.254: v2(269.74,83.09) 270.45,83.09 271.92,81.62 271.92,77.35 275.58,73.7 275.58,71.61 276.9,70.28 276.9,66.78 277.36,66.32 277.36,63.28 276.45,62.37 276.45,51.16 276.06,50.77 274.77,50.77 270.96,46.97 270.96,46.23 269.02,44.29 269.02,41.63 v4(269.16,41.49)
  GND5 w0.254: v4(269.16,41.49) 269.12,41.52 v5(268.67,41.52)
  BOTTOM w0.254: v2(256.49,26.62) 256.27,26.84 256.27,27.75 256.8,28.28 259.66,28.28 263.38,32 263.38,41.91 263.72,42.25 264.2,42.25 264.93,41.52 v5(268.67,41.52)
+VDDA_AVDD1: length 4.4
  TOP w0.356: CA9.1 270.39,40.91 CA8.1
  TOP w0.508: CA9.1 270.1,41.27 270.91,42.07 270.91,43.09 271.57,43.75 LA5.1
  vias: v1(269.22,39.26)
+VSS_PLL: length 3.8
  TOP w0.356: CE17.2 256.74,60.5 CE18.2 257.22,60.15 v1(257.66,59.71) 259.29,59.71 UE1.G1
GND: length 4111.3
  TOP w0.102: v3(275,26.76) 276.08,26.76 v6(276.38,27.06) ; v3(43.39,66.14) 43.48,66.23 v6(43.48,66.81)
  TOP w0.127: v2(79.57,42.12) 79.57,42.2 v6(78.88,42.88) ; v6(54.55,45.61) 54.55,44.74 v2(54.61,44.67) ; v3(289.98,25.82) CA22.2 ; v6(22.75,18.3) 22.88,18.42 v3(22.88,18.89) ; PC504.2 v6(217.15,31.01) ; v2(273.09,69.6) 273.31,69.82 v6(273.93,69.82) ; PC618.1 70.94,83.81 v3(70.84,83.71) ; v6(86.25,31.78) 86.26,31.77 v2(87.24,31.77) ; v6(249.32,67.9) 249.32,68.26 v2(248.96,68.61) ; v6(19.11,22.86) 19.45,23.2 v3(19.47,23.2) ; v6(215.36,37.31) v3(215.36,36.76) ; v3(239.18,45.68) 239.2,45.69 v6(239.2,46.35) ; PC926.2 v3(50.92,32.69)
  TOP w0.203: UZ3.11 v3(19.86,31.45) ; 230.52,61.2 230.49,61.23 UZ29.20 ; v2(152.01,78.27) 151.17,78.29 v2(151.16,78.29) ; v2(147.53,61.48) 147.83,60.77 v2(148.15,60.31) ; v3(28.85,54.52) 29.05,54.31 RT42.2 ; PC933.2 53.34,32.11 53.28,32.05 v3(53.28,31.3) ; UZ4.11 v3(203.48,41.42) ; v3(234.22,36.93) 234.23,36.91 UZ2.11 ; UZ5.11 v3(256.16,33.46)
  TOP w0.254: CD70.2 121.38,40.18 v2(121.28,40.27) ; PC1032.2 137.76,64.3 v2(137.47,64.02) v2(137.47,63.38) ; CZ121.2 224.53,41.76 224.06,42.23 UZ8.5 ; v2(137.47,77.61) 137.62,77.76 PC1051.2 ; v3(180,43.61) 180.88,44.49 182.68,44.49 v3(182.68,44.49) 182.69,44.49 183.66,44.49 184.92,45.75 v3(187.12,45.75) v3(195.1,45.75) 196.4,45.75 197.61,44.54 v3(203.45,44.54) v3(208.85,44.54) 210.71,44.54 v3(210.72,44.54) 211.25,44.54 213.66,46.95 v6(213.66,47) v3(214.41,47.75) 214.41,48.04 214.91,48.55 v2(214.98,48.55) 215.01,48.52 v2(216.81,48.52) 217.7,48.52 v2(217.72,48.55) v2(219.56,48.55) 223.39,48.55 v3(224.58,49.74) v3(227.63,52.79) v3(228.77,53.93) v3(229.91,55.08) 230.29,55.46 v3(230.29,56.35) 230.29,58.63 v3(230.55,58.89) 231.56,59.9 v3(231.56,59.9) ; v3(180,43.61) 179.7,43.91 179.7,44.43 179.46,44.67 179.46,47.02 v3(180,47.56) 180.28,47.84 v3(181.09,47.84) 183.58,47.84 v2(184.59,48.85) 184.59,48.94 v3(185.09,49.45) 185.75,49.45 v3(185.76,49.45) 185.76,49.45 v3(187.56,49.45) v3(189.49,49.45) 190.02,49.45 v2(190.75,50.17) ; v3(180,43.61) 179.32,42.93 v6(179.32,42.45) 179.05,42.18 v3(178.47,42.18) ; UE2.17 258.79,77.68 259.52,76.96 v2(259.52,76.73) ; v2(12.43,80.27) 12.9,79.8 DT9.2 ; CD91.2 153.11,39.85 v2(153.01,39.94) 153.12,40.05 CD85.2 153.12,41.09 152.47,41.74 CD86.2 ; v2(12.41,70.8) 12.6,70.99 DT23.2 ; v2(131.98,62.76) v2(131.99,63.38) v2(132.9,64.02) 133.03,63.89 134.6,63.89 v2(134.73,64.02) v2(135.64,64.02) ; v2(13.61,63.23) 13.53,63.31 13.44,63.31 13.25,63.5 DT27.2 ; v2(25.73,41.37) 25.74,41.38 25.95,41.38 26.46,41.89 RT193.2 ; CD109.2 148.47,38.76 148.72,39.01 CD105.2 148.72,39.95 v2(148.36,40.31) ; JUSBC2.A12 7.15,65.32 6.99,65.17 v2(6.73,65.17) ; CD68.2 118.27,37.9 v2(118.71,37.9) ; v2(145.75,72.95) 145.75,72.34 145.38,71.97 CC206.2 ; CD80.2 153.55,38.73 v2(153.59,38.69) ; UE1.C4 v2(261.42,63.38) ; DT26.2 v2(13,65.59) ; DT26.2 12.68,65.07 v2(12.49,65.26) ; DT26.2 13.36,65.07 v2(13.56,65.26) ; JXDP1.38 v3(65.37,87.72) ; v3(132.85,88.54) 132.69,88.39 CC199.2 ; v2(13.68,87.36) 13.63,87.31 13.63,87.21 13.34,86.91 DT5.2 ; CD108.2 155.74,39.25 156.15,38.84 v2(156.15,38.7) ; v2(136.56,64.75) v2(136.56,64.02) v2(135.64,64.02) ; v2(12.44,63.25) 12.51,63.25 12.75,63.5 DT27.2 ; CC279.2 v3(147.62,66.05) ; CC335.2 v3(151.38,74.83) ; v2(117.84,35.4) 117.84,35.49 CD3.2 ; v2(13.58,80.3) 13.09,79.8 DT9.2 ; v2(12.41,85.05) 12.71,85.34 DT6.2 ; CD6.2 100.32,38.49 v2(100.53,38.69) ; RI14.1 271.38,76.81 270.47,75.9 UI3.14 ; v3(190.34,43.11) 190.34,43.11 JAPS1.10 ; DT22.2 13.24,72.56 v2(13.59,72.92) ; DT22.2 12.76,72.56 v2(12.4,72.92) ; DT22.2 v2(13,73.16) ; PC1049.2 118.42,71.98 v2(118.43,71.98) 118.67,71.74 PC1329.2 ; v2(269.28,65.16) 269.28,64.9 UE1.A13 ; JXDP1.32 67.17,88.95 v3(67.38,89.16) ; v2(12.31,87.31) 12.31,87.26 12.62,86.95 12.96,86.95 DT5.2 ; v2(141.31,44.29) 141.39,44.21 CD102.2 ; CD24.2 102.97,44.62 v2(102.87,44.52) 102.76,44.62 CD22.2 ; PC1037.2 135.83,77.79 v2(135.68,77.63) ; DT5.2 13,87.41 v2(13,87.41) ; CT155.2 29.13,45.02 v3(29.25,44.89) ; CD28.2 v2(120.11,40.27) ; v2(12.98,70.47) 13,70.49 DT23.2 ; CD93.2 130.83,44.43 v2(130.7,44.43) ; v2(142.04,62.75) v2(142.04,63.38) v2(142.04,64.02) v2(141.13,64.67) v2(140.21,64.67) ; v2(118.52,46.47) 118.87,46.82 CD29.2 ; CD111.2 v6(128.38,41.28) 127.96,41.28 127.77,41.47 v2(127.04,41.47) ; v2(13,84.86) DT6.2 ; DT6.2 13.01,85.33 13.2,85.33 13.45,85.07 v2(13.56,85.07) ; v2(135.64,62.75) v2(135.64,63.38) v2(135.64,64.02) ; v2(116.5,40.17) 116.9,40.56 CD19.2 ; PC1330.2 129.35,77.5 v2(129.25,77.61) ; CD31.2 103.65,38.77 104.39,38.77 CD10.1 104.44,39.18 v2(104.94,39.69) 104.94,39.59 105.33,39.21 106.54,39.21 106.92,38.82 CD33.2 CD41.2 ; DT10.2 12.72,78.23 v2(12.44,77.95) ; DT10.2 v2(13,77.59) ; DT10.2 13.25,78.23 13.53,77.95 v2(13.61,77.95) ; v2(6.71,71.23) 6.44,71.23 6.29,71.07 JUSBC2.B12 ; CD26.2 112.73,45.04 v2(112.24,44.55) 111.55,43.86 CD75.2 ; PC1043.2 118.37,74.39 v2(117.78,73.81) 117.21,74.37 PC1055.2 ; DT9.2 v2(13,80.45) ; CD11.1 120.64,37.68 v2(120.64,37.09) 120.65,37.08 CD4.2 ; PC1030.2 134.05,77.86 v2(133.82,77.63) ; DT23.2 13.36,70.99 v2(13.53,70.82) ; RC114.2 120.99,78.19 120.99,77.61 v3(121.02,77.58) 121.81,77.58 v2(121.84,77.61) ; v2(139.3,64.02) v2(139.3,63.38) v2(139.3,62.75) ; v2(114.29,66.55) v2(113.15,64.5) v2(112.67,64.06) ; v2(177.84,29.05) 177.56,29.34 v3(177.56,30.07) 177.56,30.54 178.03,31.01 178.92,31.01 v3(179.37,31.45) ; v2(118.51,45.88) 118.51,45.78 117.8,45.07 CD21.2 117.62,45.04 CD16.2 ; v2(123.26,38.71) 123.16,38.61 CD42.2 ; RC324.2 142.85,71.54 PC1152.2 142.85,70.4 v2(142.77,70.32) ; JAPS1.12 v3(189.34,42.99) ; v2(123.26,44.31) 123.66,44.31 CD74.2 ; v2(151.16,78.29) 150.45,77.58 149.88,77.58 149.6,77.86 RC3.2 ; PC1047.2 119.72,73.79 v2(119.73,73.81) 119.71,73.83 PC1044.2 ; CD99.2 136.49,46.58 136.75,46.32 v2(137.76,46.32) 138.15,46.32 CD97.2 ; CD69.2 115.9,38.53 v2(116.08,38.71) ; DT27.2 v2(13,62.95) ; v2(151.86,44.73) 151.86,45.29 CD54.2 ; UE1.H4 v2(261.42,58.64) ; CD82.2 153.54,37.04 v2(153.59,37.09) ; v3(69.12,89.2) 68.97,89.05 JXDP1.26 ; CD23.2 101,44.36 v2(100.65,44.36) ; CD94.2 150.25,40.89 150.78,40.35 v2(150.78,40.25) ; v2(97.91,44.32) 98.11,44.13 CD36.2 ; CT28.2 35.94,60.87 v2(35.95,60.88) ; PC1054.2 PC1052.2 137.45,76.87 137.45,76.16 v2(137.47,76.15) ; UE1.E6 v2(263.02,61.78)
  TOP w0.279: JUSBC2.A1 7.37,70.82 6.97,71.23 v2(6.71,71.23) ; JUSBC1.A1 7.34,85.32 6.93,85.73 6.78,85.73 6.75,85.76 v2(6.72,85.76) 6.7,85.76 6.67,85.73 6.5,85.73 6.34,85.57 JUSBC1.B12 ; v2(6.73,65.17) 6.54,65.17 6.14,65.57 JUSBC2.B1 ; JUSBC1.A12 7.25,79.82 7.11,79.68 6.72,79.68 v2(6.71,79.69) 6.52,79.69 6.13,80.08 JUSBC1.B1
  TOP w0.305: PC1284.2 34.41,54.39 v3(34.26,54.24) ; QE2.1 249.95,69.55 249.01,68.61 v2(248.96,68.61) ; LGA1.8 274.57,88.1 v2(275.04,87.64) 275,87.6 LGA1.7 ; v2(157.67,93.95) 157.83,94.11 UZ21.5 ; v2(139.3,76.15) 139.3,76.3 139.36,76.36 PC1053.2 ; LGA1.6 v2(273.55,86.69) ; v2(272.74,86.69) 272.74,86.88 273.05,87.19 LGA1.5
  TOP w0.356: PC1149.2 143.69,74.72 v2(143.78,74.63) ; v3(271.01,46.62) 270.57,46.62 CA60.2 ; CT67.2 34.1,57.25 34.47,57.63 v2(34.65,57.63) ; CE11.2 253.36,66.98 253.44,66.91 253.83,66.91 v3(254.39,67.46) ; v2(132.04,78.22) 131.82,77.99 PC1098.2 ; CC209.2 146.25,70.62 145.73,71.13 v2(145.73,71.28) ; v3(24.78,44.15) 24.78,44.27 25.54,45.03 CT152.2 ; CZ169.2 277.03,86.83 v2(277.03,86.42) ; v2(24.44,29.66) 24.07,29.28 CI7.2 23.51,28.72 CI6.2 ; v2(263.33,53.5) CE20.2 CE13.2 ; v3(262.78,36.15) 262.3,36.63 CA10.2
  TOP w0.381: v2(114.38,70.36) 114.38,69.9 PC1018.2 ; v2(228.95,79.16) 228.49,78.7 CZ304.2 ; v2(109.56,70.37) 109.56,69.92 PC1177.2 ; PC1021.2 111.99,69.88 v2(111.99,70.34) ; PC1179.2 110.77,69.91 v2(110.77,70.37) ; v3(149,74.3) 148.92,74.38 147.18,74.38 v3(147.05,74.51) 147.13,74.51 147.62,74.99 v3(147.74,74.99) ; v2(111.12,72.73) 111.12,72.36 PC1175.2 ; PC1034.2 135.64,76.62 v2(135.64,76.15) ; PC1036.2 133.95,76.28 v2(133.81,76.15) ; PC1129.2 113.16,69.92 113.16,70.32 v2(113.17,70.32) ; v2(133.81,63.38) 133.81,63.89 133.63,64.08 PC1085.2 133.63,64.61 133.75,64.73 PC1097.2 133.75,65.38 CC297.2 ; PC1095.2 132.15,76.31 v2(131.99,76.15) ; PC1014.2 114.53,74.65 v2(115.06,74.13) ; PC1045.2 123.03,77.42 v2(122.84,77.61) ; v2(113.52,72.73) 113.52,72.36 PC1020.2 ; v2(114.73,72.74) 114.73,72.35 PC1019.2 ; CZ170.2 276.65,88.59 276.75,88.49 v2(276.75,88.08) ; v2(121.84,77.61) 121.84,77.44 121.83,77.43 PC1046.2 ; v2(280.09,69.72) DI4.3 v2(282.75,69.72) ; v3(41.11,82.69) 41.27,82.53 PQ1224.4 ; v2(112.35,72.73) 112.35,72.34 PC1023.2 ; v2(124.72,66.35) 124.7,66.38 v2(123.87,66.38) ; v2(126.43,77.61) 126.96,77.08 PC1332.2 ; v2(138.39,66.23) 138.2,66.04 PC1031.2 138.2,65.18 PC1038.2 ; UE5.3 v2(256.87,72.22) ; PC1134.2 112.91,75.81 v2(112.49,76.23) ; PC1176.2 109.92,72.36 v2(109.92,72.72) ; CE60.2 258.22,49.4 258.72,48.9 v2(258.77,48.9) 259.11,49.25 CE59.2 ; CT41.2 35.94,61.54 v2(35.95,61.53) ; v2(262.42,70.93) 262.53,70.93 263.02,71.41 UE4.3 ; v3(275,26.76) RA36.2
  TOP w0.457: UT7.4 34.94,26.93 35.23,27.23 v2(35.23,28.01)
  TOP w0.508: v2(271.26,77.68) 271.38,77.57 RI14.1 ; CC217.2 143.53,70.31 v2(143.58,70.36) 143.76,70.54 CC205.2 ; CC217.2 143.57,69.6 CC288.2 CC322.2 ; CC217.2 142.99,69.64 v2(142.55,69.19) ; v2(283.51,53.07) 283.48,53.1 CR21.2 ; CZ168.2 274.74,85.91 v2(274.19,85.35) ; CZ19.2 229.96,65.21 229.72,64.97 v2(229.72,64.68) ; CR18.1 278.67,51.42 v2(278.67,50.74) ; RT29.2 39.23,61.71 38.7,61.17 RT126.2 v3(38.49,61.18) ; JSD1.14 v2(298.14,52.18) ; CZ17.2 v2(229.91,91.27) ; 134.69,71.04 v2(134.69,71.46) ; v2(274.63,43.38) 275.76,42.25 RA37.2 ; SW3.1 257.24,84.79 v2(256.91,84.46) ; v2(133.38,73.86) 133.38,73.41 PC1003.2 ; JTAG1.2 v3(279.74,67.37) ; PC1064.2 137.02,73.46 v2(137.02,73.88) ; v2(73.97,69.57) 73.97,70.23 73.93,70.27 PC631.2 73.91,70.63 PR651.2 ; v2(157.9,65.87) 157.77,66 CC204.2 ; CR8.2 283.91,62.39 v2(284.13,62.6) CR3.2 ; v2(279.87,63.48) 279.62,63.74 CR25.2 CR26.2 ; CC195.2 147.36,77.33 147.02,76.99 CC203.2 147.86,76.31 CC264.2 147.74,75.95 v3(147.74,74.99) ; v2(60.29,30.48) 60.29,30.81 PC938.2 ; v2(286.58,59.34) 286.2,59.34 CI14.2 ; v2(251.2,87.16) 250.98,87.38 RZ511.2 ; v2(296.79,57.39) 296.02,58.16 CI32.2 ; 135.9,71.04 v2(135.9,71.46) ; CZ100.2 v2(163.14,93.5) ; DA2.1 283.2,30.18 284.4,31.37 v2(284.4,33.52) ; PC1068.2 134.61,73.42 v2(134.61,73.87) ; PC211.2 88.85,31.64 v2(88.89,31.61) ; CC209.2 146.39,70.44 CC207.2 ; v3(31.06,46.39) 30.19,46.39 30.14,46.34 CT158.2 ; CV41.2 v3(16.22,49.69) ; CI32.2 v2(295.66,59.88) ; CI32.2 v2(295.66,56.45) ; CZ21.2 231.54,65.32 v2(231.91,64.95) ; CE16.2 262.35,70.85 v2(262.42,70.93) ; CE500.2 v2(251.41,82) ; CE501.2 259.59,76.65 v2(259.52,76.73) ; CR1.2 v2(273.44,53.23) ; v2(223.89,63.38) 223.69,63.18 CZ155.2 ; 232.2,61.2 232.2,60.54 231.56,59.9 ; 232.2,61.2 232.96,61.96 CZ154.2 ; 232.2,61.2 230.52,61.2 ; v2(286.58,58.1) 286.22,58.1 CI14.2 ; v2(277.61,51.34) 277.61,51.96 277.63,51.97 CR29.2 ; v2(276.45,39.18) 276.58,39.04 RA51.2 CA72.2 ; v2(79,45.25) 79.19,45.25 79.21,45.27 79.27,45.27 79.54,45.55 PR207.1 ; PC210.2 v2(87.16,37.87) ; PC164.2 49.61,60.79 v2(49.19,60.79) ; v2(54.61,44.67) 54.45,44.51 PC955.2 PR945.2 ; CD38.2 104.18,41.94 v2(104.43,41.94) ; CA63.2 254.75,40.04 v3(255.14,39.66) ; v2(29.35,84.84) 30.09,85.58 CC340.2 ; PC221.2 v3(88.89,45.3) ; RZ122.2 269.93,88.72 v2(269.33,88.72) ; RC166.2 v3(144.74,79.59) ; v2(60.93,30.49) 61.09,30.33 61.81,30.33 61.87,30.38 PC931.1 ; CE28.2 254.33,67.52 v3(254.39,67.46) ; v3(265.6,27.64) 266.03,28.07 CA69.2 ; PC952.2 55.85,61.54 v2(56.2,61.18) ; v3(225.64,34.43) 225.77,34.55 CV22.2 ; v2(150.49,68.62) 150.34,68.62 CC326.2 ; JSD1.17 298.54,49.11 v2(298.21,49.44) ; PR1231.2 41.32,85.64 v2(41.9,86.22) 41.43,86.69 PQ1208.3 ; v2(101.82,41.12) 101.62,41.32 CD37.2 ; CR20.1 v2(279.94,50.75) ; CE502.2 251.89,79.29 v2(251.89,78.7) ; CA12.2 281.53,36.08 v2(282.31,36.08) ; CE52.2 CE61.2 v2(253.7,72.55) ; PC986.2 PC988.2 v2(66.34,62.47) ; v2(65.19,74.76) 65.45,75.02 65.96,75.02 66.21,75.27 PR310.2 ; v2(35.23,28.01) 35.45,28.23 RT390.2 ; CA59.2 v3(252.8,39.33) ; CT76.2 v2(33.82,79.64) ; v3(258.95,37.5) 259.12,37.32 259.45,37.32 CA61.2 ; DA3.1 280.94,38.79 v2(280.59,38.44) ; RT38.2 35.98,54.57 v3(36.49,54.06) ; PC223.2 v2(87.24,35.45) ; CA33.2 258.89,35.83 CA54.2 258.88,36.32 v3(259.08,36.52) ; PC204.2 v2(86.02,34.88) ; CI31.2 265.64,74.39 v2(265.57,74.33) ; RC436.1 116.88,78.95 v2(116.7,78.77) ; PC605.1 65.44,77.49 v3(65.63,77.3) ; CA64.2 v3(256.61,39.53) ; CE40.2 272.86,56.85 CR5.2 v2(272.95,57.56) ; JRTC1.2 v2(290.12,20.15) ; v2(135.82,73.87) 135.82,73.45 PC1067.2 ; CE10.2 v2(244.58,73.72) ; v2(297.91,46.69) 298.22,46.38 JSD1.20 ; PC942.2 56.51,43.86 v2(56.51,44.48) ; PC622.2 v2(98.39,56.26) ; v2(140.61,66.94) 140.62,66.94 141.31,66.24 RC167.2 ; CI14.2 v2(286.55,58.73) ; v2(256.24,51.86) 256.25,51.85 CE3.2 ; 132.28,71.04 v2(132.28,71.46) ; RA35.2 v3(273.73,26.76) ; v2(133.49,71.46) 133.49,71.04 ; v2(276.51,34.72) 276.51,34.54 275.96,34 CA62.2 RA45.2 ; v2(52.74,62.95) 53.12,63.33 PC125.2 ; v2(298.31,43.61) 298.36,43.65 JSD1.23 ; CV17.2 232.83,31.1 v3(232.83,31.2) ; v2(59.58,30.46) 59.53,30.46 58.94,31.05 PR930.2 ; CZ121.2 225.39,41.76 v3(225.67,42.05) ; CR9.2 282.92,60.44 v2(282.79,60.44) ; JRTC1.4 286.96,18.5 v2(288.05,19.59) ; CT75.2 v2(29.86,79.64) ; CE47.2 v2(269.46,51.19) ; PQ1216.1 43.52,36.17 v3(44.49,37.14) 44.82,37.47 PQ1216.4 44.95,37.91 44.95,38.85 PR1257.1 ; 137.16,71.08 v2(137.16,71.5) ; v3(116.42,76.8) RC91.2 ; SW3.3 v2(258.11,90) ; v2(265.96,77.02) 265.71,76.78 CI34.2 ; DI5.1 v2(280.17,73.36) ; PC130.2 46.9,61.65 v2(46.83,61.65) ; CE12.2 v2(248.18,75.29) ; v2(268.8,77.05) CI33.2 ; JRTC1.3 v2(294.31,18.5) ; v2(229.02,91.27) CZ25.2 ; DA1.1 v2(279.93,33.52) ; CR15.2 v2(281.09,49.74) ; RT195.2 v2(28.99,37.94) ; JSD1.6 v2(287.42,46.97)
  GND1 w0.076: JNGFF1.30 242.03,48.9
  GND1 w0.127: JNGFF2.76 237.36,90.65 237.39,90.69 ; JNGFF2.76 234.24,90.65 234.12,90.78 ; JNGFF2.76 235.89,91.59 235.86,91.63 ; 247.92,58.43 247.64,58.15 JNGFF1.76 ; 247.9,35.45 247.7,35.65 JNGFF1.77 ; 235.91,67.27 235.89,67.29 JNGFF2.77 ; JNGFF2.77 237.31,68.15 ; JNGFF2.77 234.5,68.15 ; JNGFF1.77 245.35,35.65 245.08,35.38 ; JNGFF1.77 246.49,34.9 246.6,34.79 ; JNGFF1.76 245.22,58.15 244.99,58.38 ; JNGFF1.76 246.49,58.91 246.47,58.92
  GND1 w0.203: 175.47,87 H34.1 ; H34.1 178.99,88.49 ; H34.1 177.5,89.03 ; H34.1 178.99,85.51 ; H34.1 176.01,88.49 ; H34.1 177.5,84.97 ; H34.1 176.01,85.51 ; H34.1 179.53,87 ; 292.97,61.15 JUSB1.13 ; JUSB1.13 292.97,60.38 ; JUSB1.13 295.53,60.38 ; JUSB1.13 295.53,61.93 ; JUSB1.13 294.25,61.93 ; JUSB1.13 295.53,61.15 ; JUSB1.13 294.25,60.38 ; 5.56,85.83 JUSBC1.5 ; JUSBC1.5 6.25,87.76 ; JUSBC1.5 6.25,85.83 ; JUSBC1.5 6.94,87.76 ; JUSBC1.5 5.56,86.7 ; JUSBC1.5 5.56,87.76 ; JUSBC1.5 6.94,85.83 ; 11.14,44.14 JHDMI1.5 ; JHDMI1.5 11.02,44.6 ; JHDMI1.5 11.14,45.06 ; JHDMI1.5 12.06,44.14 ; JHDMI1.5 12.06,45.06 ; JHDMI1.5 12.18,44.6 ; 54.1,89.87 H11.1 ; H11.1 52.86,92.79 ; H11.1 55.78,91.55 ; H11.1 52.42,91.55 ; H11.1 54.1,93.23 ; H11.1 55.34,90.31 ; H11.1 52.86,90.31 ; H11.1 55.34,92.79 ; 46.12,34.22 PBATT1.12 ; PBATT1.12 46.82,35.22 ; PBATT1.12 45.43,36.23 ; PBATT1.12 45.43,34.22 ; PBATT1.12 45.43,35.22 ; PBATT1.12 46.12,36.23 ; PBATT1.12 46.82,36.23 ; PBATT1.12 46.82,34.22 ; JUSBC1.4 8.18,79.16 ; JUSBC1.4 8.18,78.38 ; JUSBC1.4 5.52,78.38 ; JUSBC1.4 8.18,77.6 ; JUSBC1.4 5.52,77.6 ; JUSBC1.4 6.85,77.6 ; H14.1 151.67,92.03 ; H14.1 149.33,92.03 ; H14.1 150.5,91.61 ; H14.1 149.33,94.37 ; H14.1 148.91,93.2 ; H14.1 151.67,94.37 ; H14.1 150.5,94.79 ; H14.1 152.09,93.2 ; JSD1.10 287.93,41.35 ; JSD1.10 285.67,42.8 ; JSD1.10 285.67,42.07 ; JSD1.10 287.93,42.07 ; JSD1.10 285.67,41.35 ; JSD1.10 286.8,42.8 ; JSD1.10 287.93,42.8 ; JSD1.10 286.8,41.35 ; JSD1.13 297.53,41.35 ; JSD1.13 297.53,42.07 ; JSD1.13 296.4,42.8 ; JSD1.13 295.27,42.8 ; JSD1.13 297.53,42.8 ; JSD1.13 296.4,41.35 ; JSD1.13 295.27,41.35 ; JSD1.13 295.27,42.07 ; 11.14,50.14 JHDMI1.17 ; JHDMI1.17 11.02,50.6 ; JHDMI1.17 12.06,51.06 ; JHDMI1.17 12.06,50.14 ; JHDMI1.17 11.14,51.06 ; JHDMI1.17 12.18,50.6 ; 5.47,33.23 JUSB2.13 ; JUSB2.13 6.75,33.23 ; JUSB2.13 5.47,32.45 ; JUSB2.13 8.03,32.45 ; JUSB2.13 6.75,31.67 ; JUSB2.13 5.47,31.67 ; JUSB2.13 8.03,33.23 ; JUSBC1.2 8.15,87.02 ; JUSBC1.2 8.15,86.28 ; JUSBC1.2 6.85,86.28 ; JUSBC1.2 6.85,87.76 ; JUSBC1.2 5.55,87.02 ; JUSBC1.2 5.55,87.76 ; JUSBC1.2 8.15,87.76 ; 10.42,54.35 JHDMI1.23 ; JHDMI1.23 13.08,54.35 ; JHDMI1.23 10.42,53.37 ; JHDMI1.23 11.75,55.33 ; JHDMI1.23 10.42,55.33 ; JHDMI1.23 13.08,53.37 ; JHDMI1.23 13.08,55.33 ; JHDMI1.23 11.75,53.37 ; 1.8,86.19 JUSBC1.1 ; JUSBC1.1 3.27,87.85 ; JUSBC1.1 1.8,87.85 ; JUSBC1.1 3.27,86.19 ; JUSBC1.1 3.27,87.02 ; 294.83,81.67 H18.1 ; H18.1 294.83,79.33 ; H18.1 297.17,81.67 ; H18.1 297.59,80.5 ; H18.1 296,82.09 ; H18.1 294.41,80.5 ; H18.1 296,78.91 ; H18.1 297.17,79.33 ; 4.67,6.33 H24.1 ; H24.1 4.67,1.67 ; H24.1 7,7.23 ; H24.1 3.77,4 ; H24.1 9.33,6.33 ; H24.1 9.33,1.67 ; H24.1 10.23,4 ; H24.1 7,0.77 ; 5.47,17.53 JUSB2.10 ; JUSB2.10 5.47,15.97 ; JUSB2.10 8.03,15.97 ; JUSB2.10 6.75,17.53 ; JUSB2.10 8.03,16.75 ; JUSB2.10 5.47,16.75 ; JUSB2.10 6.75,15.97 ; JUSB2.7 13.16,24.6 ; JUSB2.7 12.45,25.31 ; JUSB2.7 12.45,23.89 ; JUSB2.7 13,24.05 ; JUSB2.7 13,25.15 ; JUSBC2.2 8.18,72.52 ; JUSBC2.2 6.85,73.3 ; JUSBC2.2 8.18,71.74 ; JUSBC2.2 8.18,73.3 ; JUSBC2.2 5.52,73.3 ; JUSBC2.2 5.52,72.52 ; H4.1 167.4,60.24 ; H4.1 165.06,57.9 ; H4.1 165.7,56.2 ; H4.1 169.1,56.2 ; H4.1 167.4,55.56 ; H4.1 169.74,57.9 ; H4.1 169.1,59.6 ; H4.1 165.7,59.6 ; JUSB1.12 299.48,61.93 ; JUSB1.12 296.92,61.15 ; JUSB1.12 299.48,60.38 ; JUSB1.12 298.2,60.38 ; JUSB1.12 299.48,61.15 ; JUSB1.12 296.92,61.93 ; JUSB1.12 298.2,61.93 ; JUSB1.12 296.92,60.38 ; 298.2,76.08 JUSB1.11 ; JUSB1.11 296.92,77.63 ; JUSB1.11 299.48,76.85 ; JUSB1.11 296.92,76.85 ; JUSB1.11 298.2,77.63 ; JUSB1.11 296.92,76.08 ; JUSB1.11 299.48,76.08 ; JUSB1.11 299.48,77.63 ; JUSB2.12 4.08,31.67 ; JUSB2.12 4.08,33.23 ; JUSB2.12 2.8,31.67 ; JUSB2.12 4.08,32.45 ; JUSB2.12 1.52,32.45 ; JUSB2.12 2.8,33.23 ; JUSB2.12 1.52,33.23 ; JHDMI1.11 12.06,47.14 ; JHDMI1.11 11.14,47.14 ; JHDMI1.11 12.06,48.06 ; JHDMI1.11 12.18,47.6 ; JHDMI1.11 11.02,47.6 ; JHDMI1.11 11.14,48.06 ; 88.91,93.2 H12.1 ; H12.1 91.67,94.37 ; H12.1 89.33,92.03 ; H12.1 91.67,92.03 ; H12.1 89.33,94.37 ; H12.1 90.5,91.61 ; H12.1 92.09,93.2 ; H12.1 90.5,94.79 ; 5.53,73.3 JUSBC2.5 ; JUSBC2.5 6.25,73.3 ; JUSBC2.5 5.53,72.19 ; JUSBC2.5 6.97,71.29 ; JUSBC2.5 5.53,71.29 ; JUSBC2.5 6.97,73.3 ; JUSBC2.5 6.25,71.29 ; 3.4,37.37 JHDMI1.20 ; JHDMI1.20 5.13,37.37 ; JHDMI1.20 1.67,37.37 ; JHDMI1.20 1.67,38.35 ; JHDMI1.20 5.13,38.35 ; H20.1 71.49,65.8 ; H20.1 69.9,64.21 ; H20.1 68.73,66.97 ; H20.1 71.07,66.97 ; H20.1 69.9,67.39 ; H20.1 68.31,65.8 ; H20.1 71.07,64.63 ; H20.1 68.73,64.63 ; JUSBC2.4 8.18,63.1 ; JUSBC2.4 5.52,63.1 ; JUSBC2.4 8.18,63.88 ; JUSBC2.4 8.18,64.65 ; JUSBC2.4 6.85,63.1 ; JUSBC2.4 5.52,63.88 ; JUSB2.11 4.08,17.53 ; JUSB2.11 4.08,15.97 ; JUSB2.11 2.8,17.53 ; JUSB2.11 1.52,15.97 ; JUSB2.11 2.8,15.97 ; JUSB2.11 4.08,16.75 ; JUSB2.11 1.52,16.75 ; JUSBC2.3 3.27,63.88 ; JUSBC2.3 3.27,63.05 ; JUSBC2.3 3.27,64.71 ; JUSBC2.3 1.8,63.05 ; JUSBC2.3 1.8,64.71 ; 288,68.45 JUSB1.7 ; JUSB1.7 287.84,69 ; JUSB1.7 288,69.55 ; JUSB1.7 288.55,68.29 ; JUSB1.7 288.55,69.71 ; JUSB1.10 295.53,76.08 ; JUSB1.10 295.53,76.85 ; JUSB1.10 294.25,77.63 ; JUSB1.10 295.53,77.63 ; JUSB1.10 294.25,76.08 ; JUSB1.10 292.97,77.63 ; JUSB1.10 292.97,76.85 ; H19.1 6.67,61.02 ; H19.1 6.67,58.68 ; H19.1 3.91,59.85 ; H19.1 4.33,58.68 ; H19.1 7.09,59.85 ; H19.1 5.5,61.44 ; H19.1 5.5,58.26 ; H19.1 4.33,61.02 ; 11.75,38.87 JHDMI1.22 ; JHDMI1.22 13.08,39.85 ; JHDMI1.22 10.42,40.83 ; JHDMI1.22 13.08,40.83 ; JHDMI1.22 10.42,39.85 ; JHDMI1.22 10.42,38.87 ; JHDMI1.22 11.75,40.83 ; JHDMI1.22 13.08,38.87 ; 60.18,35.22 PBATT1.14 ; PBATT1.14 60.87,34.22 ; PBATT1.14 60.18,34.22 ; PBATT1.14 61.57,34.22 ; PBATT1.14 61.57,35.22 ; PBATT1.14 60.18,36.23 ; PBATT1.14 61.57,36.23 ; PBATT1.14 60.87,36.23 ; 4.33,89.88 H9.1 ; H9.1 3.91,91.05 ; H9.1 6.67,92.22 ; H9.1 4.33,92.22 ; H9.1 5.5,89.46 ; H9.1 7.09,91.05 ; H9.1 6.67,89.88 ; H9.1 5.5,92.64 ; JUSBC1.6 6.97,79.61 ; JUSBC1.6 6.97,77.6 ; JUSBC1.6 5.53,77.6 ; JUSBC1.6 5.53,79.61 ; JUSBC1.6 6.25,77.6 ; JUSBC1.6 6.25,79.61 ; 46.12,37.7 PBATT1.11 ; PBATT1.11 45.43,38.7 ; PBATT1.11 46.82,38.7 ; PBATT1.11 46.12,39.7 ; PBATT1.11 45.43,37.7 ; PBATT1.11 46.82,39.7 ; JUSBC1.3 1.8,79.21 ; JUSBC1.3 1.8,77.55 ; JUSBC1.3 3.27,77.55 ; JUSBC1.3 3.27,79.21 ; JUSBC1.3 3.27,78.38 ; 134.43,90.77 H13.1 ; H13.1 135.67,91.21 ; H13.1 132.75,92.45 ; H13.1 136.11,92.45 ; H13.1 133.19,93.69 ; H13.1 134.43,94.13 ; H13.1 135.67,93.69 ; H13.1 133.19,91.21 ; 290.77,4 H27.1 ; H27.1 297.23,4 ; H27.1 294,7.23 ; H27.1 296.33,6.33 ; H27.1 291.67,1.67 ; H27.1 296.33,1.67 ; H27.1 294,0.77 ; H27.1 291.67,6.33 ; 286.8,54.95 JSD1.11 ; JSD1.11 285.67,54.95 ; JSD1.11 287.93,54.95 ; JSD1.11 286.8,56.4 ; JSD1.11 287.93,55.67 ; JSD1.11 285.67,55.67 ; JSD1.11 287.93,56.4 ; 285,2.41 H26.1 ; H26.1 286.17,2.83 ; H26.1 283.41,4 ; H26.1 286.17,5.17 ; H26.1 285,5.59 ; H26.1 286.59,4 ; H26.1 283.83,2.83 ; H26.1 283.83,5.17 ; 60.18,38.7 PBATT1.13 ; PBATT1.13 61.57,38.7 ; PBATT1.13 61.57,37.7 ; PBATT1.13 60.87,39.7 ; PBATT1.13 60.18,37.7 ; PBATT1.13 61.57,39.7 ; PBATT1.13 60.87,37.7 ; PBATT1.13 60.18,39.7 ; H1.1 109.94,80 ; H1.1 105.9,81.7 ; H1.1 109.3,81.7 ; H1.1 109.3,78.3 ; H1.1 107.6,82.34 ; H1.1 105.9,78.3 ; H1.1 107.6,77.66 ; H1.1 105.26,80 ; 105.9,56.16 H2.1 ; H2.1 107.6,55.52 ; H2.1 109.3,56.16 ; H2.1 107.6,60.2 ; H2.1 109.94,57.86 ; H2.1 109.3,59.56 ; H2.1 105.9,59.56 ; H2.1 105.26,57.86 ; 242.01,50.4 JNGFF1.24 ; JNGFF1.24 242.11,50.82 ; JNGFF1.24 242.11,49.98 ; 12.57,46.1 JHDMI1.8 ; JHDMI1.8 13.61,45.64 ; JHDMI1.8 13.73,46.1 ; JHDMI1.8 13.61,46.56 ; JHDMI1.8 12.69,46.56 ; JHDMI1.8 12.69,45.64 ; 12.69,42.64 JHDMI1.2 ; JHDMI1.2 13.15,42.52 ; JHDMI1.2 12.57,43.1 ; JHDMI1.2 12.69,43.56 ; JHDMI1.2 13.61,43.56 ; JHDMI1.2 13.73,43.1 ; JHDMI1.2 13.61,42.64 ; 234.9,93.31 H16.1 ; H16.1 233.73,96.07 ; H16.1 236.49,94.9 ; H16.1 236.07,93.73 ; H16.1 233.31,94.9 ; H16.1 234.9,96.49 ; H16.1 233.73,93.73 ; H16.1 236.07,96.07 ; JHDMI1.21 5.13,55.85 ; JHDMI1.21 1.67,56.83 ; JHDMI1.21 1.67,55.85 ; JHDMI1.21 5.13,56.83 ; JHDMI1.21 3.4,56.83 ; 298.47,56.4 JSD1.12 ; JSD1.12 298.47,55.67 ; JSD1.12 299.6,54.95 ; JSD1.12 299.6,56.4 ; 165.06,80 H3.1 ; H3.1 169.1,81.7 ; H3.1 169.1,78.3 ; H3.1 165.7,78.3 ; H3.1 165.7,81.7 ; H3.1 167.4,77.66 ; H3.1 169.74,80 ; H3.1 167.4,82.34 ; JUSBC2.1 1.8,73.35 ; JUSBC2.1 3.27,73.35 ; JUSBC2.1 1.8,71.69 ; JUSBC2.1 3.27,72.52 ; JUSBC2.1 3.27,71.69 ; 6.25,63.1 JUSBC2.6 ; JUSBC2.6 6.97,65.11 ; JUSBC2.6 5.53,65.11 ; JUSBC2.6 6.25,65.11 ; JUSBC2.6 5.53,63.1 ; JUSBC2.6 6.97,63.1 ; 84.5,63.55 84.5,64.03 ; 242.11,47.82 JNGFF1.36 ; JNGFF1.36 242.11,46.98 ; JNGFF1.36 242.01,47.4 ; 85.44,63.56 85.44,64.04
  GND1 w0.254: v3(71.25,55.62) v4(71.25,56.3) ; JUSB2.4 12.69,21.6 ; 43.69,39.9 43.69,40.33 43.74,40.38
  GND1 w0.381: v3(147.05,74.51) 146.98,74.51 146.38,73.91 v2(146.38,73.79)
  GND1 w0.508: JNGFF1.18 243.32,51.91 243.32,52.56 ; 137.3,87.36 137.4,87.46 138.01,87.46
  IN1 w0.127: 47.46,77.15 v2(47.97,77.66) 48.43,78.11 48.43,79.02 48.09,79.36 46.51,79.36 46.21,79.05 46.21,77.49 46.55,77.15 47.46,77.15
  GND2 w0.127: JNGFF2.77 235.89,67.22 235.87,67.2 ; JNGFF2.77 237.13,68.15 237.48,67.8 ; JNGFF2.77 234.61,68.15 234.19,67.74 ; JNGFF1.76 245.13,58.15 244.68,58.59 ; JNGFF1.76 246.49,58.93 246.45,58.97 ; JNGFF1.76 247.76,58.15 247.93,58.33 ; JNGFF2.76 235.89,91.49 235.92,91.53 ; JNGFF2.76 237.76,90.65 237.79,90.67 ; JNGFF2.76 234.4,90.65 234.13,90.92 ; JNGFF1.77 246.49,34.84 246.56,34.77 ; JNGFF1.77 245.2,35.65 244.75,35.2 ; JNGFF1.77 247.85,35.65 248.06,35.44
  GND2 w0.203: 5.53,65.11 JUSBC2.6 ; JUSBC2.6 6.97,65.11 ; JUSBC2.6 5.53,63.1 ; JUSBC2.6 6.25,63.1 ; JUSBC2.6 6.25,65.11 ; JUSBC2.6 6.97,63.1 ; H26.1 285,5.59 ; H26.1 283.83,2.83 ; H26.1 283.83,5.17 ; H26.1 286.17,2.83 ; H26.1 286.59,4 ; H26.1 283.41,4 ; H26.1 286.17,5.17 ; H26.1 285,2.41 ; JHDMI1.20 5.13,38.35 ; JHDMI1.20 5.13,37.37 ; JHDMI1.20 1.67,38.35 ; JHDMI1.20 1.67,37.37 ; JHDMI1.20 3.4,37.37 ; 11.14,47.14 JHDMI1.11 ; JHDMI1.11 11.14,48.06 ; JHDMI1.11 11.02,47.6 ; JHDMI1.11 12.18,47.6 ; JHDMI1.11 12.06,47.14 ; JHDMI1.11 12.06,48.06 ; 5.52,63.1 JUSBC2.4 ; JUSBC2.4 8.18,63.88 ; JUSBC2.4 6.85,63.1 ; JUSBC2.4 8.18,63.1 ; JUSBC2.4 8.18,64.65 ; JUSBC2.4 5.52,63.88 ; 1.52,15.97 JUSB2.11 ; JUSB2.11 1.52,16.75 ; JUSB2.11 2.8,15.97 ; JUSB2.11 4.08,17.53 ; JUSB2.11 2.8,17.53 ; JUSB2.11 4.08,16.75 ; JUSB2.11 4.08,15.97 ; JHDMI1.22 13.08,38.87 ; JHDMI1.22 10.42,39.85 ; JHDMI1.22 10.42,38.87 ; JHDMI1.22 11.75,38.87 ; JHDMI1.22 10.42,40.83 ; JHDMI1.22 13.08,40.83 ; JHDMI1.22 11.75,40.83 ; JHDMI1.22 13.08,39.85 ; H16.1 236.07,96.07 ; H16.1 236.07,93.73 ; H16.1 233.73,93.73 ; H16.1 234.9,96.49 ; H16.1 236.49,94.9 ; H16.1 233.31,94.9 ; H16.1 234.9,93.31 ; H16.1 233.73,96.07 ; JUSBC1.4 8.18,77.6 ; JUSBC1.4 6.85,77.6 ; JUSBC1.4 8.18,78.38 ; JUSBC1.4 5.52,78.38 ; JUSBC1.4 5.52,77.6 ; JUSBC1.4 8.18,79.16 ; 52.86,92.79 H11.1 ; H11.1 55.78,91.55 ; H11.1 55.34,92.79 ; H11.1 52.42,91.55 ; H11.1 54.1,89.87 ; H11.1 55.34,90.31 ; H11.1 52.86,90.31 ; H11.1 54.1,93.23 ; JHDMI1.17 12.06,51.06 ; JHDMI1.17 12.06,50.14 ; JHDMI1.17 12.18,50.6 ; JHDMI1.17 11.14,51.06 ; JHDMI1.17 11.02,50.6 ; JHDMI1.17 11.14,50.14 ; PBATT1.11 46.12,39.7 ; PBATT1.11 46.12,37.7 ; PBATT1.11 46.82,39.7 ; PBATT1.11 45.43,38.7 ; PBATT1.11 45.43,37.7 ; PBATT1.11 46.82,38.7 ; JSD1.13 297.53,41.35 ; JSD1.13 295.27,42.8 ; JSD1.13 295.27,41.35 ; JSD1.13 297.53,42.07 ; JSD1.13 296.4,42.8 ; JSD1.13 296.4,41.35 ; JSD1.13 297.53,42.8 ; JSD1.13 295.27,42.07 ; H20.1 71.07,64.63 ; H20.1 69.9,64.21 ; H20.1 71.49,65.8 ; H20.1 71.07,66.97 ; H20.1 68.31,65.8 ; H20.1 69.9,67.39 ; H20.1 68.73,66.97 ; H20.1 68.73,64.63 ; JHDMI1.23 13.08,54.35 ; JHDMI1.23 13.08,53.37 ; JHDMI1.23 11.75,53.37 ; JHDMI1.23 10.42,55.33 ; JHDMI1.23 10.42,54.35 ; JHDMI1.23 11.75,55.33 ; JHDMI1.23 13.08,55.33 ; JHDMI1.23 10.42,53.37 ; JUSBC2.1 3.27,73.35 ; JUSBC2.1 3.27,72.52 ; JUSBC2.1 1.8,73.35 ; JUSBC2.1 3.27,71.69 ; JUSBC2.1 1.8,71.69 ; PBATT1.14 61.57,35.22 ; PBATT1.14 60.87,34.22 ; PBATT1.14 61.57,34.22 ; PBATT1.14 61.57,36.23 ; PBATT1.14 60.18,36.23 ; PBATT1.14 60.18,34.22 ; PBATT1.14 60.87,36.23 ; PBATT1.14 60.18,35.22 ; JUSB2.7 13.16,24.6 ; JUSB2.7 13,24.05 ; JUSB2.7 12.45,23.89 ; JUSB2.7 13,25.15 ; JUSB2.7 12.45,25.31 ; 12.69,42.64 JHDMI1.2 ; JHDMI1.2 12.57,43.1 ; JHDMI1.2 13.61,43.56 ; JHDMI1.2 13.61,42.64 ; JHDMI1.2 13.73,43.1 ; JHDMI1.2 12.69,43.56 ; JHDMI1.2 13.15,42.52 ; JHDMI1.5 12.06,45.06 ; JHDMI1.5 12.18,44.6 ; JHDMI1.5 12.06,44.14 ; JHDMI1.5 11.02,44.6 ; JHDMI1.5 11.14,45.06 ; JHDMI1.5 11.14,44.14 ; 298.2,76.08 JUSB1.11 ; JUSB1.11 299.48,77.63 ; JUSB1.11 296.92,77.63 ; JUSB1.11 296.92,76.85 ; JUSB1.11 299.48,76.08 ; JUSB1.11 296.92,76.08 ; JUSB1.11 298.2,77.63 ; JUSB1.11 299.48,76.85 ; H18.1 296,82.09 ; H18.1 294.83,79.33 ; H18.1 294.41,80.5 ; H18.1 297.17,81.67 ; H18.1 296,78.91 ; H18.1 294.83,81.67 ; H18.1 297.59,80.5 ; H18.1 297.17,79.33 ; JUSBC2.2 6.85,73.3 ; JUSBC2.2 5.52,73.3 ; JUSBC2.2 8.18,71.74 ; JUSBC2.2 8.18,72.52 ; JUSBC2.2 5.52,72.52 ; JUSBC2.2 8.18,73.3 ; JUSBC1.2 8.15,87.76 ; JUSBC1.2 8.15,87.02 ; JUSBC1.2 6.85,87.76 ; JUSBC1.2 5.55,87.02 ; JUSBC1.2 8.15,86.28 ; JUSBC1.2 5.55,87.76 ; JUSBC1.2 6.85,86.28 ; 285.67,41.35 JSD1.10 ; JSD1.10 285.67,42.8 ; JSD1.10 287.93,42.07 ; JSD1.10 286.8,42.8 ; JSD1.10 286.8,41.35 ; JSD1.10 287.93,42.8 ; JSD1.10 285.67,42.07 ; JSD1.10 287.93,41.35 ; 165.7,81.7 H3.1 ; H3.1 169.1,78.3 ; H3.1 167.4,77.66 ; H3.1 165.7,78.3 ; H3.1 169.74,80 ; H3.1 169.1,81.7 ; H3.1 167.4,82.34 ; H3.1 165.06,80 ; 242.01,47.4 JNGFF1.36 ; JNGFF1.36 242.11,46.98 ; JNGFF1.36 242.11,47.82 ; 296.92,60.38 JUSB1.12 ; JUSB1.12 299.48,61.93 ; JUSB1.12 299.48,60.38 ; JUSB1.12 298.2,60.38 ; JUSB1.12 296.92,61.15 ; JUSB1.12 298.2,61.93 ; JUSB1.12 296.92,61.93 ; JUSB1.12 299.48,61.15 ; JUSB1.13 295.53,60.38 ; JUSB1.13 292.97,60.38 ; JUSB1.13 294.25,60.38 ; JUSB1.13 292.97,61.15 ; JUSB1.13 295.53,61.93 ; JUSB1.13 294.25,61.93 ; JUSB1.13 295.53,61.15 ; 242.01,50.4 JNGFF1.24 ; JNGFF1.24 242.11,50.82 ; JNGFF1.24 242.11,49.98 ; 1.8,63.05 JUSBC2.3 ; JUSBC2.3 3.27,63.05 ; JUSBC2.3 3.27,64.71 ; JUSBC2.3 1.8,64.71 ; JUSBC2.3 3.27,63.88 ; JUSBC1.1 3.27,87.02 ; JUSBC1.1 3.27,87.85 ; JUSBC1.1 3.27,86.19 ; JUSBC1.1 1.8,86.19 ; JUSBC1.1 1.8,87.85 ; 5.47,33.23 JUSB2.13 ; JUSB2.13 6.75,31.67 ; JUSB2.13 5.47,31.67 ; JUSB2.13 8.03,33.23 ; JUSB2.13 5.47,32.45 ; JUSB2.13 6.75,33.23 ; JUSB2.13 8.03,32.45 ; H2.1 109.94,57.86 ; H2.1 105.9,56.16 ; H2.1 105.26,57.86 ; H2.1 107.6,55.52 ; H2.1 107.6,60.2 ; H2.1 105.9,59.56 ; H2.1 109.3,59.56 ; H2.1 109.3,56.16 ; H4.1 169.1,56.2 ; H4.1 169.74,57.9 ; H4.1 165.7,59.6 ; H4.1 167.4,60.24 ; H4.1 169.1,59.6 ; H4.1 165.06,57.9 ; H4.1 167.4,55.56 ; H4.1 165.7,56.2 ; H34.1 177.5,89.03 ; H34.1 175.47,87 ; H34.1 178.99,88.49 ; H34.1 176.01,85.51 ; H34.1 179.53,87 ; H34.1 176.01,88.49 ; H34.1 177.5,84.97 ; H34.1 178.99,85.51 ; JUSB1.10 295.53,77.63 ; JUSB1.10 295.53,76.08 ; JUSB1.10 295.53,76.85 ; JUSB1.10 294.25,77.63 ; JUSB1.10 292.97,76.85 ; JUSB1.10 294.25,76.08 ; JUSB1.10 292.97,77.63 ; 1.8,77.55 JUSBC1.3 ; JUSBC1.3 1.8,79.21 ; JUSBC1.3 3.27,79.21 ; JUSBC1.3 3.27,77.55 ; JUSBC1.3 3.27,78.38 ; 285.67,54.95 JSD1.11 ; JSD1.11 287.93,56.4 ; JSD1.11 286.8,54.95 ; JSD1.11 287.93,54.95 ; JSD1.11 287.93,55.67 ; JSD1.11 285.67,55.67 ; JSD1.11 286.8,56.4 ; H1.1 109.3,81.7 ; H1.1 109.3,78.3 ; H1.1 105.9,81.7 ; H1.1 105.9,78.3 ; H1.1 107.6,82.34 ; H1.1 105.26,80 ; H1.1 107.6,77.66 ; H1.1 109.94,80 ; 5.47,16.75 JUSB2.10 ; JUSB2.10 5.47,15.97 ; JUSB2.10 8.03,16.75 ; JUSB2.10 6.75,15.97 ; JUSB2.10 6.75,17.53 ; JUSB2.10 8.03,15.97 ; JUSB2.10 5.47,17.53 ; JHDMI1.21 3.4,56.83 ; JHDMI1.21 5.13,55.85 ; JHDMI1.21 1.67,55.85 ; JHDMI1.21 5.13,56.83 ; JHDMI1.21 1.67,56.83 ; JUSBC1.5 6.94,87.76 ; JUSBC1.5 6.25,87.76 ; JUSBC1.5 5.56,85.83 ; JUSBC1.5 6.94,85.83 ; JUSBC1.5 5.56,87.76 ; JUSBC1.5 6.25,85.83 ; JUSBC1.5 5.56,86.7 ; H24.1 7,7.23 ; H24.1 4.67,1.67 ; H24.1 4.67,6.33 ; H24.1 7,0.77 ; H24.1 3.77,4 ; H24.1 9.33,1.67 ; H24.1 10.23,4 ; H24.1 9.33,6.33 ; PBATT1.13 61.57,38.7 ; PBATT1.13 60.87,37.7 ; PBATT1.13 60.18,38.7 ; PBATT1.13 60.18,37.7 ; PBATT1.13 60.18,39.7 ; PBATT1.13 61.57,37.7 ; PBATT1.13 60.87,39.7 ; PBATT1.13 61.57,39.7 ; 287.84,69 JUSB1.7 ; JUSB1.7 288.55,68.29 ; JUSB1.7 288.55,69.71 ; JUSB1.7 288,68.45 ; JUSB1.7 288,69.55 ; 133.19,93.69 H13.1 ; H13.1 135.67,91.21 ; H13.1 136.11,92.45 ; H13.1 133.19,91.21 ; H13.1 132.75,92.45 ; H13.1 134.43,94.13 ; H13.1 135.67,93.69 ; H13.1 134.43,90.77 ; 5.53,71.29 JUSBC2.5 ; JUSBC2.5 5.53,72.19 ; JUSBC2.5 6.25,71.29 ; JUSBC2.5 6.25,73.3 ; JUSBC2.5 6.97,73.3 ; JUSBC2.5 6.97,71.29 ; JUSBC2.5 5.53,73.3 ; 1.52,33.23 JUSB2.12 ; JUSB2.12 2.8,31.67 ; JUSB2.12 1.52,32.45 ; JUSB2.12 4.08,31.67 ; JUSB2.12 2.8,33.23 ; JUSB2.12 4.08,33.23 ; JUSB2.12 4.08,32.45 ; PBATT1.12 46.12,36.23 ; PBATT1.12 45.43,35.22 ; PBATT1.12 45.43,36.23 ; PBATT1.12 46.82,35.22 ; PBATT1.12 45.43,34.22 ; PBATT1.12 46.82,34.22 ; PBATT1.12 46.12,34.22 ; PBATT1.12 46.82,36.23 ; H14.1 151.67,94.37 ; H14.1 148.91,93.2 ; H14.1 150.5,94.79 ; H14.1 149.33,94.37 ; H14.1 152.09,93.2 ; H14.1 150.5,91.61 ; H14.1 149.33,92.03 ; H14.1 151.67,92.03 ; H9.1 6.67,92.22 ; H9.1 5.5,92.64 ; H9.1 4.33,92.22 ; H9.1 5.5,89.46 ; H9.1 3.91,91.05 ; H9.1 7.09,91.05 ; H9.1 4.33,89.88 ; H9.1 6.67,89.88 ; 89.33,92.03 H12.1 ; H12.1 90.5,91.61 ; H12.1 88.91,93.2 ; H12.1 89.33,94.37 ; H12.1 91.67,94.37 ; H12.1 92.09,93.2 ; H12.1 91.67,92.03 ; H12.1 90.5,94.79 ; 298.47,55.67 JSD1.12 ; JSD1.12 298.47,56.4 ; JSD1.12 299.6,56.4 ; JSD1.12 299.6,54.95 ; 12.69,46.56 JHDMI1.8 ; JHDMI1.8 13.61,46.56 ; JHDMI1.8 12.57,46.1 ; JHDMI1.8 13.73,46.1 ; JHDMI1.8 13.61,45.64 ; JHDMI1.8 12.69,45.64 ; H19.1 6.67,61.02 ; H19.1 4.33,61.02 ; H19.1 6.67,58.68 ; H19.1 5.5,58.26 ; H19.1 5.5,61.44 ; H19.1 4.33,58.68 ; H19.1 3.91,59.85 ; H19.1 7.09,59.85 ; H27.1 296.33,1.67 ; H27.1 294,0.77 ; H27.1 297.23,4 ; H27.1 290.77,4 ; H27.1 294,7.23 ; H27.1 291.67,1.67 ; H27.1 296.33,6.33 ; H27.1 291.67,6.33 ; 5.53,77.6 JUSBC1.6 ; JUSBC1.6 6.25,77.6 ; JUSBC1.6 6.97,79.61 ; JUSBC1.6 6.25,79.61 ; JUSBC1.6 5.53,79.61 ; JUSBC1.6 6.97,77.6
  GND2 w0.254: JUSB2.4 12.82,21.6
  GND2 w0.508: 243.33,52.62 JNGFF1.18
  IN2 w0.127: 48.37,79.09 48.37,78.05 v2(47.97,77.66) 47.49,77.17 46.52,77.17 46.25,77.45 46.25,79.08 46.51,79.35 48.11,79.35 48.37,79.09
  GND3 w0.127: 246.42,34.84 246.49,34.91 JNGFF1.77 ; 235.86,67.17 235.89,67.2 JNGFF2.77 ; 244.95,35.24 245.36,35.65 JNGFF1.77 ; JNGFF1.77 247.69,35.65 247.97,35.37 ; JNGFF2.77 234.53,68.15 234.28,67.9 ; JNGFF2.77 237.06,68.15 237.25,67.95 ; 237.46,90.79 237.32,90.65 JNGFF2.76 ; JNGFF2.76 234.34,90.65 234.07,90.93 ; JNGFF2.76 235.89,91.42 235.97,91.5 ; 246.61,58.99 246.49,58.86 JNGFF1.76 ; JNGFF1.76 245.19,58.15 244.85,58.49 ; JNGFF1.76 247.85,58.15 248.09,58.39
  GND3 w0.203: H24.1 7,7.23 ; H24.1 9.33,1.67 ; H24.1 4.67,1.67 ; H24.1 4.67,6.33 ; H24.1 3.77,4 ; H24.1 9.33,6.33 ; H24.1 7,0.77 ; H24.1 10.23,4 ; 12.69,42.64 JHDMI1.2 ; JHDMI1.2 13.61,42.64 ; JHDMI1.2 13.73,43.1 ; JHDMI1.2 12.57,43.1 ; JHDMI1.2 12.69,43.56 ; JHDMI1.2 13.15,42.52 ; JHDMI1.2 13.61,43.56 ; JUSBC1.2 8.15,87.76 ; JUSBC1.2 6.85,86.28 ; JUSBC1.2 6.85,87.76 ; JUSBC1.2 5.55,87.76 ; JUSBC1.2 5.55,87.02 ; JUSBC1.2 8.15,87.02 ; JUSBC1.2 8.15,86.28 ; 11.75,53.37 JHDMI1.23 ; JHDMI1.23 13.08,53.37 ; JHDMI1.23 11.75,55.33 ; JHDMI1.23 10.42,53.37 ; JHDMI1.23 10.42,55.33 ; JHDMI1.23 10.42,54.35 ; JHDMI1.23 13.08,55.33 ; JHDMI1.23 13.08,54.35 ; H4.1 167.4,60.24 ; H4.1 165.7,59.6 ; H4.1 169.1,59.6 ; H4.1 167.4,55.56 ; H4.1 165.7,56.2 ; H4.1 165.06,57.9 ; H4.1 169.74,57.9 ; H4.1 169.1,56.2 ; H27.1 294,7.23 ; H27.1 294,0.77 ; H27.1 296.33,1.67 ; H27.1 297.23,4 ; H27.1 296.33,6.33 ; H27.1 291.67,1.67 ; H27.1 290.77,4 ; H27.1 291.67,6.33 ; PBATT1.12 46.82,36.23 ; PBATT1.12 46.12,36.23 ; PBATT1.12 45.43,34.22 ; PBATT1.12 45.43,35.22 ; PBATT1.12 46.12,34.22 ; PBATT1.12 46.82,34.22 ; PBATT1.12 45.43,36.23 ; PBATT1.12 46.82,35.22 ; JUSB2.7 13.16,24.6 ; JUSB2.7 13,24.05 ; JUSB2.7 13,25.15 ; JUSB2.7 12.45,23.89 ; JUSB2.7 12.45,25.31 ; JSD1.11 287.93,56.4 ; JSD1.11 287.93,55.67 ; JSD1.11 286.8,54.95 ; JSD1.11 286.8,56.4 ; JSD1.11 287.93,54.95 ; JSD1.11 285.67,54.95 ; JSD1.11 285.67,55.67 ; H18.1 297.59,80.5 ; H18.1 296,82.09 ; H18.1 297.17,79.33 ; H18.1 294.83,79.33 ; H18.1 296,78.91 ; H18.1 294.83,81.67 ; H18.1 294.41,80.5 ; H18.1 297.17,81.67 ; 11.02,47.6 JHDMI1.11 ; JHDMI1.11 12.18,47.6 ; JHDMI1.11 12.06,47.14 ; JHDMI1.11 12.06,48.06 ; JHDMI1.11 11.14,48.06 ; JHDMI1.11 11.14,47.14 ; JUSB1.10 295.53,76.08 ; JUSB1.10 295.53,77.63 ; JUSB1.10 294.25,76.08 ; JUSB1.10 292.97,77.63 ; JUSB1.10 295.53,76.85 ; JUSB1.10 294.25,77.63 ; JUSB1.10 292.97,76.85 ; JHDMI1.20 5.13,37.37 ; JHDMI1.20 5.13,38.35 ; JHDMI1.20 1.67,37.37 ; JHDMI1.20 1.67,38.35 ; JHDMI1.20 3.4,37.37 ; 12.57,46.1 JHDMI1.8 ; JHDMI1.8 12.69,46.56 ; JHDMI1.8 13.61,45.64 ; JHDMI1.8 13.61,46.56 ; JHDMI1.8 13.73,46.1 ; JHDMI1.8 12.69,45.64 ; H16.1 236.49,94.9 ; H16.1 233.73,96.07 ; H16.1 234.9,93.31 ; H16.1 236.07,93.73 ; H16.1 236.07,96.07 ; H16.1 234.9,96.49 ; H16.1 233.73,93.73 ; H16.1 233.31,94.9 ; 1.52,32.45 JUSB2.12 ; JUSB2.12 4.08,32.45 ; JUSB2.12 1.52,33.23 ; JUSB2.12 2.8,31.67 ; JUSB2.12 2.8,33.23 ; JUSB2.12 4.08,31.67 ; JUSB2.12 4.08,33.23 ; PBATT1.13 61.57,38.7 ; PBATT1.13 60.18,38.7 ; PBATT1.13 60.87,39.7 ; PBATT1.13 61.57,39.7 ; PBATT1.13 60.18,37.7 ; PBATT1.13 60.18,39.7 ; PBATT1.13 60.87,37.7 ; PBATT1.13 61.57,37.7 ; 6.25,77.6 JUSBC1.6 ; JUSBC1.6 6.97,79.61 ; JUSBC1.6 6.97,77.6 ; JUSBC1.6 5.53,79.61 ; JUSBC1.6 5.53,77.6 ; JUSBC1.6 6.25,79.61 ; JUSB2.13 8.03,33.23 ; JUSB2.13 5.47,31.67 ; JUSB2.13 5.47,33.23 ; JUSB2.13 6.75,31.67 ; JUSB2.13 6.75,33.23 ; JUSB2.13 8.03,32.45 ; JUSB2.13 5.47,32.45 ; 242.01,47.4 JNGFF1.36 ; JNGFF1.36 242.11,47.82 ; JNGFF1.36 242.11,46.98 ; 45.43,37.7 PBATT1.11 ; PBATT1.11 46.82,38.7 ; PBATT1.11 45.43,38.7 ; PBATT1.11 46.82,39.7 ; PBATT1.11 46.12,37.7 ; PBATT1.11 46.12,39.7 ; 285,2.41 H26.1 ; H26.1 285,5.59 ; H26.1 283.83,2.83 ; H26.1 283.83,5.17 ; H26.1 286.17,5.17 ; H26.1 286.17,2.83 ; H26.1 286.59,4 ; H26.1 283.41,4 ; JSD1.10 286.8,42.8 ; JSD1.10 285.67,42.07 ; JSD1.10 286.8,41.35 ; JSD1.10 287.93,42.8 ; JSD1.10 285.67,42.8 ; JSD1.10 287.93,41.35 ; JSD1.10 285.67,41.35 ; JSD1.10 287.93,42.07 ; 68.31,65.8 H20.1 ; H20.1 71.49,65.8 ; H20.1 71.07,66.97 ; H20.1 68.73,66.97 ; H20.1 69.9,67.39 ; H20.1 71.07,64.63 ; H20.1 68.73,64.63 ; H20.1 69.9,64.21 ; JUSBC1.5 6.94,85.83 ; JUSBC1.5 6.25,87.76 ; JUSBC1.5 5.56,86.7 ; JUSBC1.5 5.56,85.83 ; JUSBC1.5 5.56,87.76 ; JUSBC1.5 6.25,85.83 ; JUSBC1.5 6.94,87.76 ; JUSB1.11 299.48,77.63 ; JUSB1.11 299.48,76.85 ; JUSB1.11 298.2,77.63 ; JUSB1.11 296.92,76.85 ; JUSB1.11 296.92,76.08 ; JUSB1.11 299.48,76.08 ; JUSB1.11 296.92,77.63 ; JUSB1.11 298.2,76.08 ; 5.5,58.26 H19.1 ; H19.1 4.33,61.02 ; H19.1 6.67,61.02 ; H19.1 4.33,58.68 ; H19.1 6.67,58.68 ; H19.1 3.91,59.85 ; H19.1 7.09,59.85 ; H19.1 5.5,61.44 ; JUSBC2.4 8.18,63.1 ; JUSBC2.4 8.18,63.88 ; JUSBC2.4 5.52,63.1 ; JUSBC2.4 8.18,64.65 ; JUSBC2.4 5.52,63.88 ; JUSBC2.4 6.85,63.1 ; 5.5,89.46 H9.1 ; H9.1 7.09,91.05 ; H9.1 5.5,92.64 ; H9.1 3.91,91.05 ; H9.1 6.67,89.88 ; H9.1 4.33,92.22 ; H9.1 6.67,92.22 ; H9.1 4.33,89.88 ; 6.25,63.1 JUSBC2.6 ; JUSBC2.6 6.97,63.1 ; JUSBC2.6 5.53,63.1 ; JUSBC2.6 6.97,65.11 ; JUSBC2.6 6.25,65.11 ; JUSBC2.6 5.53,65.11 ; 11.02,44.6 JHDMI1.5 ; JHDMI1.5 11.14,45.06 ; JHDMI1.5 12.06,44.14 ; JHDMI1.5 12.06,45.06 ; JHDMI1.5 12.18,44.6 ; JHDMI1.5 11.14,44.14 ; 1.67,56.83 JHDMI1.21 ; JHDMI1.21 5.13,55.85 ; JHDMI1.21 5.13,56.83 ; JHDMI1.21 3.4,56.83 ; JHDMI1.21 1.67,55.85 ; 165.7,81.7 H3.1 ; H3.1 169.1,81.7 ; H3.1 167.4,82.34 ; H3.1 167.4,77.66 ; H3.1 165.7,78.3 ; H3.1 169.74,80 ; H3.1 169.1,78.3 ; H3.1 165.06,80 ; JUSBC2.1 3.27,73.35 ; JUSBC2.1 3.27,72.52 ; JUSBC2.1 1.8,71.69 ; JUSBC2.1 1.8,73.35 ; JUSBC2.1 3.27,71.69 ; PBATT1.14 61.57,35.22 ; PBATT1.14 61.57,36.23 ; PBATT1.14 60.18,34.22 ; PBATT1.14 60.87,36.23 ; PBATT1.14 61.57,34.22 ; PBATT1.14 60.87,34.22 ; PBATT1.14 60.18,35.22 ; PBATT1.14 60.18,36.23 ; 287.84,69 JUSB1.7 ; JUSB1.7 288,68.45 ; JUSB1.7 288.55,68.29 ; JUSB1.7 288.55,69.71 ; JUSB1.7 288,69.55 ; 149.33,92.03 H14.1 ; H14.1 152.09,93.2 ; H14.1 148.91,93.2 ; H14.1 149.33,94.37 ; H14.1 151.67,94.37 ; H14.1 151.67,92.03 ; H14.1 150.5,94.79 ; H14.1 150.5,91.61 ; JUSBC1.3 1.8,79.21 ; JUSBC1.3 3.27,79.21 ; JUSBC1.3 1.8,77.55 ; JUSBC1.3 3.27,77.55 ; JUSBC1.3 3.27,78.38 ; H12.1 90.5,94.79 ; H12.1 91.67,94.37 ; H12.1 90.5,91.61 ; H12.1 91.67,92.03 ; H12.1 89.33,92.03 ; H12.1 92.09,93.2 ; H12.1 89.33,94.37 ; H12.1 88.91,93.2 ; 5.53,71.29 JUSBC2.5 ; JUSBC2.5 6.25,71.29 ; JUSBC2.5 5.53,73.3 ; JUSBC2.5 6.97,73.3 ; JUSBC2.5 6.97,71.29 ; JUSBC2.5 6.25,73.3 ; JUSBC2.5 5.53,72.19 ; 1.8,63.05 JUSBC2.3 ; JUSBC2.3 1.8,64.71 ; JUSBC2.3 3.27,63.05 ; JUSBC2.3 3.27,63.88 ; JUSBC2.3 3.27,64.71 ; JSD1.13 297.53,42.8 ; JSD1.13 297.53,41.35 ; JSD1.13 296.4,42.8 ; JSD1.13 295.27,42.8 ; JSD1.13 295.27,41.35 ; JSD1.13 296.4,41.35 ; JSD1.13 295.27,42.07 ; JSD1.13 297.53,42.07 ; 296.92,61.15 JUSB1.12 ; JUSB1.12 296.92,60.38 ; JUSB1.12 298.2,60.38 ; JUSB1.12 299.48,61.15 ; JUSB1.12 299.48,61.93 ; JUSB1.12 298.2,61.93 ; JUSB1.12 296.92,61.93 ; JUSB1.12 299.48,60.38 ; JUSBC1.1 3.27,87.02 ; JUSBC1.1 1.8,87.85 ; JUSBC1.1 3.27,87.85 ; JUSBC1.1 1.8,86.19 ; JUSBC1.1 3.27,86.19 ; JUSBC2.2 8.18,72.52 ; JUSBC2.2 8.18,71.74 ; JUSBC2.2 6.85,73.3 ; JUSBC2.2 8.18,73.3 ; JUSBC2.2 5.52,73.3 ; JUSBC2.2 5.52,72.52 ; JHDMI1.17 12.06,50.14 ; JHDMI1.17 12.06,51.06 ; JHDMI1.17 11.14,50.14 ; JHDMI1.17 11.14,51.06 ; JHDMI1.17 12.18,50.6 ; JHDMI1.17 11.02,50.6 ; H11.1 54.1,93.23 ; H11.1 55.34,90.31 ; H11.1 55.34,92.79 ; H11.1 55.78,91.55 ; H11.1 52.42,91.55 ; H11.1 52.86,92.79 ; H11.1 54.1,89.87 ; H11.1 52.86,90.31 ; H13.1 135.67,93.69 ; H13.1 134.43,90.77 ; H13.1 132.75,92.45 ; H13.1 135.67,91.21 ; H13.1 134.43,94.13 ; H13.1 136.11,92.45 ; H13.1 133.19,91.21 ; H13.1 133.19,93.69 ; 292.97,61.15 JUSB1.13 ; JUSB1.13 295.53,60.38 ; JUSB1.13 294.25,61.93 ; JUSB1.13 292.97,60.38 ; JUSB1.13 295.53,61.93 ; JUSB1.13 294.25,60.38 ; JUSB1.13 295.53,61.15 ; 299.6,54.95 JSD1.12 ; JSD1.12 298.47,55.67 ; JSD1.12 298.47,56.4 ; JSD1.12 299.6,56.4 ; 242.11,50.82 JNGFF1.24 ; JNGFF1.24 242.01,50.4 ; JNGFF1.24 242.11,49.98 ; H2.1 109.3,56.16 ; H2.1 105.9,59.56 ; H2.1 105.9,56.16 ; H2.1 107.6,55.52 ; H2.1 109.3,59.56 ; H2.1 105.26,57.86 ; H2.1 109.94,57.86 ; H2.1 107.6,60.2 ; JHDMI1.22 11.75,40.83 ; JHDMI1.22 10.42,40.83 ; JHDMI1.22 13.08,38.87 ; JHDMI1.22 13.08,39.85 ; JHDMI1.22 13.08,40.83 ; JHDMI1.22 10.42,39.85 ; JHDMI1.22 10.42,38.87 ; JHDMI1.22 11.75,38.87 ; JUSB2.10 8.03,15.97 ; JUSB2.10 5.47,16.75 ; JUSB2.10 6.75,17.53 ; JUSB2.10 5.47,17.53 ; JUSB2.10 5.47,15.97 ; JUSB2.10 6.75,15.97 ; JUSB2.10 8.03,16.75 ; H34.1 178.99,85.51 ; H34.1 177.5,89.03 ; H34.1 179.53,87 ; H34.1 176.01,85.51 ; H34.1 175.47,87 ; H34.1 176.01,88.49 ; H34.1 178.99,88.49 ; H34.1 177.5,84.97 ; 1.52,15.97 JUSB2.11 ; JUSB2.11 4.08,17.53 ; JUSB2.11 2.8,17.53 ; JUSB2.11 1.52,16.75 ; JUSB2.11 4.08,15.97 ; JUSB2.11 2.8,15.97 ; JUSB2.11 4.08,16.75 ; 5.52,78.38 JUSBC1.4 ; JUSBC1.4 8.18,79.16 ; JUSBC1.4 8.18,78.38 ; JUSBC1.4 8.18,77.6 ; JUSBC1.4 6.85,77.6 ; JUSBC1.4 5.52,77.6
  VCC w0.203: H27.1 296.33,1.67 ; H27.1 297.23,4 ; H27.1 290.77,4 ; H27.1 296.33,6.33 ; H27.1 291.67,6.33 ; H27.1 291.67,1.67 ; H27.1 294,7.23 ; H27.1 294,0.77 ; JHDMI1.22 13.08,38.87 ; JHDMI1.22 10.42,38.87 ; JHDMI1.22 10.42,40.83 ; JHDMI1.22 10.42,39.85 ; JHDMI1.22 13.08,40.83 ; JHDMI1.22 13.08,39.85 ; JHDMI1.22 11.75,38.87 ; JHDMI1.22 11.75,40.83 ; 296.92,61.15 JUSB1.12 ; JUSB1.12 299.48,61.15 ; JUSB1.12 296.92,60.38 ; JUSB1.12 298.2,61.93 ; JUSB1.12 299.48,60.38 ; JUSB1.12 296.92,61.93 ; JUSB1.12 298.2,60.38 ; JUSB1.12 299.48,61.93 ; 294.25,60.38 JUSB1.13 ; JUSB1.13 295.53,60.38 ; JUSB1.13 295.53,61.93 ; JUSB1.13 295.53,61.15 ; JUSB1.13 292.97,61.15 ; JUSB1.13 294.25,61.93 ; JUSB1.13 292.97,60.38 ; 5.47,33.23 JUSB2.13 ; JUSB2.13 5.47,32.45 ; JUSB2.13 8.03,33.23 ; JUSB2.13 6.75,31.67 ; JUSB2.13 5.47,31.67 ; JUSB2.13 6.75,33.23 ; JUSB2.13 8.03,32.45 ; 292.97,77.63 JUSB1.10 ; JUSB1.10 294.25,77.63 ; JUSB1.10 295.53,76.85 ; JUSB1.10 295.53,76.08 ; JUSB1.10 292.97,76.85 ; JUSB1.10 294.25,76.08 ; JUSB1.10 295.53,77.63 ; 296.92,76.85 JUSB1.11 ; JUSB1.11 298.2,76.08 ; JUSB1.11 296.92,77.63 ; JUSB1.11 298.2,77.63 ; JUSB1.11 299.48,76.08 ; JUSB1.11 299.48,76.85 ; JUSB1.11 296.92,76.08 ; JUSB1.11 299.48,77.63 ; 234.9,93.31 H16.1 ; H16.1 236.07,93.73 ; H16.1 236.49,94.9 ; H16.1 233.73,93.73 ; H16.1 233.31,94.9 ; H16.1 234.9,96.49 ; H16.1 236.07,96.07 ; H16.1 233.73,96.07 ; JHDMI1.11 12.06,47.14 ; JHDMI1.11 11.14,48.06 ; JHDMI1.11 12.18,47.6 ; JHDMI1.11 11.14,47.14 ; JHDMI1.11 12.06,48.06 ; JHDMI1.11 11.02,47.6 ; JHDMI1.20 5.13,37.37 ; JHDMI1.20 1.67,37.37 ; JHDMI1.20 3.4,37.37 ; JHDMI1.20 5.13,38.35 ; JHDMI1.20 1.67,38.35 ; H18.1 297.17,81.67 ; H18.1 297.59,80.5 ; H18.1 296,78.91 ; H18.1 294.41,80.5 ; H18.1 296,82.09 ; H18.1 297.17,79.33 ; H18.1 294.83,81.67 ; H18.1 294.83,79.33 ; JUSB2.11 4.08,15.97 ; JUSB2.11 1.52,16.75 ; JUSB2.11 4.08,17.53 ; JUSB2.11 4.08,16.75 ; JUSB2.11 2.8,15.97 ; JUSB2.11 2.8,17.53 ; JUSB2.11 1.52,15.97 ; JHDMI1.5 12.06,45.06 ; JHDMI1.5 11.14,44.14 ; JHDMI1.5 12.18,44.6 ; JHDMI1.5 11.14,45.06 ; JHDMI1.5 11.02,44.6 ; JHDMI1.5 12.06,44.14 ; H26.1 286.17,5.17 ; H26.1 285,2.41 ; H26.1 285,5.59 ; H26.1 286.59,4 ; H26.1 283.83,5.17 ; H26.1 283.83,2.83 ; H26.1 286.17,2.83 ; H26.1 283.41,4 ; H24.1 7,7.23 ; H24.1 3.77,4 ; H24.1 10.23,4 ; H24.1 9.33,1.67 ; H24.1 4.67,6.33 ; H24.1 9.33,6.33 ; H24.1 7,0.77 ; H24.1 4.67,1.67 ; JUSB2.7 12.45,25.31 ; JUSB2.7 13,25.15 ; JUSB2.7 12.45,23.89 ; JUSB2.7 13.16,24.6 ; JUSB2.7 13,24.05 ; 6.75,15.97 JUSB2.10 ; JUSB2.10 8.03,16.75 ; JUSB2.10 5.47,15.97 ; JUSB2.10 5.47,16.75 ; JUSB2.10 8.03,15.97 ; JUSB2.10 5.47,17.53 ; JUSB2.10 6.75,17.53 ; 12.57,46.1 JHDMI1.8 ; JHDMI1.8 12.69,45.64 ; JHDMI1.8 12.69,46.56 ; 1.52,33.23 JUSB2.12 ; JUSB2.12 4.08,31.67 ; JUSB2.12 2.8,33.23 ; JUSB2.12 4.08,32.45 ; JUSB2.12 1.52,32.45 ; JUSB2.12 2.8,31.67 ; JUSB2.12 4.08,33.23 ; 10.42,53.37 JHDMI1.23 ; JHDMI1.23 11.75,53.37 ; JHDMI1.23 13.08,53.37 ; JHDMI1.23 13.08,54.35 ; JHDMI1.23 10.42,54.35 ; 11.14,50.14 JHDMI1.17 ; JHDMI1.17 11.02,50.6 ; JHDMI1.17 12.06,50.14 ; JHDMI1.17 12.18,50.6 ; JHDMI1.17 11.14,51.06 ; JHDMI1.17 12.06,51.06 ; 12.69,42.64 JHDMI1.2 ; JHDMI1.2 13.15,42.52 ; JHDMI1.2 12.69,43.56 ; JHDMI1.2 12.57,43.1 ; 287.84,69 JUSB1.7 ; JUSB1.7 288,68.45 ; JUSB1.7 288.55,69.71 ; JUSB1.7 288.55,68.29 ; JUSB1.7 288,69.55
  GND4 w0.127: JNGFF1.76 244.94,58.15 244.56,58.53 ; JNGFF1.76 248.06,58.15 248.12,58.21 ; JNGFF1.76 246.49,58.89 246.64,59.04 ; 246.47,34.82 246.49,34.84 JNGFF1.77 ; 237.37,90.78 237.24,90.65 JNGFF2.76 ; JNGFF2.76 234.66,90.65 234.33,90.98 ; JNGFF2.76 235.89,91.42 235.96,91.49 ; JNGFF2.77 235.89,67.22 235.93,67.18 ; JNGFF2.77 234.43,68.15 233.99,67.71 ; JNGFF2.77 237.15,68.15 237.48,67.81 ; 247.97,35.45 247.78,35.65 JNGFF1.77 ; JNGFF1.77 245.26,35.65 245,35.39
  GND4 w0.203: 292.97,77.63 JUSB1.10 ; JUSB1.10 294.25,77.63 ; JUSB1.10 295.53,77.63 ; JUSB1.10 295.53,76.85 ; JUSB1.10 295.53,76.08 ; JUSB1.10 292.97,76.85 ; JUSB1.10 294.25,76.08 ; JUSB1.11 299.48,76.85 ; JUSB1.11 298.2,76.08 ; JUSB1.11 299.48,76.08 ; JUSB1.11 299.48,77.63 ; JUSB1.11 296.92,76.08 ; JUSB1.11 298.2,77.63 ; JUSB1.11 296.92,76.85 ; JUSB1.11 296.92,77.63 ; H18.1 297.17,81.67 ; H18.1 294.41,80.5 ; H18.1 296,78.91 ; H18.1 294.83,81.67 ; H18.1 296,82.09 ; H18.1 297.59,80.5 ; H18.1 294.83,79.33 ; H18.1 297.17,79.33 ; JUSB2.7 13,25.15 ; JUSB2.7 12.45,25.31 ; JUSB2.7 13.16,24.6 ; JUSB2.7 13,24.05 ; JUSB2.7 12.45,23.89 ; 1.8,86.19 JUSBC1.1 ; JUSBC1.1 3.27,87.02 ; JUSBC1.1 3.27,86.19 ; JUSBC1.1 3.27,87.85 ; JUSBC1.1 1.8,87.85 ; JUSBC2.3 1.8,64.71 ; JUSBC2.3 3.27,63.88 ; JUSBC2.3 3.27,63.05 ; JUSBC2.3 1.8,63.05 ; JUSBC2.3 3.27,64.71 ; 7,0.77 H24.1 ; H24.1 9.33,1.67 ; H24.1 3.77,4 ; H24.1 4.67,6.33 ; H24.1 9.33,6.33 ; H24.1 10.23,4 ; H24.1 4.67,1.67 ; H24.1 7,7.23 ; JUSBC1.3 3.27,78.38 ; JUSBC1.3 3.27,77.55 ; JUSBC1.3 1.8,79.21 ; JUSBC1.3 3.27,79.21 ; JUSBC1.3 1.8,77.55 ; 5.52,73.3 JUSBC2.2 ; JUSBC2.2 8.18,73.3 ; JUSBC2.2 5.52,72.52 ; JUSBC2.2 8.18,72.52 ; JUSBC2.2 6.85,73.3 ; JUSBC2.2 8.18,71.74 ; H4.1 169.1,56.2 ; H4.1 169.1,59.6 ; H4.1 169.74,57.9 ; H4.1 165.7,59.6 ; H4.1 165.06,57.9 ; H4.1 165.7,56.2 ; H4.1 167.4,60.24 ; H4.1 167.4,55.56 ; 5.53,65.11 JUSBC2.6 ; JUSBC2.6 6.25,65.11 ; JUSBC2.6 6.97,63.1 ; JUSBC2.6 6.97,65.11 ; JUSBC2.6 5.53,63.1 ; JUSBC2.6 6.25,63.1 ; 10.42,38.87 JHDMI1.22 ; JHDMI1.22 10.42,40.83 ; JHDMI1.22 13.08,40.83 ; JHDMI1.22 13.08,38.87 ; JHDMI1.22 10.42,39.85 ; JHDMI1.22 13.08,39.85 ; JHDMI1.22 11.75,38.87 ; JHDMI1.22 11.75,40.83 ; 242.11,49.98 JNGFF1.24 ; JNGFF1.24 242.11,50.82 ; JNGFF1.24 242.01,50.4 ; JHDMI1.23 13.08,54.35 ; JHDMI1.23 11.75,55.33 ; JHDMI1.23 13.08,55.33 ; JHDMI1.23 11.75,53.37 ; JHDMI1.23 10.42,53.37 ; JHDMI1.23 10.42,55.33 ; JHDMI1.23 13.08,53.37 ; JHDMI1.23 10.42,54.35 ; JUSB1.12 299.48,61.93 ; JUSB1.12 296.92,60.38 ; JUSB1.12 299.48,61.15 ; JUSB1.12 296.92,61.15 ; JUSB1.12 296.92,61.93 ; JUSB1.12 298.2,61.93 ; JUSB1.12 298.2,60.38 ; JUSB1.12 299.48,60.38 ; 105.9,81.7 H1.1 ; H1.1 107.6,82.34 ; H1.1 105.9,78.3 ; H1.1 109.3,78.3 ; H1.1 109.3,81.7 ; H1.1 107.6,77.66 ; H1.1 105.26,80 ; H1.1 109.94,80 ; 288.55,68.29 JUSB1.7 ; JUSB1.7 287.84,69 ; JUSB1.7 288,69.55 ; JUSB1.7 288.55,69.71 ; JUSB1.7 288,68.45 ; 1.67,38.35 JHDMI1.20 ; JHDMI1.20 5.13,38.35 ; JHDMI1.20 5.13,37.37 ; JHDMI1.20 1.67,37.37 ; JHDMI1.20 3.4,37.37 ; JUSB1.13 295.53,60.38 ; JUSB1.13 294.25,60.38 ; JUSB1.13 295.53,61.15 ; JUSB1.13 295.53,61.93 ; JUSB1.13 292.97,61.15 ; JUSB1.13 292.97,60.38 ; JUSB1.13 294.25,61.93 ; H9.1 5.5,92.64 ; H9.1 4.33,89.88 ; H9.1 3.91,91.05 ; H9.1 5.5,89.46 ; H9.1 7.09,91.05 ; H9.1 6.67,89.88 ; H9.1 4.33,92.22 ; H9.1 6.67,92.22 ; 11.14,48.06 JHDMI1.11 ; JHDMI1.11 11.14,47.14 ; JHDMI1.11 12.06,47.14 ; JHDMI1.11 12.06,48.06 ; JHDMI1.11 12.18,47.6 ; JHDMI1.11 11.02,47.6 ; 285.67,42.07 JSD1.10 ; JSD1.10 286.8,42.8 ; JSD1.10 287.93,41.35 ; JSD1.10 287.93,42.07 ; JSD1.10 285.67,42.8 ; JSD1.10 286.8,41.35 ; JSD1.10 285.67,41.35 ; JSD1.10 287.93,42.8 ; H2.1 109.3,59.56 ; H2.1 107.6,55.52 ; H2.1 105.9,56.16 ; H2.1 109.94,57.86 ; H2.1 109.3,56.16 ; H2.1 105.26,57.86 ; H2.1 107.6,60.2 ; H2.1 105.9,59.56 ; 291.67,6.33 H27.1 ; H27.1 296.33,6.33 ; H27.1 294,0.77 ; H27.1 290.77,4 ; H27.1 297.23,4 ; H27.1 291.67,1.67 ; H27.1 294,7.23 ; H27.1 296.33,1.67 ; JUSBC1.2 6.85,87.76 ; JUSBC1.2 8.15,87.02 ; JUSBC1.2 8.15,86.28 ; JUSBC1.2 5.55,87.76 ; JUSBC1.2 5.55,87.02 ; JUSBC1.2 8.15,87.76 ; JUSBC1.2 6.85,86.28 ; 298.47,56.4 JSD1.12 ; JSD1.12 299.6,54.95 ; JSD1.12 298.47,55.67 ; JSD1.12 299.6,56.4 ; JUSBC2.5 6.25,73.3 ; JUSBC2.5 5.53,73.3 ; JUSBC2.5 6.97,71.29 ; JUSBC2.5 5.53,72.19 ; JUSBC2.5 6.97,73.3 ; JUSBC2.5 6.25,71.29 ; JUSBC2.5 5.53,71.29 ; JUSB2.10 6.75,17.53 ; JUSB2.10 8.03,16.75 ; JUSB2.10 5.47,17.53 ; JUSB2.10 5.47,15.97 ; JUSB2.10 8.03,15.97 ; JUSB2.10 6.75,15.97 ; JUSB2.10 5.47,16.75 ; 165.7,78.3 H3.1 ; H3.1 165.7,81.7 ; H3.1 167.4,77.66 ; H3.1 169.1,81.7 ; H3.1 167.4,82.34 ; H3.1 165.06,80 ; H3.1 169.74,80 ; H3.1 169.1,78.3 ; JSD1.13 297.53,41.35 ; JSD1.13 296.4,42.8 ; JSD1.13 295.27,41.35 ; JSD1.13 297.53,42.8 ; JSD1.13 297.53,42.07 ; JSD1.13 296.4,41.35 ; JSD1.13 295.27,42.8 ; JSD1.13 295.27,42.07 ; JUSBC1.4 8.18,77.6 ; JUSBC1.4 5.52,78.38 ; JUSBC1.4 8.18,79.16 ; JUSBC1.4 6.85,77.6 ; JUSBC1.4 5.52,77.6 ; JUSBC1.4 8.18,78.38 ; JHDMI1.21 5.13,55.85 ; JHDMI1.21 3.4,56.83 ; JHDMI1.21 1.67,55.85 ; JHDMI1.21 1.67,56.83 ; JHDMI1.21 5.13,56.83 ; JHDMI1.2 13.73,43.1 ; JHDMI1.2 12.69,43.56 ; JHDMI1.2 13.61,42.64 ; JHDMI1.2 12.69,42.64 ; JHDMI1.2 12.57,43.1 ; JHDMI1.2 13.61,43.56 ; JHDMI1.2 13.15,42.52 ; 1.8,71.69 JUSBC2.1 ; JUSBC2.1 3.27,72.52 ; JUSBC2.1 3.27,73.35 ; JUSBC2.1 3.27,71.69 ; JUSBC2.1 1.8,73.35 ; JUSBC2.4 8.18,63.1 ; JUSBC2.4 6.85,63.1 ; JUSBC2.4 5.52,63.1 ; JUSBC2.4 5.52,63.88 ; JUSBC2.4 8.18,64.65 ; JUSBC2.4 8.18,63.88 ; 177.5,84.97 H34.1 ; H34.1 175.47,87 ; H34.1 178.99,88.49 ; H34.1 177.5,89.03 ; H34.1 179.53,87 ; H34.1 176.01,88.49 ; H34.1 176.01,85.51 ; H34.1 178.99,85.51 ; JHDMI1.5 12.18,44.6 ; JHDMI1.5 11.14,44.14 ; JHDMI1.5 11.02,44.6 ; JHDMI1.5 12.06,44.14 ; JHDMI1.5 11.14,45.06 ; JHDMI1.5 12.06,45.06 ; 6.25,85.83 JUSBC1.5 ; JUSBC1.5 5.56,86.7 ; JUSBC1.5 6.94,85.83 ; JUSBC1.5 6.94,87.76 ; JUSBC1.5 5.56,85.83 ; JUSBC1.5 5.56,87.76 ; JUSBC1.5 6.25,87.76 ; 11.14,51.06 JHDMI1.17 ; JHDMI1.17 12.06,50.14 ; JHDMI1.17 11.14,50.14 ; JHDMI1.17 12.18,50.6 ; JHDMI1.17 11.02,50.6 ; JHDMI1.17 12.06,51.06 ; JUSB2.11 2.8,17.53 ; JUSB2.11 1.52,16.75 ; JUSB2.11 1.52,15.97 ; JUSB2.11 4.08,15.97 ; JUSB2.11 2.8,15.97 ; JUSB2.11 4.08,17.53 ; JUSB2.11 4.08,16.75 ; 6.75,31.67 JUSB2.13 ; JUSB2.13 8.03,33.23 ; JUSB2.13 5.47,32.45 ; JUSB2.13 5.47,33.23 ; JUSB2.13 8.03,32.45 ; JUSB2.13 6.75,33.23 ; JUSB2.13 5.47,31.67 ; 45.43,36.23 PBATT1.12 ; PBATT1.12 46.12,34.22 ; PBATT1.12 45.43,34.22 ; PBATT1.12 45.43,35.22 ; PBATT1.12 46.12,36.23 ; PBATT1.12 46.82,35.22 ; PBATT1.12 46.82,36.23 ; PBATT1.12 46.82,34.22 ; 283.83,2.83 H26.1 ; H26.1 285,5.59 ; H26.1 285,2.41 ; H26.1 286.59,4 ; H26.1 283.83,5.17 ; H26.1 286.17,2.83 ; H26.1 283.41,4 ; H26.1 286.17,5.17 ; JHDMI1.8 13.61,46.56 ; JHDMI1.8 12.69,46.56 ; JHDMI1.8 13.73,46.1 ; JHDMI1.8 13.61,45.64 ; JHDMI1.8 12.57,46.1 ; JHDMI1.8 12.69,45.64 ; PBATT1.11 46.82,39.7 ; PBATT1.11 46.12,37.7 ; PBATT1.11 45.43,38.7 ; PBATT1.11 46.82,38.7 ; PBATT1.11 45.43,37.7 ; PBATT1.11 46.12,39.7 ; JSD1.11 287.93,55.67 ; JSD1.11 285.67,54.95 ; JSD1.11 285.67,55.67 ; JSD1.11 287.93,56.4 ; JSD1.11 286.8,56.4 ; JSD1.11 286.8,54.95 ; JSD1.11 287.93,54.95 ; JUSBC1.6 6.97,79.61 ; JUSBC1.6 6.25,79.61 ; JUSBC1.6 5.53,79.61 ; JUSBC1.6 6.25,77.6 ; JUSBC1.6 5.53,77.6 ; JUSBC1.6 6.97,77.6 ; PBATT1.13 61.57,39.7 ; PBATT1.13 60.18,38.7 ; PBATT1.13 60.18,39.7 ; PBATT1.13 60.87,37.7 ; PBATT1.13 60.18,37.7 ; PBATT1.13 61.57,38.7 ; PBATT1.13 61.57,37.7 ; PBATT1.13 60.87,39.7 ; PBATT1.14 61.57,35.22 ; PBATT1.14 60.87,34.22 ; PBATT1.14 60.18,35.22 ; PBATT1.14 60.18,36.23 ; PBATT1.14 61.57,34.22 ; PBATT1.14 60.87,36.23 ; PBATT1.14 60.18,34.22 ; PBATT1.14 61.57,36.23 ; 1.52,33.23 JUSB2.12 ; JUSB2.12 4.08,33.23 ; JUSB2.12 2.8,33.23 ; JUSB2.12 2.8,31.67 ; JUSB2.12 1.52,32.45 ; JUSB2.12 4.08,31.67 ; JUSB2.12 4.08,32.45 ; 242.11,47.82 JNGFF1.36 ; JNGFF1.36 242.01,47.4 ; JNGFF1.36 242.11,46.98
  IN4 w0.127: 46.22,77.48 46.5,77.2 47.52,77.2 v2(47.97,77.66) 48.37,78.05 48.37,79.16 48.16,79.36 46.44,79.36 46.22,79.14 46.22,77.48
  IN4 w0.508: v2(279.93,33.52) 280.59,34.18 v2(280.59,38.44) 283.9,41.75 284.75,41.75 v2(285.2,42.2) ; v2(279.04,43.4) 279.04,43.11 276.45,40.52 v2(276.45,39.18)
  GND5 w0.127: JNGFF2.77 234.71,68.15 234.32,67.76 ; JNGFF2.77 235.89,67.35 235.83,67.29 ; JNGFF2.77 237.16,68.15 237.38,67.93 ; JNGFF1.76 245.23,58.15 244.85,58.53 ; JNGFF1.76 246.49,58.9 246.64,59.05 ; JNGFF1.76 247.96,58.15 248.1,58.29 ; JNGFF1.77 245.3,35.65 245.03,35.38 ; JNGFF1.77 246.49,34.82 246.47,34.81 ; JNGFF1.77 247.82,35.65 248.04,35.43 ; 83.06,51.51 83.06,51.15 ; JNGFF2.76 234.7,90.65 234.24,91.11 ; JNGFF2.76 237.14,90.65 237.3,90.81 ; JNGFF2.76 235.89,91.39 235.95,91.45
  GND5 w0.203: H19.1 7.09,59.85 ; H19.1 4.33,58.68 ; H19.1 3.91,59.85 ; H19.1 5.5,58.26 ; H19.1 4.33,61.02 ; H19.1 5.5,61.44 ; H19.1 6.67,58.68 ; H19.1 6.67,61.02 ; 1.67,37.37 JHDMI1.20 ; JHDMI1.20 1.67,38.35 ; JHDMI1.20 5.13,37.37 ; JHDMI1.20 5.13,38.35 ; JHDMI1.20 3.4,37.37 ; JUSBC1.3 3.27,77.55 ; JUSBC1.3 3.27,79.21 ; JUSBC1.3 3.27,78.38 ; JUSBC1.3 1.8,79.21 ; JUSBC1.3 1.8,77.55 ; JSD1.11 286.8,56.4 ; JSD1.11 287.93,56.4 ; JSD1.11 287.93,54.95 ; JSD1.11 286.8,54.95 ; JSD1.11 285.67,54.95 ; JSD1.11 285.67,55.67 ; JSD1.11 287.93,55.67 ; 292.97,60.38 JUSB1.13 ; JUSB1.13 295.53,61.15 ; JUSB1.13 292.97,61.15 ; JUSB1.13 295.53,60.38 ; JUSB1.13 295.53,61.93 ; JUSB1.13 294.25,61.93 ; JUSB1.13 294.25,60.38 ; 295.27,42.8 JSD1.13 ; JSD1.13 297.53,42.07 ; JSD1.13 295.27,42.07 ; JSD1.13 296.4,41.35 ; JSD1.13 296.4,42.8 ; JSD1.13 297.53,41.35 ; JSD1.13 295.27,41.35 ; JSD1.13 297.53,42.8 ; JUSBC2.2 6.85,73.3 ; JUSBC2.2 8.18,73.3 ; JUSBC2.2 5.52,73.3 ; JUSBC2.2 8.18,72.52 ; JUSBC2.2 5.52,72.52 ; JHDMI1.2 13.61,43.56 ; JHDMI1.2 12.69,42.64 ; JHDMI1.2 12.69,43.56 ; JHDMI1.2 13.15,42.52 ; JHDMI1.2 12.57,43.1 ; JHDMI1.2 13.73,43.1 ; JHDMI1.2 13.61,42.64 ; 4.33,89.88 H9.1 ; H9.1 5.5,92.64 ; H9.1 7.09,91.05 ; H9.1 5.5,89.46 ; H9.1 6.67,89.88 ; H9.1 4.33,92.22 ; H9.1 3.91,91.05 ; H9.1 6.67,92.22 ; JUSB1.10 295.53,76.08 ; JUSB1.10 295.53,76.85 ; JUSB1.10 294.25,77.63 ; JUSB1.10 292.97,76.85 ; JUSB1.10 292.97,77.63 ; JUSB1.10 294.25,76.08 ; JUSB1.10 295.53,77.63 ; JUSBC1.5 6.25,87.76 ; JUSBC1.5 6.94,87.76 ; JUSBC1.5 5.56,87.76 ; JUSBC1.5 5.56,85.83 ; JUSBC1.5 5.56,86.7 ; JUSBC1.5 6.25,85.83 ; JUSBC1.5 6.94,85.83 ; 1.67,55.85 JHDMI1.21 ; JHDMI1.21 5.13,55.85 ; JHDMI1.21 1.67,56.83 ; JHDMI1.21 5.13,56.83 ; JHDMI1.21 3.4,56.83 ; 165.7,78.3 H3.1 ; H3.1 167.4,77.66 ; H3.1 169.74,80 ; H3.1 169.1,78.3 ; H3.1 165.7,81.7 ; H3.1 167.4,82.34 ; H3.1 169.1,81.7 ; H3.1 165.06,80 ; 46.12,34.22 PBATT1.12 ; PBATT1.12 46.82,36.23 ; PBATT1.12 46.82,34.22 ; PBATT1.12 45.43,34.22 ; PBATT1.12 45.43,35.22 ; PBATT1.12 46.82,35.22 ; PBATT1.12 45.43,36.23 ; H20.1 69.9,67.39 ; H20.1 71.07,64.63 ; H20.1 68.73,66.97 ; H20.1 69.9,64.21 ; H20.1 71.49,65.8 ; H20.1 68.31,65.8 ; H20.1 68.73,64.63 ; H20.1 71.07,66.97 ; 5.53,65.11 JUSBC2.6 ; JUSBC2.6 6.97,63.1 ; JUSBC2.6 5.53,63.1 ; JUSBC2.6 6.25,63.1 ; JUSBC2.6 6.97,65.11 ; JUSBC2.6 6.25,65.11 ; 285.67,42.07 JSD1.10 ; JSD1.10 285.67,41.35 ; JSD1.10 286.8,42.8 ; JSD1.10 287.93,42.07 ; JSD1.10 287.93,41.35 ; JSD1.10 285.67,42.8 ; JSD1.10 286.8,41.35 ; JSD1.10 287.93,42.8 ; H12.1 92.09,93.2 ; H12.1 91.67,92.03 ; H12.1 88.91,93.2 ; H12.1 89.33,92.03 ; H12.1 90.5,94.79 ; H12.1 89.33,94.37 ; H12.1 91.67,94.37 ; H12.1 90.5,91.61 ; H1.1 109.3,81.7 ; H1.1 105.9,78.3 ; H1.1 109.3,78.3 ; H1.1 105.9,81.7 ; H1.1 109.94,80 ; H1.1 107.6,77.66 ; H1.1 107.6,82.34 ; H1.1 105.26,80 ; 60.18,35.22 PBATT1.14 ; PBATT1.14 60.87,36.23 ; PBATT1.14 60.87,34.22 ; PBATT1.14 61.57,34.22 ; PBATT1.14 60.18,34.22 ; PBATT1.14 61.57,35.22 ; PBATT1.14 60.18,36.23 ; PBATT1.14 61.57,36.23 ; H14.1 151.67,94.37 ; H14.1 151.67,92.03 ; H14.1 150.5,91.61 ; H14.1 149.33,94.37 ; H14.1 150.5,94.79 ; H14.1 152.09,93.2 ; H14.1 149.33,92.03 ; H14.1 148.91,93.2 ; JUSB1.12 299.48,61.15 ; JUSB1.12 299.48,61.93 ; JUSB1.12 299.48,60.38 ; JUSB1.12 298.2,61.93 ; JUSB1.12 298.2,60.38 ; JUSB1.12 296.92,61.93 ; JUSB1.12 296.92,61.15 ; JUSB1.12 296.92,60.38 ; 54.1,89.87 H11.1 ; H11.1 52.42,91.55 ; H11.1 52.86,90.31 ; H11.1 55.34,92.79 ; H11.1 55.34,90.31 ; H11.1 54.1,93.23 ; H11.1 52.86,92.79 ; H11.1 55.78,91.55 ; 5.52,78.38 JUSBC1.4 ; JUSBC1.4 6.85,77.6 ; JUSBC1.4 8.18,77.6 ; JUSBC1.4 8.18,78.38 ; JUSBC1.4 5.52,77.6 ; 176.01,88.49 H34.1 ; H34.1 179.53,87 ; H34.1 178.99,85.51 ; H34.1 177.5,89.03 ; H34.1 178.99,88.49 ; H34.1 177.5,84.97 ; H34.1 175.47,87 ; H34.1 176.01,85.51 ; JUSBC1.6 6.97,79.61 ; JUSBC1.6 5.53,79.61 ; JUSBC1.6 6.25,77.6 ; JUSBC1.6 6.25,79.61 ; JUSBC1.6 6.97,77.6 ; JUSBC1.6 5.53,77.6 ; 285,2.41 H26.1 ; H26.1 285,5.59 ; H26.1 286.17,5.17 ; H26.1 283.83,5.17 ; H26.1 286.17,2.83 ; H26.1 283.83,2.83 ; H26.1 286.59,4 ; H26.1 283.41,4 ; 11.02,50.6 JHDMI1.17 ; JHDMI1.17 11.14,50.14 ; JHDMI1.17 11.14,51.06 ; JHDMI1.17 12.18,50.6 ; JHDMI1.17 12.06,50.14 ; JHDMI1.17 12.06,51.06 ; H27.1 296.33,6.33 ; H27.1 296.33,1.67 ; H27.1 291.67,6.33 ; H27.1 291.67,1.67 ; H27.1 297.23,4 ; H27.1 294,7.23 ; H27.1 294,0.77 ; H27.1 290.77,4 ; JHDMI1.5 12.18,44.6 ; JHDMI1.5 11.14,45.06 ; JHDMI1.5 11.14,44.14 ; JHDMI1.5 12.06,45.06 ; JHDMI1.5 12.06,44.14 ; JHDMI1.5 11.02,44.6 ; JUSB2.10 6.75,17.53 ; JUSB2.10 5.47,16.75 ; JUSB2.10 8.03,15.97 ; JUSB2.10 6.75,15.97 ; JUSB2.10 8.03,16.75 ; JUSB2.10 5.47,17.53 ; JUSB2.10 5.47,15.97 ; JUSBC1.1 3.27,87.02 ; JUSBC1.1 1.8,87.85 ; JUSBC1.1 3.27,87.85 ; JUSBC1.1 1.8,86.19 ; JUSBC1.1 3.27,86.19 ; 234.9,93.31 H16.1 ; H16.1 233.31,94.9 ; H16.1 234.9,96.49 ; H16.1 236.07,96.07 ; H16.1 233.73,96.07 ; H16.1 233.73,93.73 ; H16.1 236.49,94.9 ; H16.1 236.07,93.73 ; JSD1.12 299.6,56.4 ; JSD1.12 298.47,55.67 ; JSD1.12 299.6,54.95 ; JSD1.12 298.47,56.4 ; 4.67,6.33 H24.1 ; H24.1 7,0.77 ; H24.1 7,7.23 ; H24.1 10.23,4 ; H24.1 9.33,1.67 ; H24.1 3.77,4 ; H24.1 4.67,1.67 ; H24.1 9.33,6.33 ; PBATT1.13 61.57,38.7 ; PBATT1.13 60.18,39.7 ; PBATT1.13 60.87,37.7 ; PBATT1.13 61.57,39.7 ; PBATT1.13 60.87,39.7 ; PBATT1.13 60.18,37.7 ; PBATT1.13 60.18,38.7 ; PBATT1.13 61.57,37.7 ; JHDMI1.23 13.08,55.33 ; JHDMI1.23 11.75,53.37 ; JHDMI1.23 13.08,53.37 ; JHDMI1.23 10.42,55.33 ; JHDMI1.23 10.42,54.35 ; JHDMI1.23 13.08,54.35 ; JHDMI1.23 10.42,53.37 ; JHDMI1.23 11.75,55.33 ; JUSBC2.4 8.18,63.88 ; JUSBC2.4 8.18,63.1 ; JUSBC2.4 6.85,63.1 ; JUSBC2.4 5.52,63.1 ; JUSBC2.4 5.52,63.88 ; 105.26,57.86 H2.1 ; H2.1 105.9,59.56 ; H2.1 109.94,57.86 ; H2.1 105.9,56.16 ; H2.1 107.6,60.2 ; H2.1 109.3,56.16 ; H2.1 109.3,59.56 ; H2.1 107.6,55.52 ; PBATT1.11 46.82,38.7 ; PBATT1.11 46.12,37.7 ; PBATT1.11 46.12,39.7 ; PBATT1.11 46.82,39.7 ; PBATT1.11 45.43,38.7 ; PBATT1.11 45.43,37.7 ; JUSBC1.2 8.15,87.76 ; JUSBC1.2 5.55,87.76 ; JUSBC1.2 8.15,86.28 ; JUSBC1.2 6.85,86.28 ; JUSBC1.2 8.15,87.02 ; JUSBC1.2 5.55,87.02 ; JUSBC1.2 6.85,87.76 ; 5.53,72.19 JUSBC2.5 ; JUSBC2.5 6.97,71.29 ; JUSBC2.5 5.53,73.3 ; JUSBC2.5 5.53,71.29 ; JUSBC2.5 6.25,73.3 ; JUSBC2.5 6.25,71.29 ; JUSBC2.5 6.97,73.3 ; JUSB2.11 4.08,16.75 ; JUSB2.11 1.52,15.97 ; JUSB2.11 2.8,17.53 ; JUSB2.11 4.08,17.53 ; JUSB2.11 1.52,16.75 ; JUSB2.11 4.08,15.97 ; JUSB2.11 2.8,15.97 ; 296.92,77.63 JUSB1.11 ; JUSB1.11 299.48,76.85 ; JUSB1.11 296.92,76.85 ; JUSB1.11 296.92,76.08 ; JUSB1.11 298.2,77.63 ; JUSB1.11 299.48,76.08 ; JUSB1.11 299.48,77.63 ; JUSB1.11 298.2,76.08 ; 74.21,73.06 74.8,73.06 74.87,72.98 ; 1.8,63.05 JUSBC2.3 ; JUSBC2.3 3.27,63.05 ; JUSBC2.3 3.27,64.71 ; JUSBC2.3 3.27,63.88 ; JUSBC2.3 1.8,64.71 ; 242.01,50.4 JNGFF1.24 ; JNGFF1.24 242.11,49.98 ; JNGFF1.24 242.11,50.82 ; JUSB2.13 8.03,32.45 ; JUSB2.13 8.03,33.23 ; JUSB2.13 6.75,31.67 ; JUSB2.13 5.47,32.45 ; JUSB2.13 6.75,33.23 ; JUSB2.13 5.47,33.23 ; JUSB2.13 5.47,31.67 ; 165.06,57.9 H4.1 ; H4.1 165.7,59.6 ; H4.1 167.4,55.56 ; H4.1 169.1,56.2 ; H4.1 167.4,60.24 ; H4.1 165.7,56.2 ; H4.1 169.1,59.6 ; H4.1 169.74,57.9 ; JHDMI1.8 13.61,45.64 ; JHDMI1.8 13.73,46.1 ; JHDMI1.8 12.69,45.64 ; JHDMI1.8 13.61,46.56 ; JHDMI1.8 12.69,46.56 ; JHDMI1.8 12.57,46.1 ; H18.1 297.17,79.33 ; H18.1 294.83,81.67 ; H18.1 296,82.09 ; H18.1 296,78.91 ; H18.1 297.59,80.5 ; H18.1 294.83,79.33 ; H18.1 297.17,81.67 ; H18.1 294.41,80.5 ; 133.19,91.21 H13.1 ; H13.1 133.19,93.69 ; H13.1 134.43,94.13 ; H13.1 135.67,91.21 ; H13.1 132.75,92.45 ; H13.1 135.67,93.69 ; H13.1 136.11,92.45 ; H13.1 134.43,90.77 ; JUSB2.12 2.8,33.23 ; JUSB2.12 4.08,32.45 ; JUSB2.12 2.8,31.67 ; JUSB2.12 4.08,33.23 ; JUSB2.12 4.08,31.67 ; JUSB2.12 1.52,33.23 ; JUSB2.12 1.52,32.45 ; JUSB2.7 12.45,25.31 ; JUSB2.7 13,24.05 ; JUSB2.7 12.45,23.89 ; JUSB2.7 13,25.15 ; JUSB2.7 13.16,24.6 ; 11.02,47.6 JHDMI1.11 ; JHDMI1.11 11.14,48.06 ; JHDMI1.11 11.14,47.14 ; JHDMI1.11 12.18,47.6 ; JHDMI1.11 12.06,48.06 ; JHDMI1.11 12.06,47.14 ; JUSBC2.1 1.8,73.35 ; JUSBC2.1 3.27,71.69 ; JUSBC2.1 1.8,71.69 ; JUSBC2.1 3.27,73.35 ; JUSBC2.1 3.27,72.52 ; 288.55,68.29 JUSB1.7 ; JUSB1.7 287.84,69 ; JUSB1.7 288.55,69.71 ; JUSB1.7 288,69.55 ; JUSB1.7 288,68.45 ; JHDMI1.22 13.08,40.83 ; JHDMI1.22 13.08,38.87 ; JHDMI1.22 11.75,40.83 ; JHDMI1.22 10.42,40.83 ; JHDMI1.22 10.42,39.85 ; JHDMI1.22 13.08,39.85 ; JHDMI1.22 10.42,38.87 ; JHDMI1.22 11.75,38.87 ; 242.11,46.98 JNGFF1.36 ; JNGFF1.36 242.01,47.4 ; JNGFF1.36 242.11,47.82 ; v5(63.19,60.17) 63.19,60.51 v4(63.34,60.66) 63.57,60.44 v5(63.57,60.17)
  GND5 w0.254: v5(28.8,54.92) 27.62,54.92 v5(27.59,54.96) ; v5(27.47,60.36) 28.23,60.36 28.57,60.7 28.81,60.7 ; v5(27.53,55.84) 28.47,55.84 v4(28.74,56.12) ; 27.6,62.09 27.58,62.06 v5(27.58,61.35) ; v5(27.5,59.47) 27.53,59.5 29.02,59.5 ; v3(71.25,55.62) v4(71.25,56.3) ; 28.77,58.6 27.63,58.6 v5(27.58,58.66) ; 28.8,57.68 v5(27.59,57.68) ; 28.69,56.78 27.5,56.78 v5(27.49,56.76) ; JUSB2.4 12.69,21.6 ; JUSB1.4 288.37,72
  BOTTOM w0.127: v6(237.02,34.76) 237.02,34.12 v2(237.03,34.12) ; 27.68,53.32 27.68,53.65 27.97,53.94 UT1.A22 ; 136.69,78.85 136.92,79.08 136.92,79.5 136.85,79.57 136.85,79.82 136.92,79.9 136.92,80.15 136.85,80.22 136.85,80.47 136.97,80.59 v5(136.97,80.91)
  BOTTOM w0.152: v5(33.03,64.07) 33.03,64.07 UT1.M1 v5(33.03,63.2) 33.03,62.92 32.97,62.87 ; UT1.U23 UT1.U22 ; UT1.B2 UT1.B1 v5(27.97,63.66) ; UT1.AA23 v5(37.17,54) v5(37.63,54) UT1.AC22 ; v5(27.53,55.84) UT1.A18 UT1.B18 ; UT1.B12 UT1.A12 27.63,58.6 v5(27.58,58.66) ; 37.24,58.6 v5(37.63,58.6) UT1.AC12 ; 32.97,62.87 33.94,62.87 ; 32.97,62.87 32.46,62.87 32.12,63.2 UT1.K2 UT1.K1 32.11,64.07 v5(32.11,64.07) ; UT1.C23 v5(28.89,54) ; UT1.AC6 v5(37.63,61.36) 37.27,61.36 ; 37.23,59.3 37.23,58.85 ; 37.27,60.44 v5(37.63,60.44) UT1.AC8 ; UT1.R23 v5(34.41,54) ; UC1.B14 UC1.D14 ; UC1.AE67 117.81,68.34 ; UT1.AC18 v5(37.63,55.84) ; UT1.N23 v5(33.49,54) ; UT1.AC16 v5(37.63,56.76) ; v5(34.87,64.07) 34.87,64.07 UT1.T1 UT1.T2 34.87,62.84 ; UT1.B10 UT1.A10 27.55,59.52 v5(27.5,59.47) ; UT1.H2 UT1.H1 31.19,64.07 v5(31.19,64.07) ; UT1.L23 v5(32.57,54) ; v5(33.95,64.07) 33.95,64.07 UT1.P1 v5(33.95,63.2) 33.95,62.87 ; v5(28.8,54.92) UT1.B20 UT1.A20 27.62,54.92 v5(27.59,54.96) ; UT1.D16 29.02,56.76 UT1.B16 UT1.A16 v5(27.49,56.76) ; UT1.AC14 v5(37.63,57.68) ; 29,57.68 UT1.B14 UT1.A14 v5(27.59,57.68) ; UT1.B8 UT1.A8 27.56,60.44 v5(27.47,60.36) ; UT1.G23 v5(30.73,54) ; UT1.AC20 v5(37.63,54.92) 37.15,54.92 ; 37.23,59.52 v5(37.63,59.52) UT1.AC10 ; 37.2,55.25 37.26,55.3 37.26,55.84 ; CV12.2 217.06,37 216.37,37 215.69,37.68 214.95,37.68 214.75,37.88 JEDP1.28 ; v5(28.43,54) UT1.A22 ; v5(27.58,61.35) 27.59,61.36 UT1.A6 UT1.B6 ; UT1.W23 UT1.W22 ; v2(122.15,57.91) 122.28,58.04 UC1.BB60 ; UT1.J23 v5(31.65,54) ; UC1.B48 UC1.D48 ; UC1.D18 v5(145.85,80.35)
  BOTTOM w0.178: v2(113.15,64.5) 113.48,64.83 115.63,64.83 UC1.AM71 ; UC1.BB64 119.93,58.23 119.95,58.2 v2(119.95,58.15) ; v2(112.91,61.27) 112.91,61.28 113.48,61.28 114.71,62.5 UC1.AT71 ; v2(124.95,58.15) 124.88,58.22 124.88,58.71 124.88,59.02 UC1.BB55 ; v2(134.69,58.04) 134.67,58.05 134.67,59 UC1.BB38 ; v2(114.73,67.73) 114.95,67.51 UC1.AG71 ; v2(142.27,56.74) 142.33,56.8 142.33,57.7 141.98,58.04 141.98,58.62 UC1.BB26 ; v2(132.02,58.15) 132.02,58.21 132.05,58.24 UC1.BB43 ; UC1.BB34 137,58.75 137,57.39 v2(137.05,57.34) ; v2(139.77,57.71) 139.63,57.85 139.63,58.37 UC1.BB30 ; UT1.AC22 38.27,54 38.44,53.84 ; v2(145.78,58) 145.76,58.02 145.76,58.1 145.73,58.13 UC1.BB18
  BOTTOM w0.203: 117.78,62.89 UC1.AT68 117.78,62.08 ; UC1.AM68 117.97,64.95 v2(118.27,64.65) ; UC1.AM68 117.78,65.34 ; UC1.AM68 117.78,64.47 ; 31.4,58.28 31.72,57.95 UT1.J13 ; 31.4,58.28 31.08,57.96 UT1.H13 ; 31.4,58.28 31.73,58.6 UT1.J12 ; 31.4,58.28 31.08,58.6 UT1.H12 ; UC1.U64 120.06,72.3 v2(120.38,71.98) 120.71,72.3 UC1.U63 ; PC207.2 81.5,43.01 PR206.2 ; v5(32.57,54) 32.57,54.28 32.73,54.44 ; 117.8,63.7 UC1.AP68 117.8,63.66 ; 117.77,67.43 UC1.AH67 117.86,66.7 v2(117.86,66.52) 117.52,66.18 UC1.AK68 117.46,66.11 ; UT1.D6 28.97,61.36 UT1.B6 ; 130.08,60.97 UC1.AW47 129.27,60.97 ; UC1.J38 v2(133.81,76.15) ; 117.79,61.69 UC1.AV68 117.82,61.3 v2(118.27,60.84) ; 119.38,65.14 UC1.AL65 119.41,65.16 ; UT1.D12 UT1.B12 ; UT1.L13 32.38,57.96 32.05,58.28 ; 29.81,53.1 UT1.E23 v5(29.81,54) 29.81,54.05 29.51,54.35 29.09,54.35 28.89,54.15 v5(28.89,54) v5(28.43,54) ; v5(31.65,54) 31.65,54.26 31.49,54.42 ; v5(206.4,35.25) 206.54,35.12 210.33,35.12 210.72,34.73 v5(211.53,34.73) ; UT1.V6 v2(35.95,60.88) ; v2(35.95,60.88) UT1.V8 ; v2(35.95,60.88) UT1.W6 ; v2(35.95,60.88) UT1.W8 ; UC1.BA66 UC1.AY66 v2(118.27,60.84) ; 123.12,60.97 UC1.AW57 ; UC1.AW38 135.04,60.97 135.05,60.99 135.37,60.99 135.39,60.97 UC1.AW36 136.26,60.97 136.28,60.99 136.6,60.99 136.62,60.97 UC1.AW34 137.1,61.12 v2(137.45,61.46) 137.94,60.97 UC1.AW32 138.79,60.97 138.81,60.99 139.13,60.99 139.14,60.97 UC1.AW30 140.02,60.97 140.03,60.99 140.35,60.99 140.37,60.97 UC1.AW28 141.24,60.97 141.26,60.99 141.58,60.99 141.6,60.97 UC1.AW26 142.47,60.97 142.49,60.99 142.81,60.99 142.83,60.97 UC1.AW23 143.8,60.97 143.81,60.99 144.13,60.99 144.15,60.97 UC1.AW21 ; UC1.U66 118.76,72.3 v2(118.43,71.98) 118.11,72.3 UC1.U67 ; 37.26,55.84 37.26,55.84 ; 37.26,55.84 37.26,56.74 37.28,56.76 ; 37.26,55.84 v5(37.63,55.84) ; v5(91.76,55.81) 91.51,56.06 91.51,56.43 90.81,57.13 v5(90.81,57.58) ; UT1.W5 v2(35.95,61.53) UT1.V5 ; UD2.T12 113.4,44.34 113,44.34 112.78,44.55 v2(112.24,44.55) ; v5(34.41,54) 34.41,54.29 34.59,54.47 ; UT1.L15 v4(32.05,57.63) ; v5(37.17,54) 37.17,54.46 v5(36.93,54.7) ; UC1.AL66 118.85,65.17 ; v5(154.19,78.86) 154.18,78.85 UC1.F4 ; 120.31,60.97 UC1.AW64 119.42,60.97 ; 37.28,56.76 37.28,57.44 37.19,57.53 37.19,57.68 v5(37.63,57.68) ; 37.28,56.76 v5(37.63,56.76) ; UT11.A1 25.99,41.62 25.74,41.38 25.74,41.38 v2(25.73,41.37) ; 122.76,60.97 UC1.AW60 121.89,60.97 ; UC1.AW49 128.01,60.97 128,60.99 127.68,60.99 127.66,60.97 UC1.AW51 126.85,60.97 126.83,60.99 126.51,60.99 126.49,60.97 UC1.AW53 125.62,60.97 125.6,60.99 125.28,60.99 125.27,60.97 UC1.AW55 ; UC1.U69 116.81,72.3 v2(116.48,71.98) 116.16,72.3 UC1.U70 ; 29.13,59.92 UT1.D9 ; 130.44,60.97 UC1.AW45 131.31,60.97 ; 36.92,54.7 v5(36.93,54.7) ; v5(36.93,54.7) 37.15,54.92 ; UC1.AH63 120.78,67.02 ; 120.67,60.97 UC1.AW62 121.54,60.97 ; 28.92,59.52 UT1.B10 ; UC1.J35 v2(135.64,76.15) ; UT1.D18 28.97,55.84 UT1.B18 ; v2(118.27,60.84) 118.53,61.11 UC1.AW66 118.85,60.99 ; v2(140.61,66.94) 140.67,66.87 UC1.AK27 ; UT1.D8 29.13,60.54 ; 120.05,65.16 UC1.AL64 ; UC1.J32 v2(137.47,76.15) ; 120.78,67.79 UC1.AF63 ; UT1.J15 31.4,57.63 v4(31.4,57.63) UT1.H15 ; 206.4,36.84 v5(207.18,37.62) ; v5(33.49,54) 33.49,54.4 33.47,54.42 ; UT1.T15 v2(34.65,57.63) UT1.T13 ; 131.66,60.97 UC1.AW43 ; v5(156.71,61.05) 156.58,61.18 UC1.AV1
  BOTTOM w0.229: UT11.L1 26.23,46.57 25.96,46.3 v5(25.95,46.3)
  BOTTOM w0.254: UC1.AL28 v2(140.21,66.23) ; UC1.AL28 UC1.AM27 v2(140.21,64.67) ; UC1.AL28 UC1.AK27 ; DT26.2 v2(13,65.59) ; DT26.2 13.36,65.07 v2(13.56,65.26) ; DT26.2 12.68,65.07 v2(12.49,65.26) ; v2(12.98,70.47) 13,70.49 DT23.2 13,71 ; UD1.G9 104.43,41.85 v2(104.43,41.94) ; JNGFF1.29 239.82,49.15 239.72,49.05 ; v2(154.25,37.93) UD4.F5 v2(154.22,38.69) ; v2(154.25,37.93) UD4.E5 v2(154.22,38.69) ; v2(154.25,37.93) UD4.F4 ; v2(154.25,37.93) UD4.E4 ; v2(154.22,38.69) UD4.F6 ; v2(154.22,38.69) UD4.E6 ; UT1.W20 36.25,54.67 UT1.W22 ; UC1.AW36 v2(135.83,60.46) UC1.BA36 ; DT13.2 13.34,86.91 13.63,87.21 13.63,87.31 v2(13.68,87.36) ; DT13.2 12.66,86.91 12.31,87.26 v2(12.31,87.31) ; DT13.2 v2(13,87.41) ; v5(8.25,81.44) 8.25,81.39 8.53,81.11 CT102.2 ; UC1.AL48 129.24,65.52 UC1.AM46 v2(129.24,64.67) ; v2(12.44,63.25) 12.51,63.25 12.75,63.5 DT27.2 ; UC1.AV68 UC1.AV69 UC1.AV70 UC1.AV71 115.06,61.11 v2(114.92,60.96) ; v2(13.56,85.07) 13.29,85.34 DT6.2 ; JUSH1.6 v5(199.25,33.83) ; JNGFF1.57 240.07,42.15 v5(239.81,42.4) ; UC1.AP23 v2(142.04,63.38) ; UC1.AP23 UC1.AR23 ; UC1.AP23 UC1.AN23 v2(142.04,64.02) ; UD4.G3 v2(153.59,37.09) UD4.G4 ; DT6.2 v2(13,84.86) ; DT6.2 12.71,85.34 v2(12.41,85.05) ; DT27.2 v2(13,62.95) ; DT27.2 13.25,63.5 13.44,63.31 13.53,63.31 v2(13.61,63.23) ; v2(98.57,38.69) 98.57,38.7 ; 98.57,38.7 98.58,38.71 98.58,38.73 UD1.R6 ; 98.57,38.7 98.57,38.7 98.56,38.71 98.56,38.73 UD1.T6 ; UC1.AM45 130.68,65.06 v2(131.07,64.67) UC1.AM43 131.53,65.08 UC1.AL45 131.07,65.52 UC1.AM45 ; UC1.AM45 v2(130.16,64.67) ; UC1.AP68 v2(117.27,63.68) UC1.AP70 ; 13,71 12.62,71 v2(12.41,70.8) ; 13,71 13.35,71 v2(13.53,70.82) ; v2(122.6,37.13) 122.6,37.12 UD2.C3 ; UD2.M6 116.42,39.07 116.15,38.72 v2(116.08,38.71) ; UD2.K10 117.72,42.17 UD2.L9 117.29,41.3 117.29,40.94 UD2.L8 v2(116.5,40.17) ; UD4.C3 155.54,37.13 v2(155.5,37.13) 155.5,37.13 155.5,37.07 UD4.D3 ; UT1.J8 31.73,60.55 v5(31.4,60.23) 31.08,60.55 UT1.H8 ; v2(114.92,59.92) 115.03,59.81 UC1.AY71 UC1.BA71 UC1.BB70 ; v2(12.43,80.27) 12.9,79.8 DT9.2 ; UC1.BA57 v2(123.58,60.48) UC1.AW57 ; 150.16,75.35 UC1.L11 UC1.J11 ; UD2.N4 115.77,37.43 v2(116.1,37.09) ; UD2.N4 115.44,37.12 UD2.P3 ; UD2.N4 115.43,37.86 115.43,37.9 v2(115.42,37.91) 115.77,38.26 UD2.N5 115.77,38.4 v2(116.08,38.71) ; UD2.R5 113.82,37.67 UD2.T4 v2(114.14,37.12) UD2.R4 ; UD1.D12 106.05,44.23 v2(106.25,44.43) 106.91,44.43 107.35,43.99 UD1.B12 ; UD1.T12 v2(97.91,44.32) ; JNGFF1.33 239.91,48.15 239.72,48.35 239.72,49.05 ; 135.25,81.9 135.22,81.93 v5(135.22,83.42) v5(135.22,84.57) 135.22,85.68 v5(135.27,85.73) 135.27,87.01 v5(133.72,88.55) 130.47,88.55 v5(130.34,88.68) 130.13,88.89 128.27,88.89 v5(128.26,88.88) 128.25,88.89 v5(126.2,88.89) 125.83,89.26 v5(125.83,90.2) 125.83,90.93 v5(125.82,90.94) 125.83,90.95 v5(125.83,92.01) v5(125.83,93.15) 125.92,93.24 v5(126.81,93.24) v5(127.63,93.24) v5(128.67,93.24) v5(129.57,93.24) 130.16,93.24 v5(131.03,92.37) 131.03,92.1 v5(131.59,91.54) v5(132.12,91.01) v5(132.79,90.34) 133.29,90.04 v5(133.52,89.95) 134.13,89.78 v5(134.63,89.28) v5(135.75,88.16) v5(136.2,87.71) 136.9,87.01 v5(136.9,86.47) 136.9,84.98 v5(136.9,84.97) 136.9,84.97 v5(136.9,83.43) 136.9,82.75 v5(136.97,82.69) v5(136.97,82.15) v5(136.97,80.91) ; 135.25,81.9 134.82,81.47 134.82,81.01 ; 135.25,81.9 v2(135.21,81.9) ; v2(119.73,70.15) 119.41,70.47 UC1.AA65 ; UD1.L8 v2(101.82,41.12) UD1.L9 102.15,42.17 UD1.K10 ; UC1.AP63 v2(120.1,63.38) ; UC1.AP63 UC1.AN63 ; UC1.AP63 UC1.AR63 v2(120.1,62.75) UC1.AT63 ; v5(115,79.06) 115.15,78.91 UC1.E71 ; 29.81,53.1 29.81,53.05 v5(29.13,52.38) v5(28.07,51.31) 28.07,51.12 v5(27.6,50.66) 26.9,49.95 v5(26.64,49.95) v5(25.6,49.95) 25.04,49.95 CT20.2 24.81,49.51 v5(24.27,48.98) v5(23.26,48.98) v5(20.9,48.98) 20.62,49.26 v5(20.62,49.54) v5(20.62,50.22) v5(20.62,51.04) v5(20.62,51.85) v5(20.62,52.92) 20.87,53.17 v5(21.63,53.17) v5(22.5,53.17) v5(23.26,53.17) 24.02,53.17 v5(24.05,53.15) 24.12,53.15 24.81,52.46 ; UC1.AP58 v2(122.84,63.38) ; UC1.AP58 UC1.AR58 v2(122.84,62.75) UC1.AT58 ; UC1.AP58 UC1.AN58 ; UD1.T5 v2(98.57,37.92) UD1.R5 ; 233.48,47.42 v5(234.56,47.42) 235.48,48.35 v2(235.63,48.35) v5(236.16,48.88) v5(236.16,49.74) v5(235.5,50.4) ; v2(145.92,43.94) 145.9,43.94 145.62,43.67 CD110.2 ; v5(7.82,66.99) 7.82,66.84 8.07,66.58 8.56,66.58 CT166.2 ; 24.81,52.46 CT21.2 ; 24.81,52.46 25.39,53.04 v5(25.87,53.04) 25.95,53.04 26.7,52.3 27.46,52.3 27.83,52.66 v5(27.83,52.94) 27.83,53.17 27.68,53.32 ; DT10.2 v2(13,77.59) ; DT10.2 13.33,78.23 v2(13.61,77.95) ; DT10.2 12.72,78.23 v2(12.44,77.95) ; v5(189.1,40.5) 189.1,40.7 189.7,41.31 ; UC1.AJ20 144.43,66.99 v5(144.43,67.08) ; UD2.B12 122.92,43.92 123.22,44.27 v2(123.26,44.31) ; UC1.L18 145.74,74.63 UC1.N19 v2(145.08,73.81) ; UC1.AP42 v2(131.99,63.38) UC1.AR43 131.28,62.85 130.95,62.85 UC1.AR45 v2(130.16,62.79) UC1.AR46 ; UC1.AW23 v2(143.28,60.46) UC1.BA23 ; v2(129.25,77.61) 128.94,77.3 UC1.G48 ; v2(114.15,38.71) UD2.T5 ; v2(114.15,38.71) UD2.R6 ; v2(114.15,38.71) UD2.T6 ; v2(121.84,77.61) 122.14,77.3 UC1.G60 ; UD4.K10 151.3,42.17 UD4.L9 UD4.L8 v2(150.78,40.25) ; UD3.L6 135,39.25 134.63,39.25 134.5,39.12 UD3.M6 134.37,39.23 133.94,39.23 v5(133.83,39.12) ; UC1.AU32 137.9,61.81 v2(137.45,61.46) ; v5(211.53,34.73) 211.6,34.65 v5(214.09,34.65) 214.12,34.65 214.14,34.68 214.17,34.65 217.03,34.65 CV21.2 CV20.2 217.1,35.91 217.39,36.2 CV12.2 ; UC1.AK69 UC1.AK68 ; UD3.C3 v2(140.01,37.09) UD3.D3 ; JNGFF1.23 239.85,50.65 v5(239.72,50.52) ; v2(122.58,38.71) UD2.C5 ; v2(122.58,38.71) UD2.C6 ; v2(122.58,38.71) UD2.B6 v2(123.26,38.71) UD2.B5 ; UD2.C3 122.17,36.82 121.72,36.82 UD2.D3 ; UD2.C3 UD2.B2 ; v5(206.4,35.25) v5(206.4,36.84) ; UC1.J13 UC1.H15 ; UC1.H15 v5(147.98,76.67) ; UC1.H15 147.52,76.09 UC1.K16 147.7,75.47 v5(147.36,75.05) v5(146.71,75.05) ; v2(161.89,31.86) 162.43,32.4 PU402.6 ; CZ180.2 33.03,85.28 CZ186.2 ; v2(120.1,64.02) 120.49,64.41 UC1.AN63 ; UC1.AR42 132.43,63.11 v2(131.98,62.76) 132.44,62.47 UC1.AT42 ; 38.44,53.84 38.57,53.7 v5(38.57,52.99) v5(39.39,52.18) v5(39.39,50.76) 39.39,50.04 39.08,49.74 v5(39.06,49.74) 38.42,49.11 v5(38.22,49.11) 38.22,48.6 37.66,48.04 36.72,48.04 v5(36.23,48.54) 35.15,49.62 v5(33.82,49.62) 33.49,49.95 28.84,49.95 28.41,50.38 v5(28.41,50.94) ; 150.27,77.55 UC1.G10 ; v5(239.72,50.52) 239.72,49.05 ; v5(239.72,50.52) 239.09,51.14 v5(239.06,51.14) ; UC1.AL35 v2(136.56,64.75) ; UC1.AN58 v2(122.84,64.02) ; UC1.AN58 UC1.AM60 122.29,65.16 ; UT1.U22 35.33,54.4 ; DT9.2 v2(13,80.45) ; DT9.2 13.09,79.8 v2(13.58,80.3) ; RD73.2 v2(158.21,38.42) ; UC1.AT35 v2(135.64,62.75) UC1.AR35 ; UD4.B12 v2(156.83,44.33) ; UC1.AP28 v2(139.3,63.38) ; UC1.AP28 UC1.AN28 v2(139.3,64.02) UC1.AN30 ; UC1.AP28 UC1.AR28 ; UC1.AM55 125.13,65.08 v5(125.58,65.54) ; UC1.AN63 120.76,64.41 v2(121.01,64.67) 121.08,64.67 UC1.AM61 ; v5(154.18,70.52) v5(155.16,70.52) ; UD4.G9 UD4.G8 153.25,40.18 v2(153.01,39.94) ; UC1.AR28 v2(139.3,62.75) UC1.AT28 UC1.AR28 ; UC1.AW38 v2(133.81,61.43) UC1.AU38 ; v2(110.04,36.03) 110.15,36.14 v6(110.15,36.93) CD43.2 ; UC1.BA41 v2(133.35,60.46) UC1.AW41 ; UC1.AE65 UC1.AE66 ; UC1.AE66 118.76,68.97 v2(118.43,69.29) ; UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 ; UD2.J4 v2(118.71,37.9) ; UC1.C5 153.85,80 ; UD3.B2 v2(140.66,36.32) ; JEDP1.28 v5(214.75,39.55) 214.75,40.06 213.93,40.88 ; CT165.2 8.15,69.81 7.92,69.58 v5(7.92,69.22) ; v2(117.78,73.81) 117.46,74.13 UC1.N68 ; UD2.P8 v2(114.79,41.14) ; UD4.C6 155.86,39.12 156.15,38.82 v2(156.15,38.7) 156.3,38.85 156.3,38.92 UD4.B6 ; UD2.D8 v2(121.28,40.27) ; v2(12.4,72.92) 12.76,72.56 DT22.2 ; UC1.AW28 v2(140.81,60.46) UC1.BA28 ; UC1.AR23 v2(142.04,62.75) UC1.AT23 UC1.AR23 ; UC1.BA45 v2(130.87,60.46) ; v5(151.45,71.21) v5(150.8,72.28) ; v2(141.31,44.29) 141.31,44.28 141.27,44.24 141.27,44.21 UD3.B12 ; UC1.AW62 121.1,60.54 v2(121.02,60.46) 121.1,60.38 UC1.BA62 ; v5(209.25,38.55) 209.25,40.38 v5(209,40.63) 208.46,40.63 208.12,40.29 v5(208.12,38.57) 208.12,38.56 v5(207.18,37.62) ; v2(120.65,38.69) UD2.F5 ; v2(120.65,38.69) UD2.E5 ; v2(120.65,38.69) UD2.F6 UD2.G6 ; v2(120.65,38.69) UD2.E6 ; v2(117.84,35.4) 117.84,35.42 117.78,35.48 117.78,35.86 UD2.K2 ; UC1.BA49 v2(128.46,60.46) UC1.AW49 ; UC1.AW53 v2(126.06,60.46) UC1.BA53 ; UC1.AN42 132.51,64.41 v2(132.9,64.02) UC1.AN40 ; v5(10.23,84.82) 10.09,84.96 CT101.2 ; UD2.L6 v2(116.75,38.69) 116.42,38.37 UD2.M5 116.29,38.19 116.29,37.64 UD2.M4 ; PR206.2 81.64,43.12 v5(82.99,43.12) ; UD4.B2 v2(156.19,36.31) ; v2(154.88,41.11) 154.88,41.06 155.2,40.74 UD4.D8 154.96,40.48 v2(154.96,40.27) ; v2(119.73,73.81) 119.73,73.94 UC1.N65 ; UC1.AF63 UC1.AE64 ; v2(120.36,66.49) UC1.AK63 UC1.AM61 ; v2(120.36,66.49) UC1.AH63 ; v2(120.36,66.49) UC1.AH64 ; v2(116.08,38.71) UD2.N6 ; v2(152.01,78.27) 152.39,78.61 UC1.E6 ; UC1.BA32 v2(138.3,60.46) UC1.AW32 ; UC1.J25 141.13,76.14 v2(141.19,76.08) ; v2(153.59,38.69) 153.59,38.78 UD4.G6 ; 143.37,79.3 UC1.D22 143.17,79.54 143.17,80.15 UC1.B22 ; v2(136.56,64.02) 136.95,64.41 UC1.AN33 ; UD1.P8 v2(99.2,40.32) ; v5(153.87,81.32) 153.87,81.6 v5(154.65,82.38) 154.65,82.81 v5(155.26,83.42) 155.26,84.53 v5(155.06,84.74) v5(154.07,85.78) 153.56,86.72 152.8,87.14 v5(152.72,87.16) 151.88,87.16 v5(151.49,87.19) 151.09,87.23 v5(150.16,87.72) 149.18,88.06 v5(148.96,88.12) 148.74,88.21 v5(147.62,88.6) v5(146.73,89) 145.92,89.25 145.04,89.25 145,89.21 144.75,89.21 v5(144.71,89.17) 144.13,88.93 v5(143.96,88.93) v5(142.97,88.93) v5(141.77,88.93) v5(140.68,88.93) 138.85,88.93 v5(138.6,89.19) v5(138.6,90.18) v5(138.6,91.02) v5(138.6,92.08) v5(138.6,93.05) 138.85,93.3 v5(140.12,93.3) v5(141.52,93.3) v5(142.77,93.3) v5(143.93,93.3) v5(144.84,92.4) 145.46,91.78 v5(145.46,91.02) v5(146.79,90.52) v5(148.02,90.06) v5(149.14,89.63) v5(150.25,89.22) v5(151.4,88.79) 152.23,88.74 v5(152.56,88.67) 153.06,88.55 v5(153.65,88.27) 154.24,87.98 v5(154.6,87.59) v5(155.36,86.83) v5(156.13,86.06) 156.25,85.94 v5(156.25,84.82) v5(156.25,83.68) 156.25,82.88 v5(155.8,82.42) v5(155.8,81.47) 155.8,81.31 156.13,80.98 v5(156.13,80.36) ; v5(148.85,73.34) v5(148.85,74.41) ; UC1.AL66 118.76,65.14 v2(118.27,64.65) ; UD4.P8 v2(148.36,40.31) ; UT1.D8 29.02,60.44 UT1.B8 ; UC1.AL38 134.73,64.87 UC1.AN37 v2(134.73,64.02) UC1.AN38 ; UD1.M12 v2(100.65,44.36) ; UC1.G52 126.74,77.3 v2(126.43,77.61) ; UC1.AT56 124.47,62.72 v2(124.68,62.72) 124.73,62.72 125.13,63.04 UC1.AR55 ; UD2.T3 114.13,36.34 v2(114.13,36.3) UD2.T2 ; v2(117.78,70.15) 117.46,70.47 UC1.AA68 ; v2(125.58,62.75) UC1.AR53 v2(126.48,63.42) UC1.AR52 v2(127.43,63.41) UC1.AR50 v2(128.33,62.84) ; JNGFF1.39 239.74,46.65 ; 30.73,54.44 v5(30.73,54) ; UC1.AN32 v2(137.47,64.02) ; UD4.J12 v2(151.86,44.73) ; UC1.AN35 v2(135.64,64.02) ; UC1.AM61 121.65,65.06 ; UD2.E4 v2(120.64,37.09) ; UD2.H10 119.02,42.17 UD2.G9 119.54,41.39 119.54,40.84 UD2.G8 120.11,40.27 v2(120.11,40.27) ; UD4.C5 v2(156.2,37.93) UD4.B5 ; DT22.2 13.24,72.56 v2(13.59,72.92) ; DT22.2 v2(13,73.16) ; v5(32.72,74.53) v5(33.72,74.53) v5(34.22,74.53) ; UC1.AL32 v2(138.39,66.23) ; UD1.J12 v2(102.87,44.52) ; UC1.G58 123.15,77.3 v2(122.84,77.61) ; UD1.N6 100.5,38.73 v2(100.53,38.69) UD1.M6 ; UC1.AP32 v2(137.47,63.38) ; JEDP1.3 v5(227.25,39.43) ; UD1.P12 v2(99.48,44.55) ; UC1.AM25 v2(141.13,64.67) ; CD104.2 158.96,40.13 v2(158.54,39.71) ; UC1.AP38 v2(133.81,63.38) ; UC1.J28 v2(139.3,76.15) ; UD1.L6 v2(101.18,38.69) ; UC1.J42 v2(131.99,76.15) ; UC1.AP35 v2(135.64,63.38)
  BOTTOM w0.305: JNGFF2.27 v2(229.03,82.15) ; 229,88.15 228.57,88.15 v2(228.26,87.84) ; 229,88.15 JNGFF2.3 ; 229,88.15 229.02,88.12 229.02,87.74 229.11,87.65 JNGFF2.5 ; JNGFF3.45 v2(23.35,13.1) ; JNGFF3.75 15.85,13.33 v5(15.59,13.06) ; JUSH1.7 v5(198.75,33.86) ; JNGFF2.51 v2(229.02,76.15) ; JNGFF3.39 24.85,13.33 v2(24.68,13.17) ; v5(16.3,13.06) 16.35,13.12 JNGFF3.73 ; JNGFF2.73 229.25,70.65 229.15,70.75 v2(228.95,70.75) 229.35,71.15 JNGFF2.71 ; JNGFF3.9 v2(32.35,13.1) ; JNGFF2.39 228.95,79.15 v2(228.95,79.16) ; v2(228.3,86.3) 228.44,86.15 JNGFF2.11 ; JNGFF3.3 v2(33.85,13.1) ; JNGFF3.51 v2(21.85,13.1) ; v2(34.51,13.12) 34.35,13.28 JNGFF3.1 ; JNGFF3.71 16.85,13.23 v5(17.01,13.06) ; JNGFF3.33 v2(26.35,13.1) ; JNGFF3.21 v2(29.35,13.1) ; JNGFF3.15 v2(30.85,13.1) ; JNGFF3.27 v2(27.85,13.1)
  BOTTOM w0.356: CC29.2 63,89.94 v5(62.98,89.95) ; CZ92.2 v5(179.24,37.75)
  BOTTOM w0.381: v5(50.56,89.12) 51.46,89.12 PC1212.2 ; UZ35.3 173.05,83.61 173.25,83.41 173.25,83.37 v2(173.26,83.37) ; CD98.2 129.02,41.47 v2(127.04,41.47) 126.45,41.47 125.52,42.4 CD18.2 ; CLP35.1 153.17,48.54 153.17,49.15 152.77,49.54 v5(150.13,49.54) v5(148.86,49.54) v5(147.59,49.54) 147.54,49.54 147.29,49.79 v5(147.29,50.73) ; CZ187.2 33.33,87.52 CZ181.2 ; v2(14.39,25.31) 14.39,25.33 14.52,25.46 CI3.2 ; v2(17.04,23.25) 16.98,23.2 DI1.3 v2(14.39,23.2) ; v5(145.36,34.19) CD56.2 CD64.2
  BOTTOM w0.457: v5(165.33,50.63) 164.94,50.63 CZ55.2
  BOTTOM w0.508: JTS1.12 195.2,43.54 v5(194.96,43.77) ; v5(141.19,31.3) RD70.2 ; v2(298.31,43.61) 298.62,43.29 JSIM1.17 ; CZ87.2 v5(177.59,38.21) ; v2(46.83,61.65) 47.41,61.07 PC130.2 ; JSPK1.7 286.87,20.76 v2(288.05,19.59) ; v2(291.6,41.78) JSIM1.16 291.6,39.33 ; v2(50.7,60.4) 50.33,60.03 PC906.2 ; v2(291.86,25.03) 291.86,24.35 292.2,24.02 JPWR1.8 ; v5(193.28,38.93) 193.39,38.82 RV305.2 ; v2(278.67,50.74) 279.24,51.32 CZ40.2 ; v2(35.23,28.01) 34.88,27.65 JLED1.7 ; JSIM1.12 v2(290.3,55.56) ; PC652.2 72.62,69.62 v2(73.12,69.12) ; v2(33.96,85.45) CZ180.2 ; JSIM1.14 280.61,42.98 v2(280.61,42.92) ; v2(234.89,52.21) 234.89,51.93 234.37,51.4 JSAR1.4 233.51,51.4 232.21,52.7 JSAR1.6 ; v2(24.05,83.52) 24.05,83.47 ; 24.05,83.47 24.5,83.02 JTUN1.7 ; 24.05,83.47 24.05,83.42 23.7,83.08 JTUN1.8 ; UC6.4 v5(178.51,53.78) ; PC119.2 57.19,68.41 v2(57.7,68.92) ; JSEN2.13 232.05,65.09 v2(231.91,64.95) ; CZ26.2 242.19,63.05 242.45,63.32 v2(242.45,63.46) ; RT205.2 21.94,47.24 v5(21.92,47.26) ; PC2.1 290.09,24.01 v5(290.67,24.01) ; JTUN1.10 21.55,84.45 v2(21.4,84.59) ; PH601.1 v2(87.56,76.64) ; RC139.2 57.87,92.02 v2(57.73,92.16) ; PC139.2 v5(51.99,79.92) ; PC987.2 63.16,60.99 62.6,60.99 v2(62.53,60.92) 62.27,60.66 PC137.2 ; RD28.2 v5(110.71,31.98) ; v2(56.2,61.18) 55.85,61.54 PC952.2 ; CT71.2 32.78,68.67 v5(31.92,68.67) 31.89,68.64 v5(31.03,68.64) v5(30.14,68.64) ; v2(63.8,74.76) 63.59,74.96 PR302.2 ; v2(282.59,54.42) 282.2,54.03 JSIM1.13 ; RZ334.2 279.01,43.38 v2(279.04,43.4) ; JPWR1.6 v5(293.5,25.78) ; v5(28.06,34.78) 28.22,34.62 CT94.2 ; CZ83.2 175.18,37.72 v5(174.71,38.19) ; JSIM1.5 v2(297.31,53.31) ; PC686.2 87.08,77.69 v2(86.85,77.47) ; v5(157.37,28.33) 157.35,28.33 156.93,27.91 PC958.2 ; v2(33.92,81.24) CZ185.2 CZ184.2 ; RC396.2 v5(162.14,63.68) ; v5(189.49,39.13) 189.49,38.66 CV54.2 ; v2(29.35,84.84) 30.2,84.84 JTUN1.9 ; v2(184.35,33.11) 184.35,31.78 JKBTP1.21 ; CI3.2 15.11,25.95 CI46.2 ; v2(33.95,88.2) 33.74,87.99 CZ181.2 ; RV2.2 v2(220.31,34.85) ; JSIM1.11 296.97,56.7 v2(296.74,56.47) ; RT194.2 20.33,45.17 v2(20.25,45.09) ; PC313.2 63.42,67.95 v2(63.42,67.52) ; PC164.2 49.61,60.79 v2(49.19,60.79) ; JSEN2.2 233.47,56.6 233.39,56.52 v2(233.15,56.52) ; CV11.2 CV15.2 v5(223.8,33.47) ; v2(285.2,42.2) 285.2,41.53 284.88,41.21 JSIM1.15 ; PC223.2 v2(87.24,35.45) ; JLED1.8 v2(34.92,21.75) ; v5(64.33,90.41) 64.34,90.42 CC269.2 ; v2(77.51,40.09) 77.12,40.48 PC111.2 ; CZ41.2 v5(281.98,58.71) ; v2(276.51,34.72) 276.51,39.11 v2(276.45,39.18) ; PC312.2 65.78,69.12 v2(65.32,68.67) ; v5(235.5,50.4) v5(236.24,51.14) v5(237.79,51.14) v5(239.06,51.14) ; PC928.2 v2(61.76,55.2) ; RT159.1 CT147.2 20.77,43.39 20.59,43.21 v2(20.29,43.21) ; v5(142.08,31.25) RD71.2 ; v2(13.38,34.81) 13.68,35.11 QV4.3 ; CZ182.2 CZ183.2 v2(34,83.02) ; PC126.2 v2(57.7,69.68) ; PR116.2 v2(79,45.25) ; PC302.2 v2(56.93,61.17) ; v2(280.59,38.44) 282.31,36.71 v2(282.31,36.08) 282.31,35.6 v2(284.4,33.52) ; PC210.2 v2(87.16,37.87) ; RT99.2 v5(31.09,78.62) ; PC128.2 v2(78.15,46.31)
  vias: v2(0.53,75.98) v2(0.75,90.23) v2(0.75,61.78) v2(0.75,14.79) v2(0.75,10.91) v2(0.75,5.83) v2(0.78,2.17) v2(1.29,0.62) v2(1.57,93.18) v2(2.53,0.52) v2(3.63,91.08) v2(3.63,59.88) v2(3.68,0.5) v2(3.94,89.96) v2(3.94,58.76) v2(4.11,92.3) v2(4.11,61.1) v2(4.49,1.65) v2(4.56,6.41) v2(4.67,0.49) v2(5.07,73.69) v2(5.5,93) v2(5.54,89.16) v2(5.5,61.81) v2(5.54,57.96) v2(5.99,0.59) v2(7.04,92.45) v2(6.97,89.69) v2(7.04,61.25) v2(6.97,58.49) v2(7.01,7.43) v2(6.99,0.57) v2(7.46,91.6) v2(7.49,59.78) v2(8.17,0.64) v2(8.5,87.66) v2(8.51,87.08) v2(8.7,78.08) v2(8.7,73.68) v2(8.7,73.1) v2(8.76,63.74) v2(8.89,88.15) v2(9.1,87.59) v2(9.1,77.59) v2(9.31,78.19) v2(9.3,73.69) v2(9.31,73.11) v2(9.3,63.41) v2(9.3,0.49) v2(9.44,89.56) v2(9.43,1.61) v2(9.52,88.13) v2(9.49,6.45) v2(9.56,77.15) v2(9.69,77.73) v2(9.73,62.99) v2(9.86,73.49) v2(10.18,62.61) v2(10.15,0.49) v2(10.3,63.22) v2(10.53,29.88) v2(10.53,19.26) v2(10.46,3.97) v2(11.42,0.52) v2(12.41,1.13) v2(12.54,4.99) v2(12.49,3.69) v2(12.49,2.42) v2(13.51,5.98) v2(13.94,9.46) v2(14.52,89.56) v2(15.11,11.39) v2(15.78,78.02) v2(15.77,76.1) v2(16.08,63.69) v2(16.09,61.94) v2(16.18,72.95) v2(16.18,71.2) v2(16.9,31.48) v2(17.02,81.47) v2(17.32,31.02) v2(18.05,68.1) v2(18.05,66.33) v2(18.46,85.87) v2(18.46,84.11) v2(18.69,10.91) v2(19.6,89.56) v2(20.26,84.12) v2(20.26,82.37) v2(20.83,63.54) v2(20.83,61.79) v2(20.84,60.04) v2(21.17,27.39) v2(22.95,37.27) v2(22.95,36.69) v2(23.03,27.39) v2(23.08,74.66) v2(23.19,75.66) v2(23.23,44.69) v2(23.26,42.66) v2(23.28,16.01) v2(23.54,37.25) v2(23.54,36.66) v2(24.06,58.98) v2(24.17,74.38) v2(24.55,61.66) v2(24.54,59.91) v2(24.55,90) v2(24.58,63.42) v2(24.57,55.42) v2(24.58,53.65) v2(24.9,27.47) v2(25.53,49.39) v2(26.2,58.12) v2(26.78,93.81) v2(27.21,54.63) v2(27.21,52.91) v2(27.26,92.2) v2(28.44,91.33) v2(29.63,28.38) v2(29.6,26.59) v2(29.77,91.69) v2(29.87,37.94) v2(30.32,92.58) v2(30.3,44.79) v2(30.8,93.89) v2(31.13,83.12) v2(31.69,80.53) v2(32.45,26.86) v2(32.45,25.05) v2(33.34,93.91) v2(33.49,26.86) v2(33.49,25.05) v2(33.88,67.57) v2(33.93,66.96) v2(34.61,93.91) v2(35.2,11.41) v2(35.45,17.36) v2(35.6,19.06) v2(35.88,93.91) v2(36.26,9.61) v2(36.44,16.01) v2(37.08,20.28) v2(37.13,6) v2(37.15,93.91) v2(38.02,27.34) v2(38.02,26.07) v2(38.02,24.8) v2(38.02,23.53) v2(38.02,22.26) v2(37.97,15.6) v2(37.99,14.13) v2(37.99,13.01) v2(37.99,11.74) v2(37.99,10.47) v2(37.99,9.2) v2(37.99,7.91) v2(37.99,6.66) v2(38.42,93.91) v2(39.36,28.51) v2(39.69,93.91) v2(40.63,28.51) v2(40.96,93.91) v2(41.95,68.67) v2(41.93,66.9) v2(41.9,28.51) v2(42.23,93.91) v2(42.94,63.48) v2(42.94,62.87) v2(42.94,62.29) v2(43.17,28.51) v2(43.5,93.91) v2(44.44,28.51) v2(44.77,93.91) v2(45.44,54.1) v2(45.44,53.17) v2(45.71,28.51) v2(46.04,93.91) v2(46.18,59.37) v2(46.18,58.78) v2(46.77,59.95) v2(46.77,59.37) v2(46.77,58.78) v2(46.76,54.1) v2(46.76,53.1) v2(46.76,52.09) v2(46.98,28.51) v2(47.31,93.91) v2(48.07,54.1) v2(48.07,53.1) v2(48.07,52.09) v2(48.25,28.51) v2(48.58,93.91) v2(49.39,54.1) v2(49.39,53.1) v2(49.39,52.09) v2(49.52,28.51) v2(49.85,93.91) v2(50.23,52.16) v2(50.79,28.51) v2(51.5,74.96) v2(52.04,75.9) v2(52.04,73.57) v2(52.06,75.32) v2(52.06,74.74) v2(52.06,74.15) v2(52.06,28.51) v2(52.24,71.08) v2(52.3,68.69) v2(52.65,75.9) v2(52.65,75.32) v2(52.65,74.74) v2(52.65,74.15) v2(52.67,76.49) v2(52.77,68.31) v2(53.23,67.85) v2(53.26,76.49) v2(53.33,28.51) v2(54.42,37.65) v2(54.42,36.54) v2(54.42,35.42) v2(54.6,28.51) v2(55.05,60.82) v2(55.54,37.65) v2(55.54,36.54) v2(55.54,35.42) v2(55.63,60.82) v2(55.87,28.51) v2(56.33,60.55) v2(56.66,37.65) v2(56.66,36.54) v2(56.66,35.42) v2(56.94,60.55) v2(56.94,51.9) v2(56.96,52.49) v2(57.07,72.48) v2(57.07,71.33) v2(57.14,28.51) v2(57.7,72.48) v2(58.41,28.51) v2(59.48,76.11) v2(59.68,28.51) v2(59.94,96.17) v2(60.11,76.11) v2(60.34,75.41) v2(60.55,77.86) v2(60.94,76.11) v2(60.94,75.47) v2(60.95,28.51) v2(61.21,96.17) v2(61.57,76.11) v2(61.57,75.47) v2(62.21,76.11) v2(62.21,75.47) v2(62.22,28.51) v2(62.48,96.17) v2(62.53,72.49) v2(62.53,61.68) v2(62.59,70.01) v2(62.84,76.11) v2(62.84,75.47) v2(62.88,69.44) v2(63.49,28.51) v2(63.75,96.17) v2(64.79,63.2) v2(64.76,28.51) v2(65.02,96.17) v2(65.32,51.08) v2(65.32,50.49) v2(65.37,63.2) v2(65.8,63.81) v2(65.96,63.2) v2(66.02,51.12) v2(66.02,50.19) v2(66.03,28.51) v2(66.29,96.17) v2(67.33,51.12) v2(67.33,50.11) v2(67.33,49.11) v2(67.3,28.51) v2(67.43,60.92) v2(67.35,36.92) v2(67.56,96.17) v2(67.61,65.62) v2(67.61,35.09) v2(67.73,37.42) v2(68.11,30.69) v2(68.24,67.27) v2(68.29,35.09) v2(68.37,64.22) v2(68.65,51.12) v2(68.65,50.11) v2(68.65,49.11) v2(68.57,28.51) v2(68.83,96.17) v2(68.75,30.69) v2(69.84,28.51) v2(69.89,68.03) v2(69.89,63.59) v2(69.96,51.12) v2(69.96,50.11) v2(69.96,49.11) v2(70.1,96.17) v2(70.55,51.15) v2(70.55,50.57) v2(70.55,49.98) v2(70.55,49.4) v2(70.76,78.05) v2(70.76,76.53) v2(70.76,75.01) v2(71.13,51.15) v2(71.13,50.57) v2(71.13,49.98) v2(71.13,49.4) v2(71.11,28.51) v2(71.37,96.17) v2(71.42,67.27) v2(71.42,64.35) v2(72.05,65.62) v2(72.29,78.05) v2(72.29,76.53) v2(72.28,75) v2(72.38,28.51) v2(72.64,96.17) v2(73.65,28.51) v2(73.81,78.05) v2(73.81,76.53) v2(73.81,75.01) v2(73.91,96.17) v2(74.08,44.15) v2(74.21,41.74) v2(74.92,28.51) v2(75.05,48.26) v2(75.18,96.17) v2(75.61,48.47) v2(75.61,47.84) v2(75.87,46.61) v2(76.24,48.47) v2(76.24,47.84) v2(76.19,28.51) v2(76.45,96.17) v2(76.5,46.67) v2(77.46,28.51) v2(77.72,96.17) v2(78.73,53.53) v2(78.73,52.49) v2(78.73,28.51) v2(78.78,96.19) v2(78.78,38.72) v2(78.78,37.44) v2(78.78,36.15) v2(78.78,35.09) v2(79.1,69.9) v2(79.1,69.31) v2(79.1,68.73) v2(79.1,68.14) v2(79.65,49.44) v2(79.68,69.9) v2(79.68,69.31) v2(79.68,68.73) v2(79.68,68.14) v2(80,28.51) v2(80.26,96.17) v2(80.29,78.84) v2(80.29,78.25) v2(80.27,69.9) v2(80.27,69.31) v2(80.27,68.73) v2(80.27,68.14) v2(80.53,53.53) v2(80.53,52.49) v2(80.88,78.84) v2(80.88,78.25) v2(80.85,69.9) v2(80.85,69.31) v2(80.85,68.73) v2(80.85,68.14) v2(80.85,67.56) v2(81.27,28.51) v2(81.53,96.17) v2(81.91,55.34) v2(82.49,55.34) v2(82.54,28.51) v2(82.62,55.96) v2(83.08,96.19) v2(83.08,55.34) v2(83.2,55.96) v2(83.33,67.6) v2(83.66,55.34) v2(83.79,55.96) v2(83.81,28.51) v2(83.86,60.74) v2(83.9,60.02) v2(83.98,68.3) v2(83.98,66.74) v2(84.21,96.19) v2(84.45,60.74) v2(84.37,55.96) v2(84.49,60.02) v2(84.96,55.96) v2(85.13,60.03) v2(85.08,28.51) v2(85.34,96.17) v2(85.28,68.3) v2(85.28,66.74) v2(85.54,55.96) v2(85.72,60.03) v2(86.12,55.96) v2(86.14,47.44) v2(86.2,48.12) v2(86.15,46.84) v2(86.3,60.03) v2(86.35,28.51) v2(86.61,96.17) v2(86.57,68.3) v2(86.57,66.74) v2(86.71,55.96) v2(86.72,47.44) v2(86.74,46.84) v2(86.81,48.09) v2(86.87,60.64) v2(86.89,60.03) v2(86.95,65.6) v2(87.33,47.43) v2(87.32,46.85) v2(87.42,67.96) v2(87.39,48.09) v2(87.62,28.51) v2(87.88,96.17) v2(87.85,73.57) v2(87.91,50.2) v2(87.99,60.85) v2(88.21,40.67) v2(88.21,40.06) v2(88.5,93.02) v2(88.64,61.55) v2(88.64,59.99) v2(88.89,28.51) v2(89.06,94.44) v2(89.2,91.81) v2(89.34,96.16) v2(89.82,72.94) v2(89.93,61.55) v2(89.93,59.99) v2(89.88,49.45) v2(90.42,96.17) v2(90.37,28.43) v2(90.51,95.06) v2(90.56,91.23) v2(90.97,75.91) v2(90.97,74.61) v2(90.97,73.32) v2(91.23,61.55) v2(91.23,59.99) v2(91.61,58.85) v2(91.64,27.69) v2(91.69,96.17) v2(91.79,91.92) v2(91.82,76.56) v2(91.88,94.48) v2(92.08,61.21) v2(92.18,72.47) v2(92.46,92.95) v2(92.53,75.91) v2(92.53,74.61) v2(92.53,73.32) v2(92.96,96.17) v2(93.03,79.23) v2(93.03,78.33) v2(94,27.69) v2(94.23,96.17) v2(94.4,65.46) v2(94.4,64.88) v2(94.99,65.46) v2(94.99,64.88) v2(95.5,96.17) v2(96.41,49.56) v2(96.72,27.69) v2(96.77,96.17) v2(98.04,96.17) v2(99.22,50.28) v2(99.23,27.69) v2(99.31,96.17) v2(100.27,66.61) v2(100.27,66.02) v2(100.58,96.17) v2(100.74,72.83) v2(100.68,70.42) v2(100.86,66.61) v2(100.86,66.02) v2(101.12,52.63) v2(101.44,66.61) v2(101.71,52.63) v2(101.69,50.34) v2(101.85,96.17) v2(101.85,70.42) v2(101.8,27.69) v2(102.01,72.83) v2(102.02,66.61) v2(102.61,66.61) v2(103.12,96.17) v2(104.39,96.17) v2(105.05,27.29) v2(105.66,96.17) v2(105.78,24.85) v2(106.93,96.17) v2(106.95,24.49) v2(108.2,96.17) v2(109.26,24.49) v2(109.47,96.17) v2(110.74,96.17) v2(110.83,62.48) v2(110.91,64.14) v2(111.04,67.95) v2(111.22,66.48) v2(111.17,35.47) v2(111.83,61.84) v2(111.83,47.82) v2(111.88,64.83) v2(111.91,60.05) v2(112.01,96.17) v2(112.03,24.49) v2(112.39,66.53) v2(112.92,67.95) v2(112.92,59.37) v2(113.07,92.05) v2(113.12,57.52) v2(113.28,96.17) v2(114.55,96.17) v2(114.52,24.49) v2(115.04,47.39) v2(115.82,96.17) v2(116.68,93.43) v2(117.09,96.17) v2(117.14,69.29) v2(117.11,24.49) v2(117.34,93.43) v2(117.78,69.27) v2(118.36,96.17) v2(118.81,93.96) v2(118.95,56.53) v2(118.93,54.7) v2(119.35,93.43) v2(119.63,96.17) v2(119.74,69.22) v2(119.68,24.49) v2(119.85,52.12) v2(119.95,61.46) v2(119.99,56.37) v2(119.99,54.59) v2(120.44,93.43) v2(120.39,75.65) v2(120.4,69.22) v2(120.9,96.17) v2(121.68,69.66) v2(121.86,93.91) v2(122.12,56.14) v2(122.13,54.28) v2(122.14,52.23) v2(122.17,96.17) v2(122.23,73.35) v2(122.19,24.49) v2(122.45,93.91) v2(122.74,71.01) v2(123.36,96.19) v2(123.47,73.34) v2(123.57,56.78) v2(123.57,54.96) v2(123.76,78.83) v2(123.94,71) v2(124.4,67.19) v2(124.38,24.49) v2(124.71,96.17) v2(124.75,73.34) v2(124.69,56.18) v2(124.76,54.25) v2(125.98,96.17) v2(126.13,68.74) v2(126.1,56.02) v2(126.08,53.91) v2(126.1,52.74) v2(127.2,56.95) v2(127.2,55.72) v2(127.27,24.49) v2(127.63,96.2) v2(128.33,78.83) v2(128.33,57.01) v2(128.44,54.61) v2(128.39,52.73) v2(128.73,96.17) v2(129.22,78.83) v2(129.31,72.53) v2(129.33,71.31) v2(129.66,24.49) v2(129.79,96.17) v2(130.07,39.39) v2(130.19,55.64) v2(130.29,53.73) v2(130.91,67.72) v2(131.06,96.17) v2(131.06,77.61) v2(131.11,71.84) v2(131.94,66.99) v2(132.17,73.87) v2(132.33,96.17) v2(132.35,24.49) v2(132.57,92.19) v2(132.8,93.34) v2(132.86,69.1) v2(133.13,53.13) v2(133.15,91.06) v2(133.18,56.73) v2(133.19,54.92) v2(133.32,82.46) v2(133.6,96.17) v2(134.05,69.12) v2(134.38,94.32) v2(134.43,90.59) v2(134.68,56.24) v2(134.68,54.31) v2(134.68,53.12) v2(134.76,24.52) v2(134.87,96.17) v2(135.25,69.12) v2(135.65,93.86) v2(135.69,51.8) v2(135.84,56.27) v2(135.79,54.25) v2(135.91,91.32) v2(136.14,96.17) v2(136.29,92.36) v2(136.44,69.12) v2(137.15,55.55) v2(137.41,96.17) v2(137.41,37.93) v2(137.43,24.49) v2(137.66,69.12) v2(137.94,55.25) v2(137.9,53.43) v2(138.26,73.88) v2(138.57,72.48) v2(138.68,96.17) v2(138.74,75.25) v2(139.02,69.7) v2(139.62,69.55) v2(139.67,68.67) v2(139.77,56.53) v2(139.77,54.64) v2(139.77,53.43) v2(139.79,51.57) v2(139.95,96.17) v2(139.97,24.49) v2(140.28,74.18) v2(140.28,72.96) v2(140.68,71.76) v2(140.72,70.56) v2(141.22,96.17) v2(141.24,54.9) v2(141.24,52.94) v2(142.23,41.7) v2(142.49,96.17) v2(142.51,24.49) v2(142.64,55.58) v2(143.76,96.17) v2(143.86,64.59) v2(144.26,55.48) v2(144.29,53.7) v2(144.79,64.02) v2(144.79,62.75) v2(145.03,96.17) v2(145.03,52.1) v2(145.28,24.29) v2(145.73,60.28) v2(146.3,96.17) v2(147.32,96.19) v2(147.7,72.11) v2(147.74,22.28) v2(147.81,23.71) v2(148.42,96.19) v2(148.63,93.23) v2(148.68,25.79) v2(148.94,92.11) v2(149.11,94.45) v2(149.3,70.58) v2(149.29,67.43) v2(150.11,96.17) v2(150.5,95.15) v2(150.54,91.31) v2(150.53,26.49) v2(151.2,76.26) v2(151.38,96.17) v2(151.63,38.69) v2(152.04,94.6) v2(151.97,91.84) v2(152.39,68.62) v2(152.44,25.66) v2(152.49,93.13) v2(152.5,74.95) v2(152.65,96.17) v2(153.19,23.8) v2(153.22,22.36) v2(153.66,73.9) v2(153.74,72.91) v2(153.92,96.17) v2(154.59,72.92) v2(155.19,96.17) v2(155.26,23.83) v2(156.23,24.49) v2(156.46,96.17) v2(157.5,24.49) v2(157.73,96.17) v2(158.54,67.65) v2(158.77,24.49) v2(159,96.17) v2(160.04,24.49) v2(160.27,96.17) v2(161.31,24.49) v2(161.54,96.17) v2(162.58,24.49) v2(162.81,96.17) v2(163.85,24.49) v2(164.08,96.17) v2(164.23,32.11) v2(164.27,33.21) v2(165.12,24.49) v2(165.35,96.17) v2(165.35,33.18) v2(165.35,32.13) v2(166.39,24.49) v2(166.62,96.17) v2(166.6,43.52) v2(166.6,42) v2(166.6,40.47) v2(167.13,94.23) v2(167.44,93.11) v2(167.66,24.49) v2(167.89,96.17) v2(168.13,43.52) v2(168.13,42) v2(168.13,40.47) v2(168.93,24.49) v2(169.04,92.31) v2(169.16,96.17) v2(169.65,43.52) v2(169.65,42) v2(169.65,40.47) v2(170.2,24.49) v2(170.43,96.17) v2(170.47,92.84) v2(170.99,94.13) v2(171.51,95.22) v2(171.47,24.49) v2(171.98,93.89) v2(172.74,24.49) v2(173.47,93.48) v2(174.01,24.49) v2(175.28,24.49) v2(175.4,93.48) v2(176.55,24.49) v2(176.79,29.02) v2(176.8,28.01) v2(177.36,93.51) v2(177.83,27.99) v2(177.8,25.74) v2(177.82,24.49) v2(178.46,25.74) v2(179.09,24.49) v2(179.21,91.83) v2(179.21,89.75) v2(179.19,84.31) v2(179.19,82.08) v2(179.19,79.84) v2(179.19,77.61) v2(179.21,75.32) v2(179.21,73.08) v2(179.21,70.49) v2(179.37,67.78) v2(180,64.68) v2(180.36,24.49) v2(180.48,46.82) v2(181.04,61.76) v2(181.63,24.49) v2(182.01,45.37) v2(182.26,46.82) v2(182.57,58.94) v2(182.64,43.04) v2(182.9,24.49) v2(183.79,45.37) v2(183.89,57.08) v2(184.17,24.49) v2(185.44,24.49) v2(185.46,55.33) v2(186.37,48.84) v2(186.71,24.49) v2(187.16,53.78) v2(187.8,46.95) v2(187.98,24.49) v2(188.94,52.49) v2(189.25,24.49) v2(189.58,46.95) v2(190.52,24.49) v2(191.23,51.19) v2(191.79,24.49) v2(193.06,24.49) v2(193.62,50.2) v2(194.33,24.49) v2(195.6,24.49) v2(195.72,49.59) v2(196.87,24.49) v2(198.14,24.49) v2(198.37,49.13) v2(199.41,24.49) v2(199.66,49.03) v2(200.68,24.49) v2(201.05,49) v2(201.95,24.49) v2(202.32,48.61) v2(203.22,24.49) v2(203.7,47.71) v2(204.49,24.49) v2(205.33,47.96) v2(205.76,24.49) v2(206.52,48.23) v2(207.03,24.49) v2(207.72,48.58) v2(208.3,24.49) v2(209.26,49.15) v2(209.57,24.49) v2(210.84,24.49) v2(211.33,50.1) v2(212.11,24.49) v2(213.17,51.19) v2(213.38,24.49) v2(214.65,24.49) v2(214.84,52.38) v2(215.92,24.49) v2(217.19,24.49) v2(217.37,52.54) v2(217.66,46.85) v2(218.46,24.49) v2(218.71,52.08) v2(219.73,24.49) v2(220.11,52.03) v2(221,24.49) v2(221.4,52.43) v2(221.96,61.67) v2(222.22,42.98) v2(222.27,24.49) v2(222.47,59.88) v2(222.6,63.41) v2(222.72,53.37) v2(223.2,65.6) v2(223.55,67.74) v2(223.54,58.48) v2(223.54,24.49) v2(223.69,92.26) v2(223.69,90.99) v2(223.69,89.72) v2(223.69,88.45) v2(223.69,87.18) v2(223.69,85.91) v2(223.69,84.64) v2(223.69,83.37) v2(223.69,82.1) v2(223.69,80.83) v2(223.69,79.56) v2(223.69,78.29) v2(223.69,77.02) v2(223.69,75.75) v2(223.69,74.48) v2(223.69,73.21) v2(223.69,71.94) v2(223.68,69.98) v2(223.74,55.03) v2(223.99,56.7) v2(224.1,93.33) v2(224.81,24.49) v2(224.91,94.67) v2(225.64,93.11) v2(225.81,95.45) v2(226.08,24.49) v2(226.51,61.48) v2(227.2,92.9) v2(227.32,96.17) v2(227.35,24.49) v2(227.37,81.92) v2(227.73,61.48) v2(228.59,96.17) v2(228.62,24.49) v2(228.67,92.84) v2(228.95,61.48) v2(229.19,94.13) v2(229.59,63.8) v2(229.86,96.17) v2(229.89,24.49) v2(231.18,96.25) v2(231.16,24.49) v2(232.11,96.96) v2(232.43,24.49) v2(233.03,94.93) v2(233.18,97.49) v2(233.34,93.81) v2(233.51,96.15) v2(233.7,24.49) v2(234.87,97.48) v2(234.9,96.85) v2(234.94,93.01) v2(234.97,24.49) v2(235.63,46.44) v2(236.24,24.49) v2(236.36,96.3) v2(236.37,93.54) v2(236.89,94.83) v2(237.51,24.49) v2(237.66,34.12) v2(238.37,94.98) v2(238.83,53.69) v2(238.85,51.92) v2(238.78,24.49) v2(239.11,54.92) v2(240.05,24.49) v2(240.06,92.93) v2(241.32,24.49) v2(242.59,24.49) v2(243.45,91.5) v2(243.86,24.49) v2(244.72,91.5) v2(245.13,24.49) v2(245.28,90.28) v2(246.4,24.49) v2(246.55,89.8) v2(247.72,33.82) v2(247.67,24.49) v2(247.79,90.36) v2(248.94,24.49) v2(249.55,91.5) v2(250.21,24.49) v2(250.82,91.5) v2(251.48,24.49) v2(252.09,91.5) v2(252.75,24.49) v2(253.36,91.5) v2(254.02,24.49) v2(255.32,79.24) v2(255.32,77.13) v2(255.29,24.49) v2(255.9,91.5) v2(256.37,78.18) v2(256.49,92.69) v2(256.56,24.49) v2(257.17,91.5) v2(257.42,79.24) v2(257.42,77.13) v2(257.83,24.49) v2(258.31,91.91) v2(258.5,33.99) v2(259.1,24.49) v2(259.71,91.5) v2(260.37,24.49) v2(260.8,27.72) v2(260.9,91.5) v2(261.38,27.72) v2(261.64,24.49) v2(261.93,91.49) v2(261.99,27.72) v2(262.91,24.49) v2(263.52,91.5) v2(263.7,89.11) v2(264.18,24.49) v2(264.38,89.04) v2(264.39,88.22) v2(264.79,91.5) v2(265.21,36.89) v2(265.21,35.57) v2(265.21,34.26) v2(265.21,32.95) v2(265.45,24.49) v2(266.06,91.5) v2(266.52,36.89) v2(266.52,35.57) v2(266.52,34.26) v2(266.52,32.95) v2(266.72,24.49) v2(267.24,89.91) v2(267.33,91.5) v2(267.83,36.89) v2(267.83,35.57) v2(267.83,34.26) v2(267.83,32.95) v2(267.99,24.49) v2(268.6,91.5) v2(269.14,36.89) v2(269.14,35.57) v2(269.14,34.26) v2(269.14,32.95) v2(269.26,24.49) v2(269.6,73.84) v2(269.87,91.5) v2(270.22,74.46) v2(270.22,73.22) v2(270.53,24.49) v2(270.84,73.84) v2(271.14,91.5) v2(271.8,24.49) v2(272.41,91.5) v2(272.51,71.66) v2(273.09,67.7) v2(273.13,51.98) v2(273.07,24.49) v2(273.68,91.5) v2(274.34,24.49) v2(274.95,91.5) v2(275.61,24.49) v2(276.22,91.5) v2(276.88,24.49) v2(277.49,91.5) v2(278.06,58.7) v2(278.06,57.59) v2(278.06,56.47) v2(278.15,24.49) v2(278.35,90.79) v2(278.37,89.24) v2(278.38,88.25) v2(278.38,86.98) v2(278.38,85.71) v2(278.73,84.54) v2(279.18,58.7) v2(279.18,57.59) v2(279.18,56.47) v2(279.58,24.39) v2(280.29,58.7) v2(280.29,57.59) v2(280.29,56.47) v2(280.47,23.29) v2(280.52,22.02) v2(280.52,20.75) v2(280.52,19.48) v2(280.52,18.21) v2(280.52,16.94) v2(280.52,15.67) v2(280.52,14.4) v2(280.52,13.13) v2(280.52,11.86) v2(280.52,10.59) v2(280.52,9.32) v2(280.52,8.05) v2(280.52,6.78) v2(280.52,5.51) v2(280.52,4.24) v2(280.52,2.97) v2(280.52,1.7) v2(281.22,84) v2(282.25,0.54) v2(282.29,44.04) v2(282.64,70.98) v2(282.72,68.36) v2(282.88,72.75) v2(283.13,4.03) v2(283.44,2.91) v2(283.35,0.5) v2(283.47,72.74) v2(283.61,5.25) v2(283.74,84.01) v2(284.19,46.53) v2(284.19,44.77) v2(284.63,81.53) v2(284.9,80.6) v2(285,5.95) v2(285.04,2.11) v2(285.11,82.75) v2(285.11,46.67) v2(285.08,0.68) v2(286.54,79.61) v2(286.54,5.4) v2(286.47,2.64) v2(286.66,0.52) v2(286.99,3.93) v2(287.84,79.81) v2(287.93,0.69) v2(288.04,82.9) v2(288.03,4.63) v2(288.03,3.36) v2(288.07,6.49) v2(288.07,1.65) v2(288.49,81.43) v2(288.82,84.01) v2(289.32,7.5) v2(290.47,63.69) v2(290.53,6.52) v2(290.54,1.63) v2(290.57,4.53) v2(290.59,2.85) v2(290.7,0.64) v2(291.44,1.55) v2(291.56,6.41) v2(291.72,0.5) v2(293.11,0.52) v2(293.85,14.15) v2(293.9,84.01) v2(294.01,7.43) v2(294.13,80.53) v2(294.31,0.52) v2(294.44,79.41) v2(294.61,81.75) v2(296,82.45) v2(296.04,78.61) v2(296.23,17.51) v2(296.43,1.61) v2(296.49,6.45) v2(296.61,27.95) v2(297.54,81.9) v2(297.47,79.14) v2(297.46,3.96) v2(297.99,80.43) v2(298.59,41.3) v2(298.62,0.87) v2(298.85,10.91) v2(298.85,5.83) v2(298.98,84.01) v2(299.69,17.51) v2(300.25,82) v2(300.21,76.72) v2(300.19,61.5) v2(300.25,56.6) v2(300.25,26.12) v2(300.25,21.04) v2(300.5,51.52) v2(300.5,46.44) v3(11.22,62.32) v3(12.36,62.32) v3(13.12,83.02) v3(13.12,68.03) v3(13.5,62.32) v3(13.97,37.55) v3(13.99,35.34) v3(14.52,62.32) v3(15.21,50.4) v3(15.54,61.81) v3(15.55,52.73) v3(15.64,31.58) v3(15.64,28.96) v3(15.64,20.07) v3(15.64,18.8) v3(15.64,17.53) v3(15.66,29.98) v3(16.25,81.62) v3(16.25,80.73) v3(16.25,66.76) v3(16.25,65.74) v3(17.06,61.17) v3(17.31,14.98) v3(18.1,60.11) v3(18.46,32.09) v3(18.84,24.34) v3(18.91,32.82) v3(19.1,58.93) v3(20.41,57.6) v3(20.41,24.37) v3(20.82,16.72) v3(21.45,56.55) v3(21.4,16.72) v3(21.63,31.45) v3(21.79,26.91) v3(22.21,55.73) v3(22.22,42.93) v3(22.29,26.91) v3(22.32,18.89) v3(22.39,48.35) v3(22.39,47.2) v3(22.39,41.36) v3(22.65,78.01) v3(22.65,54.97) v3(22.96,45.93) v3(23.11,76.16) v3(23.13,75.14) v3(23.16,43.9) v3(23.28,47.08) v3(23.39,73.62) v3(23.72,26.91) v3(23.79,73.59) v3(24.05,17.51) v3(24.25,75.37) v3(24.25,74.94) v3(24.2,26.91) v3(24.45,17.48) v3(24.68,71.46) v3(24.68,53.09) v3(24.91,77.81) v3(24.86,71) v3(24.86,70.42) v3(24.88,24.75) v3(25.19,73.75) v3(25.27,52.92) v3(25.39,19.14) v3(25.6,73.54) v3(25.67,45.81) v3(25.67,20.15) v3(25.77,19.14) v3(25.95,49.11) v3(26.08,70.66) v3(26.13,20.15) v3(26.36,52.89) v3(26.4,17.36) v3(26.51,73.64) v3(26.59,21.24) v3(27.09,21.24) v3(28.03,21.47) v3(28.24,46.01) v3(28.49,66.38) v3(28.53,24.09) v3(28.49,21.45) v3(28.62,53.5) v3(28.72,64.5) v3(28.84,58.88) v3(28.84,58.25) v3(28.84,57.59) v3(28.84,56.95) v3(28.95,28.49) v3(29.02,29.9) v3(29.06,34.79) v3(29.2,59.64) v3(29.15,27.87) v3(29.18,26.96) v3(29.18,22.77) v3(29.18,22.16) v3(29.46,71.71) v3(29.62,60.3) v3(29.76,74.76) v3(29.76,63.99) v3(29.82,20.02) v3(30.04,61.55) v3(29.96,21.14) v3(29.96,20.76) v3(30.27,44.15) v3(30.42,72.88) v3(30.74,57.62) v3(30.69,56.88) v3(30.68,55.16) v3(30.85,67.31) v3(30.8,61.37) v3(30.9,74.71) v3(30.87,54.31) v3(31.28,64.83) v3(31.41,66.89) v3(31.45,60.9) v3(31.44,59.57) v3(31.43,58.22) v3(31.41,55.46) v3(31.47,60.3) v3(31.88,73.7) v3(31.88,72.78) v3(31.86,70.03) v3(32.05,58.21) v3(32.13,55.82) v3(32.22,82.94) v3(32.22,82.36) v3(32.25,81.77) v3(32.25,81.19) v3(32.55,54.53) v3(32.56,14.44) v3(32.68,15.2) v3(32.91,61.52) v3(32.86,32.82) v3(33.14,74.51) v3(33.06,64.75) v3(33.24,57.57) v3(33.19,54.53) v3(33.15,29.19) v3(33.28,59.06) v3(33.25,58.43) v3(33.53,60.28) v3(33.53,59.65) v3(33.8,71.46) v3(33.82,70.09) v3(33.95,64.75) v3(34,55.52) v3(34.14,38.01) v3(34.09,34.1) v3(34.15,58.9) v3(34.18,37.07) v3(34.74,55.29) v3(34.66,42.64) v3(34.94,47.84) v3(34.94,46.95) v3(34.99,34.26) v3(35.22,57.07) v3(35.28,42.64) v3(35.39,56.47) v3(35.63,70.06) v3(35.86,49.62) v3(35.91,23.76) v3(36.03,34.12) v3(36.39,59.9) v3(36.43,57.51) v3(36.49,47.33) v3(36.62,70.7) v3(36.83,75.31) v3(36.84,73.53) v3(36.84,72.64) v3(37.2,40.13) v3(37.53,69.55) v3(37.51,30.53) v3(38.22,59.9) v3(38.52,47.84) v3(38.73,34.12) v3(39.16,49.74) v3(39.77,83.83) v3(40.76,61.05) v3(40.76,60.56) v3(40.78,59.34) v3(40.78,58.84) v3(40.77,39.84) v3(41.04,55.84) v3(41.04,55.33) v3(41.06,53.81) v3(41.06,53.27) v3(41.12,32.95) v3(41.22,51.77) v3(41.8,57.57) v3(41.78,57.01) v3(42.19,58.39) v3(42.44,65.36) v3(42.46,68.08) v3(42.46,67.6) v3(42.46,64.86) v3(42.72,84.29) v3(43.05,58.43) v3(43.05,57.87) v3(43.05,56.52) v3(43.05,55.94) v3(43.22,34.88) v3(43.22,33.99) v3(43.4,30.49) v3(43.6,85.05) v3(44.11,86.19) v3(44.06,60.21) v3(44.06,59.67) v3(44.42,91.53) v3(44.42,90.64) v3(44.75,85.56) v3(45.33,88.86) v3(45.33,87.97) v3(45.64,84.03) v3(46.52,86.83) v3(46.58,88.88) v3(46.59,87.98) v3(46.56,33.76) v3(47.41,31.07) v3(47.87,89.87) v3(48.18,43.97) v3(48.46,32.46) v3(49.04,30.39) v3(49.48,45.87) v3(50.2,30.32) v3(50.89,35.98) v3(51.22,81.49) v3(51.83,40.89) v3(51.99,87.46) v3(52.87,81.87) v3(52.95,87.36) v3(53.76,87.46) v3(56.72,30.98) v3(57.01,41.47) v3(57.82,91.13) v3(58.47,91.73) v3(58.59,82.66) v3(58.58,81.76) v3(58.76,83.6) v3(59.07,91.73) v3(59.8,43.93) v3(59.81,39.46) v3(59.83,35.47) v3(60.06,85.5) v3(60.21,86.44) v3(60.51,40.34) v3(61.24,85.58) v3(61.77,88.48) v3(62.07,91.73) v3(62.21,40.34) v3(62.27,34.71) v3(63.08,85.58) v3(63.11,37.42) v3(63.11,36.53) v3(63.34,60.18) v3(63.49,80.38) v3(64.08,90.51) v3(64.06,37.94) v3(64.34,53.96) v3(64.91,90.53) v3(64.94,33.79) v3(65.67,91.73) v3(65.79,82.95) v3(66.13,79.19) v3(66.08,40.22) v3(67,55.56) v3(67.47,91.73) v3(68.01,55.58) v3(68.32,85.46) v3(68.97,84.33) v3(69.06,83.02) v3(69.27,91.73) v3(69.51,44.54) v3(69.51,42.06) v3(70.77,88.48) v3(71.07,91.73) v3(72.57,88.48) v3(72.87,91.73) v3(74.37,88.48) v3(74.67,91.73) v3(75.3,73.36) v3(76.12,42.81) v3(76.17,88.48) v3(76.98,80.64) v3(77.12,91.13) v3(77.26,92.49) v3(77.56,93.48) v3(77.66,78.62) v3(78.15,93.48) v3(78.45,92.49) v3(78.54,78.28) v3(78.54,74.2) v3(79.33,56.78) v3(79.3,55.89) v3(79.58,88.64) v3(79.58,87.69) v3(80.6,51.51) v3(81.02,95.18) v3(81.03,93.3) v3(83.05,41.28) v3(83.56,87.72) v3(83.58,43.32) v3(83.81,89.19) v3(86.84,85.84) v3(88.89,44.41) v3(90.67,42.76) v3(91.89,44.81) v3(93.2,39.93) v3(94.32,42.3) v3(94.4,43.23) v3(95.17,95.21) v3(95.18,47.77) v3(96.34,47.16) v3(96.94,40.29) v3(97.66,41.49) v3(97.83,38.11) v3(97.88,39.58) v3(98.15,95.21) v3(99.33,47.52) v3(100.44,72.1) v3(100.51,71.12) v3(101.64,95.21) v3(101.66,72.1) v3(101.71,71.13) v3(102.93,72.19) v3(103.04,92.33) v3(103.52,34.76) v3(104.51,36.53) v3(105,94.05) v3(105.26,95.4) v3(108.76,95.34) v3(111.55,41.65) v3(111.87,95.21) v3(115.28,77.38) v3(119.03,76.76) v3(119.37,41.74) v3(119.59,45.04) v3(120.4,34.63) v3(120.74,46.82) v3(124.22,76.88) v3(125.45,76.88) v3(125.46,93.78) v3(126.6,29.18) v3(126.79,71.14) v3(127.55,29.18) v3(128.16,76.83) v3(128.5,29.18) v3(128.88,94.95) v3(129.18,84.31) v3(129.18,83.78) v3(129.18,83.14) v3(129.18,82.53) v3(129.18,81.95) v3(129.21,68) v3(129.38,52.85) v3(130.09,83.83) v3(130.6,83.85) v3(130.62,77.86) v3(131.11,79.33) v3(131.23,83.85) v3(131.41,53.22) v3(131.49,94.89) v3(131.61,87.59) v3(131.82,83.85) v3(132.51,79.21) v3(132.58,38.69) v3(132.68,39.58) v3(132.94,86.83) v3(133.01,81.42) v3(133.14,87.97) v3(133.42,86.83) v3(133.39,46.4) v3(133.55,81.42) v3(133.95,53.35) v3(133.95,80.63) v3(134.03,67.62) v3(134.05,78.74) v3(134.14,34.21) v3(134.41,80.63) v3(134.5,46.82) v3(134.65,78.75) v3(134.65,78.18) v3(135.09,41.11) v3(135.21,67.62) v3(135.84,78.75) v3(135.9,67.65) v3(135.98,38.57) v3(136.19,44.08) v3(136.52,34.25) v3(136.74,52.85) v3(137.65,94.76) v3(137.6,78.75) v3(137.81,39.33) v3(138.41,36.18) v3(138.9,78.83) v3(138.9,53.35) v3(139,69.17) v3(139,68.59) v3(139.08,81.29) v3(139.44,34.63) v3(139.54,81.26) v3(139.72,78.85) v3(139.7,78.22) v3(139.7,77.64) v3(140.12,86.06) v3(140.19,94.76) v3(140.42,53.35) v3(140.58,88.36) v3(140.58,87.85) v3(140.58,87.35) v3(140.81,84.79) v3(140.76,78.24) v3(140.87,85.92) v3(140.88,77.45) v3(141.23,84.79) v3(141.24,81.8) v3(141.19,74.96) v3(141.34,78.57) v3(141.39,80.17) v3(141.46,77.45) v3(141.75,89.28) v3(141.93,78.52) v3(141.93,78.09) v3(142.13,89.28) v3(142.2,52.85) v3(142.25,75.52) v3(142.38,86.67) v3(142.51,89.28) v3(142.51,79.79) v3(142.59,85.63) v3(142.85,94.76) v3(142.92,80.6) v3(142.89,66.14) v3(143.51,65.24) v3(144.19,72.87) v3(144.34,89.28) v3(144.72,89.28) v3(145.1,89.28) v3(145.12,85.94) v3(145.08,65.16) v3(145.25,53.53) v3(145.83,68.25) v3(145.97,65.24) v3(146.09,89.28) v3(146.35,85.94) v3(146.39,53.54) v3(146.47,89.28) v3(146.68,66.96) v3(146.85,89.28) v3(146.91,52.66) v3(147.07,45.04) v3(147.24,95.18) v3(147.31,62.95) v3(147.36,85.02) v3(147.92,52.21) v3(147.99,71.33) v3(148.04,67.98) v3(148.48,86.57) v3(148.68,71) v3(148.7,65.92) v3(149.06,52.21) v3(149.18,65.16) v3(149.36,88.44) v3(149.36,87.93) v3(149.36,87.42) v3(149.78,85.56) v3(149.83,45.3) v3(149.95,52.16) v3(150.03,74.35) v3(150.69,78.52) v3(151.22,85.07) v3(151.19,70.82) v3(151.18,53.48) v3(151.73,51.57) v3(153.25,53.98) v3(153.66,86.5) v3(154.13,34.25) v3(154.17,70.06) v3(154.18,45.17) v3(155.57,87.51) v3(155.62,31.07) v3(155.62,30.18) v3(156.05,69.27) v3(156,68.24) v3(155.97,67.22) v3(156.33,87.51) v3(156.39,63.55) v3(156.63,28.28) v3(157.4,91.83) v3(158.24,78.08) v3(158.71,88.44) v3(159.43,53.55) v3(159.73,63.66) v3(160.29,68.55) v3(160.67,73.9) v3(160.88,77.72) v3(161.24,72.7) v3(161.5,63.68) v3(163.49,73.11) v3(163.51,72.22) v3(164.51,40.12) v3(165.78,43.52) v3(165.97,44.63) v3(167.23,39.07) v3(168.06,31.66) v3(168.06,27.48) v3(171.06,36.43) v3(171.57,26.31) v3(172.13,26.68) v3(172.13,26.27) v3(172.66,30.64) v3(172.69,26.31) v3(173.55,30.64) v3(174.22,27.33) v3(174.29,53.57) v3(174.29,53.07) v3(174.29,52.57) v3(174.91,38.22) v3(175.01,39.62) v3(175.29,37.75) v3(175.4,31.52) v3(176.17,39.65) v3(176.29,37.68) v3(176.7,67.27) v3(176.79,54.57) v3(176.79,43.07) v3(177.08,34.17) v3(177.21,37.69) v3(177.26,37.09) v3(177.44,39.65) v3(177.53,72.09) v3(177.59,55.63) v3(177.97,35.21) v3(178.02,34.25) v3(178.12,32.42) v3(178.12,31.53) v3(178.45,57.67) v3(181.02,46.31) v3(181.12,37.71) v3(181.6,46.29) v3(182.31,43.39) v3(182.72,44.89) v3(182.95,42.66) v3(183.15,44.89) v3(183.74,29.52) v3(183.85,30.07) v3(184.57,38.82) v3(184.57,38.31) v3(184.75,29.55) v3(184.85,48.42) v3(185.08,38.57) v3(185.15,29.55) v3(185.34,44.78) v3(185.59,38.82) v3(186.1,38.69) v3(186.1,38.31) v3(186.19,29.55) v3(186.22,26.63) v3(186.61,38.69) v3(186.57,29.55) v3(186.85,26.79) v3(186.85,26.37) v3(188.34,42.28) v3(189.25,46.52) v3(189.41,39.16) v3(191.34,42.28) v3(191.55,36.05) v3(191.48,28.29) v3(192.31,38.77) v3(192.56,36.05) v3(192.94,38.77) v3(193.58,38.77) v3(193.58,36.05) v3(194.21,38.77) v3(194.59,36.05) v3(195.04,39.25) v3(195.84,44.78) v3(195.99,36.05) v3(196.48,30.94) v3(197.01,36.05) v3(197.98,28.29) v3(201.9,42.89) v3(202.66,43.31) v3(203.48,39.74) v3(203.61,43.31) v3(204.37,42.89) v3(204.84,37.42) v3(205.13,43.31) v3(206.29,35.77) v3(206.48,30.69) v3(206.88,36.58) v3(208.09,36.58) v3(208.2,26.22) v3(208.91,36.58) v3(210.13,36.58) v3(211.28,32.4) v3(211.31,31.44) v3(211.42,35.72) v3(211.57,29.27) v3(211.99,29.28) v3(212.06,36.71) v3(212.51,36.79) v3(213.33,35.7) v3(213.31,31.59) v3(213.89,35.7) v3(214.55,36.79) v3(215.61,48.01) v3(215.82,45.93) v3(215.94,36.76) v3(216.04,48.01) v3(216.92,29.5) v3(217.35,29.5) v3(218.25,46.36) v3(218.27,42.79) v3(218.43,48.04) v3(218.36,29.52) v3(218.81,46.36) v3(218.78,29.52) v3(218.89,48.04) v3(221.53,44.79) v3(221.73,46.24) v3(222.17,46.24) v3(222.34,39.06) v3(222.98,44.56) v3(223.05,41.36) v3(223.18,45.81) v3(223.44,44.56) v3(223.36,39.06) v3(225.04,78.9) v3(225.04,77.71) v3(224.99,76.64) v3(224.99,76.21) v3(225.14,80.83) v3(225.14,79.61) v3(225.11,35.54) v3(225.06,34.48) v3(225.21,87.28) v3(225.21,86.88) v3(225.43,61.23) v3(225.47,88.6) v3(225.46,74.19) v3(225.46,73.11) v3(225.49,43.49) v3(225.71,72.11) v3(225.9,38.67) v3(226.16,74.98) v3(226.38,64.14) v3(226.56,35.21) v3(226.89,64.12) v3(227.25,89.49) v3(227.73,81.54) v3(227.7,79.75) v3(227.88,58.81) v3(227.86,56.83) v3(228.01,64.09) v3(227.98,62.78) v3(228.14,89.49) v3(228.21,81.54) v3(228.21,79.76) v3(228.52,55.33) v3(228.8,59.44) v3(228.9,64.79) v3(229,75.62) v3(229.13,87.33) v3(229.13,86.72) v3(229.23,56.73) v3(229.3,64.19) v3(229.53,72.3) v3(229.48,62.78) v3(229.52,58.04) v3(229.76,59.47) v3(231.06,40.73) v3(231.95,26.25) v3(232.71,38.48) v3(233.09,52) v3(233.09,51.05) v3(233.72,38.62) v3(234.23,35.01) v3(234.64,38.62) v3(234.99,31.63) v3(235.12,47.71) v3(235.12,47.08) v3(236.26,35.61) v3(238.32,53.09) v3(238.35,52.61) v3(239.09,57.46) v3(239.09,56.57) v3(239.09,55.68) v3(239.18,44.22) v3(239.67,54.71) v3(240.35,46.49) v3(240.68,45.86) v3(240.68,45.42) v3(240.68,44.43) v3(240.68,44.03) v3(241.05,58.25) v3(246.94,61.7) v3(250.39,66) v3(251.25,71.55) v3(251.39,73.3) v3(251.6,61.85) v3(251.92,65.08) v3(251.99,63.97) v3(252.26,41.23) v3(252.65,57.29) v3(253.33,61.85) v3(253.85,51.74) v3(254.28,44.39) v3(254.28,33.46) v3(254.4,66.25) v3(255.19,60.08) v3(255.24,44.39) v3(256.09,41.04) v3(256.51,57.11) v3(256.59,41.04) v3(257.03,68.13) v3(257.01,47.68) v3(257.09,41.04) v3(257.22,58.34) v3(257.37,34.66) v3(257.37,32.19) v3(257.59,41.04) v3(257.79,33.9) v3(257.79,32.95) v3(257.97,83.38) v3(259.69,83.35) v3(259.87,31.23) v3(260.01,81.39) v3(260.04,71.45) v3(259.96,39.52) v3(260.9,80.27) v3(261.05,35.89) v3(261.45,73.84) v3(261.46,67.31) v3(261.59,52.28) v3(261.67,77.92) v3(261.66,75.27) v3(261.79,81.19) v3(262.02,83.31) v3(262.09,31.53) v3(262.42,67.52) v3(262.91,29.39) v3(263.39,64.61) v3(263.82,68.92) v3(263.85,48.25) v3(264.2,40.22) v3(265.35,68.67) v3(266.79,72.23) v3(267.3,74.57) v3(267.43,72.23) v3(267.51,42.69) v3(268.51,49.51) v3(268.65,84.44) v3(268.77,72.35) v3(268.76,42.66) v3(269.05,40.44) v3(271.62,56.09) v3(272.14,64.95) v3(273.09,65.26) v3(273.09,62.54) v3(274.08,55.68) v3(275,53.04) v3(275.17,57.05) v3(275.24,54.31) v3(275.38,64.35) v3(276.01,67.22) v3(276.9,67.22) v3(277.11,53.65) v3(277.27,63.71) v3(279.65,53.67) v3(282.19,61.81) v3(283.68,58.3) v3(284.14,49.62) v3(285.41,76.11) v3(285.39,75.24) v3(285.39,73.97) v3(285.44,72.81) v3(285.41,64.91) v3(285.44,63.79) v3(285.39,62.47) v3(286.45,23.45) v3(289.34,59.4) v3(289.98,24.04) v3(290.1,59.31) v3(291.05,59.31) v3(295.72,23.45) v3(297.4,23.45) v3(297.4,22.56) v4(19.32,23.73) v4(19.93,23.73) v4(20.21,16.19) v4(20.41,48.27) v4(21.71,18.4) v4(22.04,42.48) v4(22.04,41.84) v4(21.99,16.19) v4(22.05,44.5) v4(22.06,43.9) v4(22.34,48.9) v4(22.34,47.79) v4(22.48,46.55) v4(22.48,45.96) v4(22.7,43.29) v4(23.23,47.57) v4(23.22,41.45) v4(23.16,16.9) v4(23.46,18.45) v4(24.6,18.63) v4(24.66,73.39) v4(24.99,16.93) v4(25.19,71.59) v4(25.39,21.17) v4(25.74,71.84) v4(26.41,22.31) v4(26.38,18.63) v4(26.64,49.41) v4(27.55,22.26) v4(27.63,20.48) v4(28.14,50.02) v4(28.11,47.15) v4(28.42,49.51) v4(28.79,42.1) v4(28.9,60.21) v4(28.87,55.41) v4(28.87,20.46) v4(29.45,58.93) v4(29.45,57.63) v4(29.46,56.96) v4(29.63,23.38) v4(29.68,59.6) v4(29.72,43.67) v4(29.8,44.25) v4(29.91,50.02) v4(30.07,21.73) v4(30.22,75.12) v4(30.22,74.53) v4(30.27,46.36) v4(30.75,73.67) v4(31.28,75.02) v4(31.38,46.03) v4(31.39,45.45) v4(31.89,75.02) v4(31.98,67.05) v4(32.05,60.26) v4(32.5,75) v4(32.66,72.75) v4(32.73,58.99) v4(32.89,50.01) v4(33.77,50.17) v4(34.05,60.28) v4(35.3,54.39) v4(35.32,49.54) v4(35.96,55.72) v4(36.24,47.79) v4(37.99,47.81) v4(38.57,49.69) v4(39.1,37.27) v4(39.44,33.87) v4(40.35,35.25) v4(40.61,38.2) v4(40.94,79.5) v4(41.03,56.49) v4(41.29,59.96) v4(41.29,58.2) v4(41.54,54.72) v4(41.5,52.64) v4(42.94,65.95) v4(42.94,64.14) v4(42.97,41.72) v4(43.42,43.38) v4(43.53,85.58) v4(43.54,57.25) v4(43.54,54.94) v4(43.55,59.01) v4(44.59,86.85) v4(45.1,84.48) v4(45.05,42.43) v4(45.1,41.84) v4(45.08,41.21) v4(45.54,61.05) v4(45.54,59.26) v4(45.74,42.45) v4(45.74,41.84) v4(45.74,41.23) v4(45.99,86.88) v4(46.2,84.54) v4(46.35,42.2) v4(46.33,41.61) v4(47.24,86.65) v4(51.13,80.96) v4(52.89,80.96) v4(63.8,54.57) v4(67.43,55.98) v4(111.01,78.09) v4(112.62,83.68) v4(119.02,35.42) v4(125.7,34.81) v4(132.28,87.27) v4(132.58,88.1) v4(133.8,87.84) v4(135.07,80.1) v4(138.5,82.23) v4(139.61,73.42) v4(139.66,75.21) v4(140.12,85.33) v4(140.15,69.07) v4(140.22,69.66) v4(140.36,74.8) v4(140.64,68.54) v4(140.91,80.1) v4(141.67,86.65) v4(144.04,86.17) v4(144.48,83.54) v4(145.71,86.7) v4(147.34,86.17) v4(147.67,86.72) v4(148.15,78.7) v4(149.34,77) v4(149.87,67.51) v4(150.05,86.12) v4(151.58,86.72) v4(151.58,86.13) v4(152.95,49.36) v4(153.36,86.09) v4(155.49,78.88) v4(173.4,44.76) v4(206.45,36.24) v4(208.45,36.23) v4(210.48,36.23) v4(212.51,36.23) v4(214.6,36.23) v4(215.56,46.57) v4(221.15,45.35) v4(222.29,45.07) v4(223.59,41.72) v4(223.79,45.58) v4(225.85,81.11) v4(225.87,77.33) v4(225.87,75.52) v4(226.1,87.94) v4(226.1,86.17) v4(226.43,78.34) v4(226.43,63.03) v4(227.02,79.26) v4(227.14,63.05) v4(227.93,55.84) v4(228.01,75.09) v4(227.99,73.65) v4(228.44,80.52) v4(228.53,77.49) v4(228.54,58.48) v4(228.97,55.86) v4(229.8,58.44) v4(239.38,45.01) v4(239.57,63.46) v4(239.57,43.65) v4(239.59,39.28) v4(239.67,46.41) v4(245.41,72.04) v4(246.04,62.21) v4(247.82,62.24) v4(252.57,50.81) v4(253.21,58.32) v4(253.84,56.9) v4(263.29,69.17) v4(263.26,67.42) v4(264.08,68.11) v4(265.24,68.13) v4(267.68,61.73) v4(268.04,72.96) v4(274.77,52.46) v4(275.99,64.4) v4(276.6,64.4) v4(281.3,60.74) v4(281.88,52.49) v4(282.47,52.49) v4(296.94,48.65) v4(297.17,43.72) v5(3.94,9.37) v5(5.17,14.6) v5(5.17,14) v5(6.44,14.6) v5(6.44,14) v5(7.12,10.25) v5(7.59,12.02) v5(7.71,14.6) v5(7.71,14) v5(8.13,83.78) v5(8.26,67.14) v5(8.36,69.25) v5(8.62,36.39) v5(8.72,81.67) v5(8.98,14.6) v5(8.98,14) v5(9.5,9.18) v5(13.63,83.14) v5(13.63,68.16) v5(15.42,55.38) v5(15.42,51.57) v5(15.41,42.88) v5(15.41,42.12) v5(15.61,19.24) v5(15.61,17.97) v5(15.92,41.23) v5(16.01,61.05) v5(16.05,20.48) v5(16.12,32.72) v5(16.55,39.84) v5(17.12,28.86) v5(17.19,38.69) v5(17.32,20.48) v5(17.39,32.72) v5(17.98,80.22) v5(17.95,37.17) v5(18.56,31.89) v5(18.59,20.48) v5(18.71,35.9) v5(19.05,23.25) v5(19.18,53.61) v5(19.25,30.59) v5(19.35,34.76) v5(19.27,24.9) v5(19.6,74.38) v5(19.85,59.52) v5(19.86,33.87) v5(19.93,29.37) v5(19.88,24.9) v5(19.85,23.2) v5(19.86,20.48) v5(20.24,55.04) v5(20.35,14.25) v5(20.35,47.65) v5(20.49,32.85) v5(20.62,16.85) v5(20.74,79.97) v5(20.89,87.27) v5(20.95,28.76) v5(21,31.84) v5(21.13,20.48) v5(21.51,17.74) v5(21.51,16.72) v5(21.61,52.16) v5(21.63,26.91) v5(21.76,64.98) v5(21.84,30.95) v5(22.14,80.07) v5(22.19,68.44) v5(22.22,28.76) v5(22.24,18.91) v5(22.33,66.13) v5(22.27,55.27) v5(22.42,67.6) v5(22.47,26.91) v5(22.75,73.64) v5(22.88,64.96) v5(22.9,18.93) v5(23.03,15.58) v5(23.13,75.17) v5(23.12,42.15) v5(23.23,55.25) v5(23.28,44.15) v5(23.41,49.95) v5(23.49,28.76) v5(23.59,26.93) v5(23.56,25.27) v5(23.79,17.48) v5(23.92,17.99) v5(24.17,64.98) v5(24.35,17.48) v5(24.5,26.98) v5(24.49,16.48) v5(24.76,28.76) v5(25.44,64.98) v5(25.39,20.18) v5(25.58,19.18) v5(25.7,22.31) v5(25.85,78.57) v5(25.99,70.19) v5(26.03,28.76) v5(25.95,21.17) v5(26.05,21.75) v5(26.26,27.28) v5(26.26,23.28) v5(26.46,20.2) v5(26.84,78.44) v5(26.94,22.28) v5(27.2,27.28) v5(27.35,20.91) v5(27.5,21.29) v5(27.73,45.12) v5(27.68,21.73) v5(27.73,19.97) v5(28.23,44.62) v5(28.23,44.12) v5(28.57,28.76) v5(28.73,44.12) v5(28.73,43.62) v5(28.73,41.62) v5(29.13,19.9) v5(29.22,71.03) v5(29.23,44.62) v5(29.23,43.62) v5(29.23,41.62) v5(29.52,66.91) v5(29.46,62.72) v5(29.46,61.5) v5(29.46,60.87) v5(29.46,60.21) v5(29.45,58.28) v5(29.51,20.2) v5(29.58,23.86) v5(29.73,45.12) v5(29.73,43.12) v5(29.73,42.12) v5(29.73,41.62) v5(29.86,50.63) v5(30.01,20.28) v5(30.12,62.72) v5(30.09,61.5) v5(30.07,60.21) v5(30.07,56.96) v5(30.07,56.37) v5(30.12,27.8) v5(30.12,27.21) v5(30.3,24.45) v5(30.37,31) v5(30.4,21.34) v5(30.52,23) v5(30.5,22.06) v5(30.65,21.68) v5(30.72,74.53) v5(30.72,73.03) v5(30.72,72.53) v5(30.73,61.5) v5(30.75,62.8) v5(30.75,62.19) v5(30.75,60.89) v5(31.22,74.53) v5(31.22,74.03) v5(31.22,73.53) v5(31.22,73.03) v5(31.27,66.91) v5(31.31,50.63) v5(31.27,37.69) v5(31.41,88.32) v5(31.41,60.89) v5(31.41,56.42) v5(31.64,31) v5(31.72,74.53) v5(31.72,74.03) v5(31.72,73.53) v5(31.72,73.03) v5(31.73,56) v5(31.73,55.35) v5(31.89,48.12) v5(32.05,56.42) v5(32.22,74.53) v5(32.22,74.03) v5(32.22,73.53) v5(32.22,73.03) v5(32.38,54.7) v5(32.71,61.6) v5(32.71,54.95) v5(32.81,49.01) v5(32.94,77.73) v5(32.91,31) v5(33.03,58.6) v5(33.03,54.7) v5(33.05,37.69) v5(33.34,58.91) v5(33.37,61.6) v5(33.47,60.23) v5(33.72,74.03) v5(33.68,59.25) v5(33.68,58.6) v5(33.68,57.95) v5(33.68,57.3) v5(33.68,54.7) v5(34,61.6) v5(34,56.96) v5(34.22,74.03) v5(34.22,73.53) v5(34.22,71.03) v5(34.18,31) v5(34.33,56) v5(34.33,55.35) v5(34.33,54.7) v5(34.37,48.99) v5(34.71,78.65) v5(34.71,68.28) v5(34.66,61.6) v5(34.66,56.35) v5(34.66,54.97) v5(34.83,37.69) v5(35.3,61.6) v5(35.3,60.89) v5(35.3,60.23) v5(35.3,57.54) v5(35.3,56.98) v5(35.3,56.35) v5(35.6,78.65) v5(35.86,49.49) v5(35.96,59.6) v5(36.01,57.72) v5(36.47,49.74) v5(36.62,59.6) v5(36.59,57.72) v5(36.64,48.68) v5(36.61,37.72) v5(36.72,55.03) v5(36.93,59.9) v5(37.1,60.89) v5(37.25,61.68) v5(37.41,76.16) v5(37.41,75.27) v5(37.41,73.49) v5(37.63,63.2) v5(37.77,48.69) v5(38.09,63.66) v5(38.09,49.77) v5(38.37,66.65) v5(38.42,40.73) v5(38.52,92.67) v5(38.59,47.33) v5(38.78,72.34) v5(39.97,92.69) v5(40.16,43.8) v5(40.84,68.16) v5(40.84,66.38) v5(40.84,64.6) v5(40.84,63.2) v5(40.84,62.32) v5(40.95,43.2) v5(40.94,42.63) v5(40.91,41.65) v5(40.91,41.04) v5(41.01,55.15) v5(41.24,92.69) v5(41.64,43.23) v5(41.62,42.52) v5(41.61,41.65) v5(41.6,41.06) v5(41.78,61.12) v5(41.83,60.61) v5(41.83,59.52) v5(41.8,58.76) v5(41.85,57.75) v5(42.11,55.39) v5(42.21,54.7) v5(42.33,65.36) v5(42.42,64.39) v5(42.45,42.52) v5(42.45,41.74) v5(42.42,41.06) v5(42.46,43.23) v5(42.68,82.04) v5(42.84,54.35) v5(42.84,53.58) v5(42.85,53.13) v5(42.97,59.01) v5(43.2,56.85) v5(43.27,41.04) v5(43.53,55.42) v5(43.45,54.34) v5(43.74,85.05) v5(44.03,58.34) v5(44.04,57.86) v5(44.04,54.35) v5(44.05,53.95) v5(44.05,53.11) v5(44.04,41.04) v5(44.11,60.21) v5(44.11,59.62) v5(44.06,53.53) v5(44.07,43.2) v5(44.06,42.49) v5(44.06,41.73) v5(44.49,85.94) v5(44.51,54.35) v5(44.51,53.95) v5(44.51,53.55) v5(44.51,53.12) v5(44.71,43.2) v5(44.87,88.94) v5(44.95,54.34) v5(44.95,53.96) v5(44.95,53.55) v5(44.95,53.12) v5(45.43,43.2) v5(45.77,85.86) v5(46.21,59.91) v5(46.18,29.85) v5(46.27,58.24) v5(46.27,57.86) v5(46.27,43.2) v5(46.45,40.98) v5(46.65,58.24) v5(46.65,57.86) v5(46.84,87.31) v5(47.07,43.2) v5(47.12,42.66) v5(47.12,41.89) v5(47.12,41.13) v5(47.65,41.58) v5(47.65,41.17) v5(47.67,41.96) v5(47.85,43.14) v5(47.85,42.68) v5(47.97,74.38) v5(47.97,73.36) v5(48.05,41.96) v5(48.08,41.55) v5(48.1,41.17) v5(48.48,42.22) v5(48.48,40.98) v5(48.61,42.68) v5(48.66,87.82) v5(48.8,29.89) v5(48.95,41.96) v5(48.92,41.58) v5(48.92,41.17) v5(48.99,43.2) v5(49.33,41.96) v5(49.33,41.17) v5(49.37,42.68) v5(49.35,41.55) v5(49.67,43.19) v5(49.8,42.24) v5(49.76,40.99) v5(50.14,41.58) v5(50.15,41.19) v5(50.17,41.97) v5(50.34,92.67) v5(50.41,53.63) v5(50.4,53.22) v5(50.39,52.82) v5(50.41,42.49) v5(50.55,41.98) v5(50.58,41.58) v5(50.6,41.19) v5(50.69,54.45) v5(50.84,81.49) v5(50.83,53.87) v5(50.82,53.49) v5(50.82,53.09) v5(51.08,54.44) v5(51.24,53.06) v5(51.27,53.89) v5(51.25,53.45) v5(51.4,92.69) v5(51.43,41.97) v5(51.4,41.59) v5(51.4,41.18) v5(51.43,29.93) v5(51.71,53.89) v5(51.71,53.45) v5(51.71,53.04) v5(51.81,41.97) v5(51.83,41.56) v5(51.86,41.18) v5(53,79.92) v5(53.5,43.53) v5(54.02,79.92) v5(55.03,79.92) v5(55.2,29.89) v5(55.58,94.01) v5(56.38,72.6) v5(58.09,95.6) v5(58.3,29.89) v5(59.36,95.6) v5(60.51,86.38) v5(60.63,95.6) v5(61.9,95.6) v5(62.2,91.12) v5(62.98,92.19) v5(63.15,85.43) v5(63.17,95.6) v5(63.24,44.73) v5(64.13,53.96) v5(64.44,95.6) v5(64.52,53.96) v5(65.71,95.6) v5(65.75,94.14) v5(66.13,91.17) v5(66.11,75.17) v5(66.27,74.25) v5(66.39,79.54) v5(66.4,73.19) v5(66.74,94.07) v5(66.98,95.6) v5(67.05,86.77) v5(67,55.76) v5(67,55.36) v5(68.01,55.81) v5(68.01,55.42) v5(68.25,95.6) v5(68.35,84.87) v5(68.59,82.92) v5(69.52,95.6) v5(70.71,57.35) v5(70.68,48.88) v5(70.68,48.5) v5(70.68,48.12) v5(70.68,47.74) v5(70.68,47.35) v5(70.68,46.97) v5(70.68,46.59) v5(70.79,95.6) v5(70.83,91.17) v5(70.89,86.73) v5(70.9,70.56) v5(71.07,48.88) v5(71.07,48.5) v5(71.07,48.12) v5(71.07,47.74) v5(71.07,47.35) v5(71.07,46.97) v5(71.07,46.59) v5(71.61,57.73) v5(72.06,95.6) v5(72.19,84.83) v5(72.5,57.73) v5(72.97,52.32) v5(73.33,95.6) v5(73.83,86.52) v5(73.84,52.93) v5(74.35,94.15) v5(74.34,49.51) v5(74.31,48.62) v5(74.6,95.6) v5(74.73,53.58) v5(75.13,84.62) v5(75.1,49.67) v5(75.21,89.2) v5(75.27,69.41) v5(75.62,94.15) v5(75.66,47.13) v5(75.79,48.95) v5(75.87,95.6) v5(75.99,49.67) v5(76.12,49.16) v5(76.5,48.98) v5(76.5,47.2) v5(76.57,94.41) v5(76.65,49.69) v5(76.97,49.01) v5(77.14,95.6) v5(77.7,79.88) v5(77.7,79.01) v5(77.87,54.06) v5(78,88.07) v5(78.41,95.6) v5(79.27,88.07) v5(79.6,60.06) v5(79.68,95.6) v5(80.17,60.47) v5(80.22,59.29) v5(80.15,29.63) v5(80.31,40.6) v5(80.5,92.75) v5(80.54,88.07) v5(80.84,60.9) v5(80.79,59.68) v5(80.83,58.51) v5(80.95,95.6) v5(81.44,60.12) v5(81.4,58.94) v5(81.42,29.63) v5(81.54,61.39) v5(81.58,84.91) v5(81.58,84.15) v5(81.58,83.38) v5(81.58,82.62) v5(81.79,63.99) v5(82.01,59.41) v5(82.14,64.24) v5(82.22,95.6) v5(82.24,60.64) v5(82.58,91.22) v5(82.71,59.95) v5(82.69,29.63) v5(82.85,84.91) v5(82.85,84.15) v5(82.85,83.38) v5(82.85,82.62) v5(83.49,95.6) v5(83.87,29.63) v5(84.12,84.91) v5(84.12,84.15) v5(84.12,83.38) v5(84.12,82.62) v5(84.12,81.86) v5(84.12,81.1) v5(84.6,50.1) v5(84.68,44.79) v5(84.66,44.23) v5(84.76,95.6) v5(85.14,29.63) v5(85.21,93.9) v5(85.21,92.63) v5(85.21,90.09) v5(85.39,84.91) v5(85.39,84.15) v5(85.39,83.38) v5(85.39,82.62) v5(85.39,81.86) v5(85.85,93.9) v5(85.85,92.63) v5(85.85,91.36) v5(85.85,90.09) v5(85.87,61.43) v5(86.03,95.6) v5(86.06,56.75) v5(86.15,64.33) v5(86.25,61.43) v5(86.41,29.63) v5(86.66,84.91) v5(86.66,84.15) v5(86.66,83.38) v5(86.66,82.62) v5(86.66,81.86) v5(87.3,95.6) v5(87.93,84.91) v5(87.93,84.15) v5(88.31,43.9) v5(88.31,43.52) v5(88.35,66.53) v5(88.57,95.6) v5(89.02,49.45) v5(89.2,84.91) v5(89.2,84.15) v5(89.32,87.99) v5(89.32,80.86) v5(89.57,67.06) v5(89.58,31.63) v5(89.84,95.6) v5(90.47,84.91) v5(90.47,84.15) v5(90.47,43.47) v5(90.47,31.63) v5(90.59,87.99) v5(90.59,80.86) v5(90.71,70.27) v5(91.11,95.6) v5(91.36,31.63) v5(91.55,46.28) v5(91.74,84.91) v5(91.74,84.15) v5(91.86,87.99) v5(91.86,80.86) v5(92.25,40.65) v5(92.38,95.6) v5(92.41,46.22) v5(92.83,84.91) v5(92.83,84.15) v5(93.13,87.99) v5(93.16,59.81) v5(93.34,80.86) v5(93.32,43.15) v5(94.03,29.63) v5(94.26,60.22) v5(94.4,87.99) v5(94.42,85.01) v5(94.42,84.25) v5(94.42,83.46) v5(94.42,82.7) v5(94.84,47.02) v5(94.86,45.47) v5(94.86,36.58) v5(94.86,35.31) v5(94.86,34.07) v5(94.89,33.11) v5(94.86,31.53) v5(94.86,30.26) v5(95.09,95.63) v5(95.12,95.11) v5(95.12,94.6) v5(95.12,94) v5(95.3,29.63) v5(95.51,85.01) v5(95.51,84.25) v5(95.51,83.46) v5(95.51,82.7) v5(95.78,47.86) v5(95.88,92.25) v5(95.88,90.98) v5(95.88,89.71) v5(96.36,95.63) v5(96.39,95.11) v5(96.39,94.6) v5(96.39,94) v5(96.51,92.25) v5(96.51,90.98) v5(96.51,89.71) v5(96.57,29.63) v5(97.05,47.86) v5(97.63,95.63) v5(97.66,95.11) v5(97.66,94.6) v5(97.66,94) v5(97.84,29.63) v5(98.04,92.25) v5(98.04,90.98) v5(98.04,89.71) v5(98.24,49.56) v5(98.25,37.52) v5(98.25,36.71) v5(98.25,35.91) v5(98.67,92.25) v5(98.67,90.98) v5(98.67,89.71) v5(98.69,49.56) v5(98.9,95.63) v5(98.93,95.11) v5(98.93,94.6) v5(98.93,94) v5(98.9,37.52) v5(99.01,31.2) v5(99.11,29.63) v5(99.43,49.56) v5(99.55,36.71) v5(99.89,49.56) v5(99.96,51.95) v5(100.07,92.25) v5(100.07,90.98) v5(100.07,89.71) v5(100.17,95.63) v5(100.2,95.11) v5(100.2,94.6) v5(100.2,94) v5(100.2,38.32) v5(100.2,37.52) v5(100.44,72.1) v5(100.42,51.95) v5(100.51,71.12) v5(100.7,92.25) v5(100.7,90.98) v5(100.7,89.71) v5(100.68,49.56) v5(100.67,31.2) v5(100.85,38.32) v5(100.85,37.52) v5(101.13,51.95) v5(101.13,49.56) v5(101.44,95.63) v5(101.47,95.11) v5(101.47,94.6) v5(101.47,94) v5(101.59,51.95) v5(101.66,72.1) v5(101.71,71.13) v5(101.86,86.63) v5(102.15,35.91) v5(102.31,88.08) v5(102.71,95.63) v5(102.73,95.11) v5(102.73,94.6) v5(102.73,94) v5(102.8,37.52) v5(102.93,72.19) v5(103.17,88.1) v5(103.45,42.32) v5(103.45,35.91) v5(103.54,83.12) v5(103.77,86.83) v5(103.77,85.94) v5(103.75,81.32) v5(103.98,95.63) v5(104,95.11) v5(104,94.6) v5(104,94) v5(104.1,40.72) v5(104.1,39.12) v5(104.1,37.52) v5(104.1,36.71) v5(104.75,43.92) v5(104.75,39.12) v5(104.75,38.32) v5(104.75,37.52) v5(105.25,95.63) v5(105.27,95.11) v5(105.27,94.6) v5(105.27,94) v5(105.31,84.17) v5(105.4,39.12) v5(105.4,38.32) v5(105.4,37.52) v5(106.05,40.72) v5(106.05,36.71) v5(106.52,95.63) v5(106.54,95.11) v5(106.54,94.6) v5(106.54,94) v5(106.7,39.12) v5(106.7,38.32) v5(106.7,36.71) v5(107.35,39.12) v5(107.35,38.32) v5(107.35,35.91) v5(107.36,28.09) v5(107.36,26.01) v5(107.48,75.74) v5(107.48,74.72) v5(107.62,52) v5(107.73,94) v5(107.79,95.63) v5(107.81,95.11) v5(107.81,94.6) v5(108.04,29.63) v5(108.44,75.76) v5(108.44,74.74) v5(109,94) v5(109.06,95.63) v5(109.08,95.11) v5(109.08,94.6) v5(109.2,75.76) v5(109.2,74.74) v5(109.31,29.63) v5(109.64,85.73) v5(110.11,94.01) v5(110.16,95.64) v5(110.19,95.12) v5(110.19,94.61) v5(110.2,53.3) v5(110.2,52.28) v5(110.15,42.55) v5(110.58,29.63) v5(111.43,95.64) v5(111.38,94.01) v5(111.46,95.12) v5(111.46,94.61) v5(111.85,29.63) v5(112.44,28.09) v5(112.44,26.01) v5(113.12,29.63) v5(114.08,95.65) v5(114.98,86.72) v5(115.12,43.92) v5(115.32,95.49) v5(115.5,80.86) v5(115.66,29.63) v5(115.83,77.11) v5(115.83,75.75) v5(115.97,81.32) v5(116.42,43.92) v5(116.51,95.51) v5(117.39,86.78) v5(117.52,28.09) v5(117.52,26.01) v5(117.75,95.61) v5(117.9,88.68) v5(117.92,81.32) v5(117.92,58.7) v5(118.37,43.92) v5(118.47,77.36) v5(118.59,80.35) v5(118.59,79.33) v5(119,95.65) v5(119.02,35.91) v5(119.49,78.67) v5(119.67,37.52) v5(119.67,36.71) v5(120.31,95.68) v5(120.32,43.92) v5(120.32,37.52) v5(120.5,77.36) v5(120.57,86.78) v5(121.07,79.33) v5(121.58,95.67) v5(121.58,86.78) v5(121.62,43.92) v5(122.6,28.09) v5(122.6,26.01) v5(122.89,95.65) v5(123.28,29.63) v5(123.49,86.78) v5(123.76,65.54) v5(124.17,95.64) v5(124.55,29.63) v5(125.13,77.3) v5(125.33,95.64) v5(125.82,29.63) v5(125.9,36.32) v5(126.03,80.35) v5(126.25,95.16) v5(126.26,94.6) v5(126.26,94) v5(126.54,36.32) v5(126.61,38.19) v5(126.61,37.17) v5(127.09,29.63) v5(127.41,65.54) v5(127.52,95.16) v5(127.53,94.6) v5(127.53,94) v5(127.68,28.09) v5(127.68,26.01) v5(128.36,29.63) v5(128.67,84.84) v5(128.79,95.16) v5(128.8,94.6) v5(128.8,94) v5(128.76,35.77) v5(128.76,34.5) v5(129.13,83.35) v5(129.18,84.31) v5(129.63,29.63) v5(129.84,92.31) v5(129.84,89.59) v5(130.01,83.91) v5(130.06,95.16) v5(130.07,94.6) v5(130.07,94) v5(130.65,83.88) v5(130.9,29.63) v5(131.16,87.66) v5(131.23,87.08) v5(131.23,83.91) v5(131.33,95.16) v5(131.34,94.6) v5(131.34,94) v5(131.79,83.91) v5(131.88,43.92) v5(131.88,39.12) v5(131.88,38.32) v5(131.88,37.52) v5(131.88,36.71) v5(131.88,35.91) v5(132.17,29.63) v5(132.28,87.74) v5(132.38,86.83) v5(132.53,81.64) v5(132.53,39.12) v5(132.53,38.32) v5(132.53,37.52) v5(132.6,95.16) v5(132.61,94.6) v5(132.61,94) v5(132.76,86.47) v5(132.76,28.09) v5(132.76,26.01) v5(133.22,87.79) v5(133.22,78.98) v5(133.18,43.92) v5(133.18,40.72) v5(133.18,36.71) v5(133.4,95.18) v5(133.41,94.69) v5(133.6,86.42) v5(133.82,86.93) v5(133.77,80.6) v5(133.83,38.32) v5(133.83,37.52) v5(134.03,82.18) v5(134.2,95.2) v5(134.49,79) v5(134.48,43.92) v5(134.48,38.32) v5(134.48,37.52) v5(135.13,41.52) v5(135.13,40.72) v5(135.21,95.23) v5(135.23,94.72) v5(135.78,42.32) v5(135.78,35.91) v5(135.94,80.35) v5(135.94,79.33) v5(136.36,95.22) v5(136.37,94.71) v5(136.43,43.92) v5(136.43,37.52) v5(137.08,42.32) v5(137.08,35.91) v5(137.34,95.18) v5(137.36,94.67) v5(137.36,94.08) v5(137.73,41.52) v5(137.73,40.72) v5(137.73,39.12) v5(137.73,37.52) v5(137.73,36.71) v5(137.84,28.09) v5(137.84,26.01) v5(138.27,86.34) v5(138.42,79.87) v5(138.38,43.92) v5(138.38,39.12) v5(138.38,38.32) v5(138.38,37.52) v5(138.61,95.18) v5(138.63,94.67) v5(138.63,94.08) v5(139.03,39.12) v5(139.03,38.32) v5(139.03,37.52) v5(139.6,95.18) v5(139.62,94.67) v5(139.62,94.08) v5(139.68,43.92) v5(139.68,40.72) v5(139.76,77.95) v5(140.18,47.88) v5(140.33,39.12) v5(140.33,38.32) v5(140.53,84.84) v5(140.71,85.78) v5(140.67,77.95) v5(140.87,95.18) v5(140.89,94.67) v5(140.89,94.08) v5(140.9,79.33) v5(140.98,39.12) v5(140.98,38.32) v5(140.99,29.63) v5(141.14,86.32) v5(141.24,85.76) v5(141.45,47.88) v5(141.5,84.84) v5(141.83,85.33) v5(142.14,95.18) v5(142.16,94.67) v5(142.16,94.08) v5(142.26,29.63) v5(142.38,86.6) v5(142.66,92.8) v5(142.74,85.38) v5(142.72,47.88) v5(142.79,90) v5(142.92,26.01) v5(142.95,77.56) v5(143.1,87.13) v5(143.32,27.85) v5(143.41,95.18) v5(143.43,94.67) v5(143.43,94.08) v5(143.53,29.63) v5(143.63,87.13) v5(143.55,39.4) v5(143.68,42.81) v5(143.85,66.2) v5(143.98,49.92) v5(143.99,47.88) v5(144.06,85.68) v5(144.11,73.37) v5(144.11,72.53) v5(144.38,83.06) v5(144.54,87.13) v5(144.57,41.69) v5(144.68,95.18) v5(144.7,94.67) v5(144.7,94.08) v5(144.7,39.4) v5(144.8,29.63) v5(144.87,77.56) v5(145.13,83.02) v5(145.15,87.13) v5(145.2,84.06) v5(145.26,47.88) v5(145.41,69.18) v5(145.56,48.98) v5(145.71,86.19) v5(145.7,63.38) v5(145.76,84.03) v5(145.95,95.18) v5(145.97,94.67) v5(145.97,94.08) v5(146.04,83.17) v5(146.07,29.63) v5(146.17,85.78) v5(146.16,78.6) v5(146.16,76.65) v5(146.53,47.88) v5(146.6,49.97) v5(146.96,85.18) v5(147.05,67.09) v5(147.05,68.77) v5(147.24,94.7) v5(147.34,29.63) v5(147.4,43.92) v5(147.4,39.12) v5(147.4,38.32) v5(147.4,37.52) v5(147.4,36.71) v5(147.4,35.91) v5(147.53,63.44) v5(147.8,47.88) v5(147.92,50.3) v5(148.05,39.12) v5(148.05,38.32) v5(148.05,37.52) v5(148.12,84.95) v5(148.15,86.52) v5(148.36,78.26) v5(148.63,86.52) v5(148.61,29.63) v5(148.7,43.92) v5(148.7,36.71) v5(148.81,50.3) v5(148.86,84.87) v5(148.85,69.08) v5(149.35,39.12) v5(149.35,38.32) v5(149.35,37.52) v5(149.7,50.3) v5(149.82,78.6) v5(149.82,63.11) v5(149.88,87) v5(149.87,65.67) v5(150.03,85.56) v5(150,43.92) v5(150,39.12) v5(150,38.32) v5(150,37.52) v5(150.13,79.37) v5(150.3,61.45) v5(150.39,31.94) v5(150.54,87.08) v5(150.57,60.49) v5(150.65,39.12) v5(150.73,63.76) v5(150.81,80.35) v5(150.81,79.33) v5(150.94,85.12) v5(151.05,86.24) v5(151.3,35.91) v5(151.47,50.3) v5(151.64,63.11) v5(151.95,37.52) v5(152.01,86.03) v5(152.1,70.14) v5(152.36,50.3) v5(152.56,77.3) v5(152.6,42.32) v5(152.6,35.91) v5(152.83,80.32) v5(153.33,85.43) v5(153.4,71.21) v5(153.4,66.94) v5(153.47,77.3) v5(153.47,63.11) v5(153.9,43.92) v5(154.01,60.46) v5(154.18,75.82) v5(154.18,67.87) v5(154.18,65.22) v5(154.67,62.39) v5(155.11,95.08) v5(155.16,78.48) v5(155.16,67.87) v5(155.2,43.92) v5(155.81,78.48) v5(155.94,27.91) v5(156.31,29.63) v5(157.58,29.63) v5(158.55,28.01) v5(158.85,29.63) v5(159.15,35.67) v5(159.15,33.56) v5(159.15,31.77) v5(159.17,45.37) v5(159.16,43.27) v5(160.13,47.88) v5(160.12,29.63) v5(160.57,46.8) v5(160.57,45.42) v5(160.57,44.15) v5(160.57,33.99) v5(160.57,32.72) v5(160.56,31.14) v5(160.57,30.18) v5(161.21,95.08) v5(162.14,62.73) v5(162.14,61.68) v5(162.14,60.66) v5(162.14,59.65) v5(162.17,45.59) v5(162.35,91.27) v5(162.59,42.15) v5(162.73,54.52) v5(162.95,43.8) v5(163.01,48.41) v5(163.44,44.56) v5(163.94,58.63) v5(163.94,57.74) v5(163.87,56.65) v5(163.87,55.76) v5(164.18,92.41) v5(164.58,54.82) v5(164.57,48.52) v5(165.08,37.18) v5(165.58,43.75) v5(165.58,40.25) v5(165.68,38.25) v5(165.91,61.67) v5(166.03,95.08) v5(166.34,36.99) v5(166.36,51.67) v5(166.49,49.69) v5(166.5,49.11) v5(166.75,71.88) v5(167.44,61.46) v5(168.31,38.08) v5(168.31,37.13) v5(168.31,36.24) v5(168.72,35.34) v5(168.73,33.55) v5(169.02,31.84) v5(169.09,64.04) v5(169.18,76.67) v5(169.33,90.76) v5(169.38,44.55) v5(169.46,52.1) v5(169.71,46.99) v5(169.87,63.07) v5(169.89,61.08) v5(170.02,83.73) v5(170.42,31.55) v5(170.48,91.53) v5(170.5,48.15) v5(170.49,37.83) v5(170.68,40.25) v5(171.49,92.29) v5(171.47,36.88) v5(171.67,74.73) v5(171.67,65.27) v5(172,49.89) v5(172.04,49.13) v5(172.75,34.92) v5(173.4,37.51) v5(173.54,42.63) v5(173.99,52.03) v5(173.99,45.43) v5(174.15,81.55) v5(174.25,34.92) v5(174.29,37.51) v5(175.09,76.95) v5(175.25,34.92) v5(175.69,79.16) v5(175.94,37.5) v5(177.44,77.72) v5(178.25,34.92) v5(178.52,59.49) v5(178.48,38.21) v5(181.04,46.34) v5(181.25,34.92) v5(181.63,46.34) v5(181.7,43.47) v5(181.75,34.92) v5(182.59,45.86) v5(182.69,36.2) v5(183.18,45.86) v5(183.25,43.72) v5(183.3,42.43) v5(183.71,36.23) v5(184.73,43.75) v5(185.18,49.36) v5(185.22,37.61) v5(185.62,40.85) v5(185.79,49.34) v5(186.12,37.61) v5(186.63,43.75) v5(186.96,37.96) v5(187,31.25) v5(187.22,41.44) v5(187.85,35.34) v5(188.31,47.43) v5(188.26,43.75) v5(188.99,47.46) v5(189.75,34.92) v5(189.88,43.72) v5(190.24,41.46) v5(190.25,34.92) v5(191.48,43.7) v5(192.04,41.41) v5(192.04,38.44) v5(192.77,44.17) v5(193.51,41.7) v5(197.25,34.92) v5(198.93,47) v5(201.67,47.02) v5(202.72,36.42) v5(203.47,45.59) v5(204,31.25) v5(205.85,32.14) v5(206.35,41.5) v5(209.6,43.45) v5(211.02,35.09) v5(212.06,35.09) v5(212.54,37.02) v5(212.54,33.76) v5(213.07,35.09) v5(214,32.14) v5(214.12,35.09) v5(215.1,35.09) v5(215.36,33.94) v5(215.56,45.93) v5(216.15,35.09) v5(217.09,35.77) v5(217.09,34.76) v5(217.25,38.55) v5(217.75,38.55) v5(218.25,46.34) v5(218.5,43.45) v5(218.75,38.55) v5(218.84,46.31) v5(219.25,38.55) v5(219.54,33.14) v5(219.75,38.55) v5(221.15,44.66) v5(221.35,46.21) v5(222.32,46.24) v5(222.29,44.54) v5(222.93,45.6) v5(223.51,44.54) v5(223.75,38.55) v5(223.96,45.04) v5(224.37,34.71) v5(224.63,78.93) v5(224.81,33.94) v5(225.09,75.46) v5(225.29,91.53) v5(225.29,90.89) v5(225.32,89.98) v5(225.32,89.29) v5(225.32,88.71) v5(225.32,88.02) v5(225.32,87.44) v5(225.32,86.75) v5(225.32,86.17) v5(225.32,85.48) v5(225.32,84.9) v5(225.32,84.21) v5(225.32,83.63) v5(225.32,82.94) v5(225.32,82.36) v5(225.32,81.67) v5(225.32,81.09) v5(225.32,80.4) v5(225.32,79.82) v5(225.32,79.13) v5(225.34,77.12) v5(225.34,76.44) v5(225.34,75.85) v5(225.34,74.58) v5(225.34,73.9) v5(225.34,73.31) v5(225.34,72.63) v5(225.34,72.04) v5(225.34,71.36) v5(225.34,70.77) v5(225.34,70.09) v5(225.34,69.5) v5(225.34,68.82) v5(225.34,68.23) v5(225.34,67.55) v5(225.34,66.96) v5(225.44,33.95) v5(225.95,34.73) v5(226.41,64.19) v5(226.56,91.58) v5(226.56,90.89) v5(226.59,89.98) v5(226.59,89.29) v5(226.59,88.71) v5(226.59,88.02) v5(226.59,87.44) v5(226.59,86.75) v5(226.59,86.17) v5(226.59,85.48) v5(226.59,84.9) v5(226.59,84.21) v5(226.59,83.63) v5(226.59,82.94) v5(226.59,82.36) v5(226.59,81.67) v5(226.59,81.09) v5(226.59,80.4) v5(226.59,79.82) v5(226.59,77.86) v5(226.61,77.12) v5(226.61,76.44) v5(226.61,75.85) v5(226.61,75.17) v5(226.61,74.58) v5(226.61,73.9) v5(226.61,73.31) v5(226.61,72.63) v5(226.61,72.04) v5(226.61,71.36) v5(226.61,70.77) v5(226.61,70.09) v5(226.61,69.5) v5(226.61,68.82) v5(226.61,68.23) v5(226.61,67.55) v5(226.61,66.96) v5(226.56,42.42) v5(226.92,64.17) v5(226.86,62.57) v5(226.86,30.7) v5(226.99,78.72) v5(227.25,81.37) v5(227.37,78.44) v5(227.41,42.49) v5(227.53,64.14) v5(227.65,55.33) v5(227.93,80.55) v5(227.87,36.63) v5(228.06,87.31) v5(228.06,86.78) v5(228.27,42.55) v5(228.25,38.55) v5(228.39,73.24) v5(228.52,73.95) v5(228.52,57.87) v5(228.62,79.54) v5(228.72,81.11) v5(228.74,72.65) v5(228.66,36.65) v5(228.8,64.35) v5(229.02,77.76) v5(229.23,55.12) v5(229.28,64.32) v5(229.41,26.5) v5(229.63,57.77) v5(229.85,36.64) v5(229.91,30.04) v5(230.14,80.65) v5(230.14,77.65) v5(230.14,74.65) v5(230.65,41.5) v5(230.7,40.22) v5(230.8,27.71) v5(231.23,50.3) v5(231.67,51.16) v5(232.05,54.52) v5(232.07,34.97) v5(232.17,51.77) v5(234.87,46.31) v5(234.96,38.77) v5(235.12,47.41) v5(236.16,47.91) v5(236.19,46.9) v5(236.34,53.77) v5(236.35,54.76) v5(236.38,52.59) v5(236.64,46.44) v5(236.66,55.67) v5(237.01,51.86) v5(237.23,56.18) v5(237.41,47.84) v5(237.41,46.82) v5(237.53,48.73) v5(238.03,51.85) v5(238.29,48.73) v5(238.36,56.19) v5(238.42,47.84) v5(238.51,62.89) v5(238.68,46.82) v5(238.93,54.35) v5(239.18,44.56) v5(239.21,44.13) v5(239.31,46.82) v5(239.29,45.88) v5(239.29,45.5) v5(239.4,53.96) v5(239.36,53.12) v5(239.36,52.54) v5(239.53,27.15) v5(239.6,56.19) v5(239.69,54.29) v5(240.53,29.8) v5(240.84,56.15) v5(240.85,54.65) v5(240.85,50.65) v5(240.85,49.15) v5(240.85,48.15) v5(240.85,46.65) v5(240.85,45.15) v5(240.85,43.65) v5(240.85,40.65) v5(240.85,39.15) v5(240.85,37.65) v5(244.25,32.89) v5(246.03,27.15) v5(249.22,34.25) v5(249.22,33.36) v5(250.99,34.28) v5(251.25,33.38) v5(253.53,34.25) v5(253.53,33.38) v5(255.57,85.96) v5(255.57,84.69) v5(255.57,83.42) v5(255.57,82.15) v5(255.57,80.88) v5(256.33,34.88) v5(256.33,33.99) v5(257.47,85.96) v5(257.47,84.69) v5(257.47,82.15) v5(257.47,80.88) v5(259,34.88) v5(259.76,85.84) v5(259.76,84.57) v5(259.76,82.03) v5(260.39,26.88) v5(261.79,29.32) v5(261.79,28.18) v5(261.79,26.91) v5(261.92,85.84) v5(261.92,84.57) v5(261.92,83.3) v5(262.93,29.93) v5(263.61,63.22) v5(263.95,29.32) v5(263.95,28.18) v5(263.95,26.91) v5(264.08,85.96) v5(264.08,84.69) v5(264.08,83.42) v5(264.08,82.15) v5(264.97,28.15) v5(264.97,26.91) v5(266.36,83.42) v5(266.36,82.15) v5(267.5,72.86) v5(268.27,85.96) v5(268.27,83.42) v5(268.27,82.15) v5(268.77,73.11) v5(273.65,69) v5(273.68,68.31) v5(274.08,58.66) v5(274.11,58.05) v5(274.49,72.88) v5(274.49,71.61) v5(274.49,70.34) v5(274.49,69.07) v5(274.49,66.53) v5(274.49,60.94) v5(274.49,59.67) v5(274.49,57.13) v5(274.49,55.86) v5(274.49,54.59) v5(276.01,65.54) v5(276.27,63.84) v5(276.65,65.52) v5(276.65,60.94) v5(276.65,59.67) v5(276.65,58.4) v5(276.65,57.13) v5(276.65,55.86) v5(276.65,54.59) v5(276.78,72.88) v5(276.78,71.61) v5(276.78,70.34) v5(276.78,69.07) v5(276.78,67.8) v5(276.78,66.53) v5(278.94,72.88) v5(278.94,71.61) v5(278.94,70.34) v5(278.94,69.07) v5(278.94,67.8) v5(278.94,66.53) v5(280.97,72.75) v5(280.97,71.48) v5(280.97,70.21) v5(280.97,68.94) v5(280.97,67.67) v5(280.97,66.4) v5(281.95,11.88) v5(282.72,70.49) v5(282.72,69.02) v5(282.9,71.51) v5(283.46,71.51) v5(283.74,70.82) v5(283.74,70.06) v5(283.76,69.3) v5(283.76,68.64) v5(284.02,58.58) v5(285.41,75.8) v5(285.41,74.53) v5(285.41,73.26) v5(285.41,64.37) v5(285.41,63.1) v5(286.94,25.23) v5(286.87,9.03) v5(298.8,23.05) v6(28.81,37.36) v6(35.1,35.96) v6(43.45,53.69) v6(44.35,30.5) v6(59.92,76.81) v6(63.06,61.31) v6(64.13,30.69) v6(65.51,33.14) v6(78.27,69.39) v6(80.5,83.71) v6(84.94,94.51) v6(85.95,84.69) v6(88.65,67.43) v6(91.13,84.74) v6(93.44,76.31) v6(99.27,91.55) v6(102.54,50.53) v6(106.28,76.83) v6(115.79,65.05) v6(155.9,94.84) v6(176.8,25.66) v6(214.65,33.54) v6(279.7,72.14)
