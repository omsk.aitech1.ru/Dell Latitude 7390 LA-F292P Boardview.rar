# Allegro board LAF292PR10-1114.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L05ESDL5V0NA-4_SLP2510P8-10-9
  rect 0.203x0.686 smd: 1(0,0) 2(-0.5,0) 4(-1.5,0) 5(-2,0) 6(-2,-0.875) 7(-1.5,-0.875) 8(-0.5,-0.875) 9(0,-0.875)
  rect 0.406x1.549 smd: 3(-1,-0.437)
L30ESD24VC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_7X7X2P4_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
LM393DGKR_VSSOP8
  oval 1.575x0.381 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(4.35,-1.95) 6(4.35,-1.3) 7(4.35,-0.65) 8(4.35,0)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LOTES_APCI0241-P001A_75P-T
  round 1.092 hole 1.092 unplated: (-1.75,-1.7)
  round 1.6 hole 1.6 unplated: (20.25,-1.7)
  oval 0.305x1.499 smd: 1(0,0) 3(0.5,0) 5(1,0) 7(1.5,0) 17(4,0) 19(4.5,0) 21(5,0) 23(5.5,0) 25(6,0) 27(6.5,0) 29(7,0) 31(7.5,0) 33(8,0) 35(8.5,0) 37(9,0) 39(9.5,0) 41(10,0) 43(10.5,0) 45(11,0) 47(11.5,0) 49(12,0) 51(12.5,0) 53(13,0) 55(13.5,0) 57(14,0) 59(14.5,0) 61(15,0) 63(15.5,0) 65(16,0) 67(16.5,0) 69(17,0) 71(17.5,0) 73(18,0) 75(18.5,0)
  round 0.762 hole 0.508: 2(0.25,-2.59) 4(0.75,-1.79) 6(1.25,-2.59) 16(3.75,-1.79) 18(4.25,-2.59) 20(4.75,-1.79) 22(5.25,-2.59) 24(5.75,-1.79) 26(6.25,-2.59) 28(6.75,-1.79) 30(7.25,-2.59) 32(7.75,-1.79) 34(8.25,-2.59) 36(8.75,-1.79) 38(9.25,-2.59) 40(9.75,-1.79) 42(10.25,-2.59) 44(10.75,-1.79) 46(11.25,-2.59) 48(11.75,-1.79) 50(12.25,-2.59) 52(12.75,-1.79) 54(13.25,-2.59) 56(13.75,-1.79) 58(14.25,-2.59) 60(14.75,-1.79) 62(15.25,-2.59) 64(15.75,-1.79) 66(16.25,-2.59) 68(16.75,-1.79) 70(17.25,-2.59) 72(17.75,-1.79) 74(18.25,-2.59)
  oval 0.889x2.159 hole 0.508x1.753: 76(-2,-5.75) 77(20.5,-5.75)
LOTES_APCI0242-P001A_75P-T
  round 1.092 hole 1.092 unplated: (-1.75,-1.7)
  round 1.6 hole 1.6 unplated: (20.25,-1.7)
  oval 0.305x1.499 smd: 1(0,0) 3(0.5,0) 5(1,0) 7(1.5,0) 9(2,0) 11(2.5,0) 21(5,0) 23(5.5,0) 25(6,0) 27(6.5,0) 29(7,0) 31(7.5,0) 33(8,0) 35(8.5,0) 37(9,0) 39(9.5,0) 41(10,0) 43(10.5,0) 45(11,0) 47(11.5,0) 49(12,0) 51(12.5,0) 53(13,0) 55(13.5,0) 57(14,0) 59(14.5,0) 61(15,0) 63(15.5,0) 65(16,0) 67(16.5,0) 69(17,0) 71(17.5,0) 73(18,0) 75(18.5,0)
  round 0.762 hole 0.508: 2(0.25,-2.59) 4(0.75,-1.79) 6(1.25,-2.59) 8(1.75,-1.79) 10(2.25,-2.59) 20(4.75,-1.79) 22(5.25,-2.59) 24(5.75,-1.79) 26(6.25,-2.59) 28(6.75,-1.79) 30(7.25,-2.59) 32(7.75,-1.79) 34(8.25,-2.59) 36(8.75,-1.79) 38(9.25,-2.59) 40(9.75,-1.79) 42(10.25,-2.59) 44(10.75,-1.79) 46(11.25,-2.59) 48(11.75,-1.79) 50(12.25,-2.59) 52(12.75,-1.79) 54(13.25,-2.59) 56(13.75,-1.79) 58(14.25,-2.59) 60(14.75,-1.79) 62(15.25,-2.59) 64(15.75,-1.79) 66(16.25,-2.59) 68(16.75,-1.79) 70(17.25,-2.59) 72(17.75,-1.79) 74(18.25,-2.59)
  oval 0.889x2.159 hole 0.508x1.753: 76(-2,-5.75) 77(20.5,-5.75)
LOTES_YPCI0016-P003A_75P
  round 1.092 hole 1.092 unplated: (-1.75,-1.55)
  round 1.6 hole 1.6 unplated: (20.25,-1.55)
  oval 0.305x1.499 smd: 1(0,0) 3(0.5,0) 5(1,0) 7(1.5,0) 9(2,0) 11(2.5,0) 13(3,0) 15(3.5,0) 17(4,0) 19(4.5,0) 21(5,0) 23(5.5,0) 25(6,0) 27(6.5,0) 29(7,0) 31(7.5,0) 33(8,0) 35(8.5,0) 37(9,0) 39(9.5,0) 41(10,0) 43(10.5,0) 45(11,0) 47(11.5,0) 49(12,0) 51(12.5,0) 53(13,0) 55(13.5,0) 57(14,0) 67(16.5,0) 69(17,0) 71(17.5,0) 73(18,0) 75(18.5,0)
  round 0.762 hole 0.508: 2(0.25,-2.85) 4(0.75,-2.05) 6(1.25,-2.85) 8(1.75,-2.05) 10(2.25,-2.85) 12(2.75,-2.05) 14(3.25,-2.85) 16(3.75,-2.05) 18(4.25,-2.85) 20(4.75,-2.05) 22(5.25,-2.85) 24(5.75,-2.05) 26(6.25,-2.85) 28(6.75,-2.05) 30(7.25,-2.85) 32(7.75,-2.05) 34(8.25,-2.85) 36(8.75,-2.05) 38(9.25,-2.85) 40(9.75,-2.05) 42(10.25,-2.85) 44(10.75,-2.05) 46(11.25,-2.85) 48(11.75,-2.05) 50(12.25,-2.85) 52(12.75,-2.05) 54(13.25,-2.85) 56(13.75,-2.05) 58(14.25,-2.85) 68(16.75,-2.05) 70(17.25,-2.85) 72(17.75,-2.05) 74(18.25,-2.85)
  rect 1.194x2.743 smd: 76(-2.135,-6.52) 77(20.635,-6.52)
LP2301ALT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MAG_MLV-FY12N1R0M-O1L_2P
  rect 0.889x2.489 smd: 1(0,0) 2(2.6,0)
MAG_MMD05CZR47M_4P
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
MAG_MND-04ABIR60M-XGL_2P
  rect 1.448x3.708 smd: 1(0,0) 2(2.845,0)
MEC5105_WFBGA_169P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B6(4,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C6(4,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D6(4,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E6(4,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F6(4,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G6(4,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H6(4,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J6(4,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K6(4,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L6(4,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M6(4,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N6(4,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601)
MMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15BB221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15GA750SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX600SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_LQG15HS4N3S02D_2P
  rect 0.533x0.559 smd: 1(0,0) 2(0.925,0)
MURAT_LQG15HS15NJ02D_2P
  rect 0.559x0.508 smd: 1(0,0) 2(0.95,0)
MURAT_LQM18NN1R0K00D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
NCP302045MNTWG_PQFN33_5X5
  oval 0.305x0.711 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  custom 0.32x0.32 smd: 9(3.135,1.266)
  custom 0.543x0.543 smd: 10(2.225,3.266)
  rect 3.81x0.711 smd: 11(1.75,4.902)
  rect 0.711x1.295 smd: 12(-0.701,3.701)
  oval 0.711x0.305 smd: 13(-0.701,2.701) 14(-0.701,2.201) 15(-0.701,1.701) 16(-0.701,1.201) 17(-0.701,0.701)
  rect 1.422x1.118 smd: 18(0.7,1.266)
  rect 0.584x0.356 smd: 19(0.09,2.676)
NPCT650JB2YX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
NTR4502PT1G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PANAS_EXC24CQ900U_4P
  rect 0.356x0.559 smd: 1(0,0) 2(0,-1.25) 3(-0.6,-1.25) 4(-0.6,0)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
R0201_0OHM
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8097ALGE_SOT23-6
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0.95,2.6) 6(0,2.6)
RTS5330-GR_QFN32_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 17(4.1,-2.8) 18(4.1,-2.4) 19(4.1,-2) 20(4.1,-1.6) 21(4.1,-1.2) 22(4.1,-0.8) 23(4.1,-0.4) 24(4.1,0)
  oval 0.203x0.889 smd: 9(0.65,-3.45) 10(1.05,-3.45) 11(1.45,-3.45) 12(1.85,-3.45) 13(2.25,-3.45) 14(2.65,-3.45) 15(3.05,-3.45) 16(3.45,-3.45) 25(3.45,0.65) 26(3.05,0.65) 27(2.65,0.65) 28(2.25,0.65) 29(1.85,0.65) 30(1.45,0.65) 31(1.05,0.65) 32(0.65,0.65)
  rect 2.692x2.692 smd: 33(2.05,-1.4)
SANTA_375230-1_9P-T
  round 1.067 hole 0.711: 1(0,0) 2(-2,0) 3(-4,0) 4(-6,0) 5(-7,0.8) 6(-5,0.8) 7(-3,0.8) 8(-1,0.8) 9(1,0.8)
  oval 1.194x2.21 hole 0.61x1.6: 10(-10.85,-4.9) 11(-10.85,-8.85) 12(4.85,-8.85) 13(4.85,-4.9)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI2303CDS-T1-GE3_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
SINGA_2SJ3095-085111F_6P
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(-9.5,5.5) 3(0,5.2) 4(0,7.8) 5(-9.5,0) 6(-9.5,2.75) 7(0,2.65)
SLGC55544CVTR_TQFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.702x1.702 smd: 17(0.75,1.55)
SMF22A-SOD123FL-2-S
  rect 1.295x1.397 smd: 1(0,0) 2(2.9,0)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SOLDER_PREFORMS_0603
  rect 1.118x1.397 smd: 1(0,0) 2(1.422,0)
SW_SKRBAAE010_4P
  rect 0.889x1.219 smd: 1(0,0) 2(3.9,0) 3(0,4.075) 4(3.9,4.075)
SW_SSAL120100_3P
  rect 0.787x0.787 smd: 1(0,0) 3(3.4,0)
  rect 1.194x0.787 smd: 2(1.7,0)
  rect 1.041x0.889 smd: 4(-2.375,-1.6) 5(5.775,-1.6)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8210AQVC_QFN19_4X3
  oval 0.787x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 6(0,-2.25) 7(0,-2.7) 8(0,-3.15) 12(2.8,-3.15) 13(2.8,-2.7) 14(2.8,-2.25) 15(2.8,-1.8) 16(2.8,-1.35) 17(2.8,-0.9) 18(2.8,-0.45) 19(2.8,0)
  rect 0.94x2.108 smd: 9(1.07,-0.43)
  rect 0.406x2.108 smd: 10(2,-0.43)
  rect 1.295x2.007 smd: 11(1.25,-2.78)
SY8288BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288CRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288RAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
T-SOL_158-1240902600_23P-T
  round 0.787 hole 0.787 unplated: (2.4,-0.45) (3.4,-11.65)
  oval 0.61x1.295 smd: 1(0,0) 2(-0.9,0) 3(-1.8,0) 4(-2.7,0) 5(-3.6,0) 6(-4.5,0) 7(-5.4,0) 8(-6.3,0)
  oval 0.711x1.295 smd: 9(-7.9,0)
  oval 1.092x1.905 hole 0.508x1.194: 10(-9.4,-0.45) 11(4.2,-0.45) 12(4.2,-13.25) 13(-9.4,-10.05)
  rect 1.092x1.194 smd: 14(0.71,-12.95)
  oval 0.61x1.194 smd: 15(-0.54,-12.95) 16(-1.45,-12.95) 17(-2.36,-12.95) 18(-3.27,-12.95) 19(-4.18,-12.95) 20(-5.09,-12.95) 21(-6,-12.95) 22(-6.91,-12.95) 23(-7.82,-12.95)
TAI-T_HCB2012KF-121T50_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TAIYO_MCF12102G900-T_4P-NPM
  rect 0.508x0.305 smd: 1(0,0) 2(0,-0.55) 3(1.25,-0.55) 4(1.25,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TCS40DLR_SOT23F3
  oval 0.787x0.889 smd: 1(0,0) 2(0.95,2.1) 3(-0.95,2.1)
TPC12
  round 0.305 smd: 1(0,0)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TPS62134ARGT_QFN16_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.702x1.702 smd: 17(1.55,-0.75)
TPS62134CRGT_QFN16_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  oval 0.254x0.889 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.702x1.702 smd: 17(1.55,-0.75)
TPS65982_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
TS5A3159ADCKR_SC70-6
  oval 0.381x1.372 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0.65,1.74) 6(0,1.74)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q128FVSIQ_SO8-NPM
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_7V25000034_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.8) 4(0,1.8)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G024000DC1H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)

## Nets
0.6V_DDR_VTT_ON: PR210.1 RD83.1 UD5.4
1.8V_OUT: PC515.1 PC516.1 PJP506.1 PR515.1 PU503.1
1.8V_PRIM_PWRGD: PR517.1 PU501.5 UE1.L7
3.3V_ALS_EN#: JSEN2.8 RE521.2
3.3V_ALW2: RE57.1 RE58.1 UE1.B1
3.3V_CAM_EN#: RC311.1 RZ380.1 UC1.AT15
3.3V_TS_EN: RE557.1 RV323.1 UE1.J7
3.3V_WWAN_EN: RZ40.2 UE1.C6 UZ4.5
3V5V_EN: PC128.1 PR114.2 PR116.1 PU100.12 PU102.12
3V_FB: PC113.1 PU100.13
3V_SN: PC112.1 PR106.2
3V_VIN: PC100.1 PC103.1 PC104.1 PC105.1 PC131.1 PJP100.2 PU100.2 PU100.3 PU100.4 PU100.5
5V_FB: PC127.1 PU102.13
5V_SN: PC125.1 PR112.2
5V_VIN: PC115.1 PC116.1 PC117.1 PC118.1 PC132.1 PJP101.2 PU102.2 PU102.3 PU102.4 PU102.5
+0.6V_DDR_VTT: CD55.1 CD56.1 CD57.1 CD58.1 CD60.1 CD61.1 CD62.1 CD63.1 CD64.1 CD66.1 PJP201.2 RD1.1 RD2.1 RD3.1 RD4.1 RD5.1 RD6.1 RD7.1 RD8.1 RD9.1 RD10.1 RD11.1 RD12.1 RD13.1 RD14.1 RD15.1 RD16.1 RD17.1 RD18.1 RD19.1 RD20.1 RD21.2 RD22.2 RD23.2 RD24.2 RD25.2 RD26.2 RD27.2 RD30.2 RD33.2 RD42.1 RD43.1 RD44.1 RD45.1 RD46.1 RD47.1 RD48.1 RD49.1 RD50.1 RD51.1 RD52.1 RD53.1 RD54.1 RD55.1 RD56.1 RD57.1 RD58.1 RD59.1 RD60.1 RD61.1 RD62.2 RD63.2 RD64.2 RD65.2 RD66.2 RD67.2 RD68.2 RD69.2 RD74.2 RD79.2 RD80.2 RD81.2 RD82.2
+0.6VSP: PC219.1 PJP201.1 PU200.5 PU200.6
+0.9V_TBT_CIO: CT38.1 CT39.1 CT40.1 UT1.R8 UT1.R9 UT1.R11 UT1.R12
+0.9V_TBT_DP: CT25.1 CT26.1 CT27.1 CT28.1 CT29.1 CT30.1 CT31.1 UT1.L6 UT1.L8 UT1.L11 UT1.L12 UT1.M6 UT1.M8 UT1.T11 UT1.T12 UT1.V11 UT1.V12 UT1.V13
+0.9V_TBT_LVR_OUT: CT59.1 CT60.1 CT61.1 CT62.1 UT1.F18 UT1.H11 UT1.H18 UT1.J11
+0.9V_TBT_PCIE: CT34.1 CT35.1 CT36.1 CT37.1 UT1.L18 UT1.L19 UT1.M13 UT1.M15 UT1.M16 UT1.M18 UT1.N18 UT1.N19
+0.9V_TBT_SVR: CT48.1 CT49.1 CT50.1 CT51.1 CT52.1 CT53.1 CT54.1 CT55.1 CT56.1 CT57.1 LT1.2 UT1.E12 UT1.E13 UT1.F11 UT1.F12 UT1.F13 UT1.F15 UT1.J9 UT1.L9 UT1.M9
+0.9V_TBT_USB: CT32.1 CT33.1 UT1.R15 UT1.R16
+1.0V_AMPHYPLL: CC219.1 CC264.1 RC169.2 UC1.K15 UC1.L15
+1.0V_APLL: CC314.1 CC323.1 LC2.2 UC1.V15
+1.0V_APLLEBB: CC218.1 CC325.1 RC310.2 UC1.N18
+1.0V_CLK1: RC302.2 UC1.A14
+1.0V_CLK2: CC220.1 RC170.2 UC1.K19
+1.0V_CLK3: RC303.2 UC1.L21
+1.0V_CLK4: CC226.1 RC173.2 UC1.N20
+1.0V_CLK5: CC221.1 RC52.2 RC171.2 UC1.L19
+1.0V_CLK6: CC216.1 RC300.2 UC1.A10
+1.0V_DTS: RC301.2 UC1.T1
+1.0V_MPHYAON: CC203.1 RC299.2 UC1.K17 UC1.L1
+1.0V_MPHYGT: CC210.1 CC211.1 CC281.1 PJP3.2 RC169.1 RC309.1 RC310.1 UC1.N15 UC1.N16 UC1.N17 UC1.P15 UC1.P16
+1.0V_PRIM: CC206.1 CC225.1 CC335.1 CZ100.1 CZ105.1 LC2.1 PJP3.1 PJP302.2 RC170.1 RC171.1 RC173.1 RC216.1 RC299.1 RC300.1 RC301.1 RC302.1 RC303.1 UC1.AB17 UC1.AB19 UC1.AB20 UC1.AK20 UC1.P18 UC1.Y18 UZ19.1 UZ19.2 UZ19.7 UZ21.1 UZ21.2 UZ21.7
+1.0V_PRIM_CORE: CC205.1 PJP402.2 UC1.AF18 UC1.AF19 UC1.V20 UC1.V21
+1.0V_PRIM_COREP: PC415.1 PC424.1 PC427.1 PJP402.1 PL404.2 PR423.2 PU402.1
+1.0V_PRIM_XDP: CC28.1 CC29.1 JXDP1.43 JXDP1.44 RC115.2 RC138.2 RC216.2
+1.0V_SRAM: CC217.1 RC309.2 UC1.AF20 UC1.AF21 UC1.T19 UC1.T20
+1.0V_VCCST: CC195.1 CC202.1 PC602.1 PJP1.1 PR601.1 PR604.1 PR605.1 RC71.2 RC79.2 RC80.2 RC120.2 RC152.2 RC157.2 RC218.2 RE59.1 RE90.1 RZ151.2 UC1.A18 UC1.K20 UC1.K21
+1.0V_VCCST_C: CZ101.1 PJP1.2 UZ21.6
+1.0V_VCCSTG: CC199.1 PJP2.1 RC81.2 RC82.2 RC83.2 RC87.2 RC130.2 RC131.2 RC134.2 RC135.2 RC143.2 RZ151.1 UC1.A22
+1.0V_VCCSTG_C: CZ106.1 PJP2.2 UZ19.6
+1.0V_VCCSTG_R: RC143.1 UC1.G20
+1.0VO_DSW: CC204.1 UC1.AL1
+1.0VS_VCCIO: CC250.1 CC251.1 CC252.1 CC253.1 PJP401.2 QE11.1 RC2.2 RC132.2 RC165.2 UC1.AK28 UC1.AK30 UC1.AL30 UC1.AL42 UC1.AM28 UC1.AM30 UC1.AM42
+1.2V_DDR_B+: PC200.1 PC201.1 PC202.1 PC203.1 PJP202.2 PU200.10
+1.2V_DDRP: PC208.1 PC209.1 PC210.1 PC211.1 PC212.1 PC213.1 PC214.1 PC216.1 PC217.1 PC223.1 PJP200.1 PL201.2 PR204.1 PU200.7 PU200.8
+1.2V_LDO: CR5.1 CR6.1 UR1.6
+1.2V_MEM: CC176.1 CC177.1 CC178.1 CC179.1 CC294.1 CC295.1 CC296.1 CD1.1 CD2.1 CD3.1 CD4.1 CD5.1 CD6.1 CD16.1 CD17.1 CD18.1 CD19.1 CD22.1 CD23.1 CD24.1 CD25.1 CD26.1 CD27.1 CD28.1 CD29.1 CD30.1 CD31.1 CD32.1 CD33.1 CD36.1 CD37.1 CD38.1 CD68.1 CD69.1 CD70.1 CD71.1 CD72.1 CD78.1 CD79.1 CD80.1 CD81.1 CD82.1 CD83.1 CD84.1 CD85.1 CD86.1 CD87.1 CD88.1 CD89.1 CD90.1 CD91.1 CD92.1 CD93.1 CD94.1 CD95.1 CD96.1 CD97.1 CD98.1 CD99.1 CD100.1 CD101.1 CD102.1 CD105.1 CD108.1 CD109.1 CD113.1 CD114.1 CD115.1 CZ102.1 PJP200.2 RC231.2 RD34.1 RD35.1 RD75.1 RZ119.1 UC1.AU23 UC1.AU28 UC1.AU35 UC1.AU42 UC1.BB23 UC1.BB32 UC1.BB41 UC1.BB47 UC1.BB51 UD1.A8 UD1.A9 UD1.A11 UD1.C12 UD1.D4 UD1.D5 UD1.D6 UD1.E8 UD1.E12 UD1.F2 UD1.G2 UD1.G5 UD1.G12 UD1.H3 UD1.H5 UD1.H6 UD1.H8 UD1.H9 UD1.H11 UD1.H12 UD1.J5 UD1.J6 UD1.J9 UD1.J10 UD1.K5 UD1.K6 UD1.K8 UD1.K11 UD1.K12 UD1.L2 UD1.L5 UD1.L12 UD1.M2 UD1.N8 UD1.N12 UD1.P4 UD1.P5 UD1.P6 UD1.R12 UD1.U8 UD1.U9 UD1.U11 UD2.A8 UD2.A9 UD2.A11 UD2.C12 UD2.D4 UD2.D5 UD2.D6 UD2.E8 UD2.E12 UD2.F2 UD2.G2 UD2.G5 UD2.G12 UD2.H3 UD2.H5 UD2.H6 UD2.H8 UD2.H9 UD2.H11 UD2.H12 UD2.J5 UD2.J6 UD2.J9 UD2.J10 UD2.K5 UD2.K6 UD2.K8 UD2.K11 UD2.K12 UD2.L2 UD2.L5 UD2.L12 UD2.M2 UD2.N8 UD2.N12 UD2.P4 UD2.P5 UD2.P6 UD2.R12 UD2.U8 UD2.U9 UD2.U11 UD3.A8 UD3.A9 UD3.A11 UD3.C12 UD3.D4 UD3.D5 UD3.D6 UD3.E8 UD3.E12 UD3.F2 UD3.G2 UD3.G5 UD3.G12 UD3.H3 UD3.H5 UD3.H6 UD3.H8 UD3.H9 UD3.H11 UD3.H12 UD3.J5 UD3.J6 UD3.J9 UD3.J10 UD3.K5 UD3.K6 UD3.K8 UD3.K11 UD3.K12 UD3.L2 UD3.L5 UD3.L12 UD3.M2 UD3.N8 UD3.N12 UD3.P4 UD3.P5 UD3.P6 UD3.R12 UD3.U8 UD3.U9 UD3.U11 UD4.A8 UD4.A9 UD4.A11 UD4.C12 UD4.D4 UD4.D5 UD4.D6 UD4.E8 UD4.E12 UD4.F2 UD4.G2 UD4.G5 UD4.G12 UD4.H3 UD4.H5 UD4.H6 UD4.H8 UD4.H9 UD4.H11 UD4.H12 UD4.J5 UD4.J6 UD4.J9 UD4.J10 UD4.K5 UD4.K6 UD4.K8 UD4.K11 UD4.K12 UD4.L2 UD4.L5 UD4.L12 UD4.M2 UD4.N8 UD4.N12 UD4.P4 UD4.P5 UD4.P6 UD4.R12 UD4.U8 UD4.U9 UD4.U11 UD5.5 UZ26.1 UZ26.2 UZ26.7
+1.2V_MEM_CPUCLK: CC297.1 RC231.1 UC1.AM40
+1.8V_3.3V_ALW_VTR3: CE21.1 PJP20.2 PJP21.2 RE340.2 RE529.2 RE553.1 RE554.1 UE1.N5 UE10.5
+1.8V_MEM: CD41.1 CD42.1 CD43.1 CD52.1 CD74.1 CD75.1 CD76.1 CD103.1 CD104.1 CD106.1 CD107.1 CD110.1 CD111.1 CD112.1 PJP506.2 UD1.A3 UD1.A4 UD1.A5 UD1.A6 UD1.A10 UD1.U3 UD1.U4 UD1.U5 UD1.U6 UD1.U10 UD2.A3 UD2.A4 UD2.A5 UD2.A6 UD2.A10 UD2.U3 UD2.U4 UD2.U5 UD2.U6 UD2.U10 UD3.A3 UD3.A4 UD3.A5 UD3.A6 UD3.A10 UD3.U3 UD3.U4 UD3.U5 UD3.U6 UD3.U10 UD4.A3 UD4.A4 UD4.A5 UD4.A6 UD4.A10 UD4.U3 UD4.U4 UD4.U5 UD4.U6 UD4.U10
+1.8V_PGPPF: RC304.2 UC1.AF16
+1.8V_PRIM: CC212.1 CE22.1 PJP20.1 PJP502.2 QC3.2 RC212.1 RC234.1 RC304.1 RC313.1 RC388.1 RC389.1 RC390.1 RC391.1 RC392.1 RC506.1 UC1.AA1 UZ8.1 UZ8.2
+1.8V_RUN: CA65.1 CA66.1 PJP42.2 Q1.2 QC4.2 QC4.5 RA3.1 RC362.2 RC363.2 RC370.2 RC510.1 RC511.1 RZ344.1 RZ501.2 RZ502.2 RZ503.2 RZ504.2 RZ510.1 RZ512.2 RZ513.2
+1.8V_RUN_AUDIO: CA57.1 CA58.1 CA69.1 RA3.2 UA1.16 UA1.21
+1.8V_RUN_CARD: CR19.2 CR20.2 JSD1.15 UR1.13
+1.8V_RUN_UZ8: CZ120.1 PJP42.1 UZ8.7 UZ8.8
+1.8V_VIN: PC514.1 PJP505.2 PU503.8
+1.8VALWP: PC501.1 PC503.1 PC504.1 PJP502.1 PL501.2 PR501.1
+1VALWP: PC307.1 PC308.1 PC309.1 PC310.1 PC311.1 PJP302.1 PL301.2 PR306.1
+1VALWP_B+: PC301.1 PC303.1 PC305.1 PC306.1 PJP301.2 PU301.2 PU301.3 PU301.4 PU301.5
+1VS_VCCIOP: PC406.1 PC407.1 PC422.1 PJP401.1 PL402.2 PR421.1 PU401.1
+3.3V_1.8V_ESPI: PJP4.2 RC21.2
+3.3V_1.8V_PGPPA: PJP4.1 RC211.2 RC212.2 RC550.1 UC1.AK15
+3.3V_1.8V_PGPPG: CC326.1 RC234.2 RC235.2 UC1.AD15
+3.3V_ALW: CE16.1 CE52.1 CE53.1 CE59.1 CE60.1 CE61.1 CE501.1 CE502.1 CT237.1 CT238.1 CV17.1 CZ57.1 CZ58.1 CZ68.1 CZ73.1 CZ82.1 CZ91.1 CZ104.1 CZ167.1 CZ188.1 JAPS1.3 JAPS1.7 JKBTP1.6 JUSH1.14 JUSH1.15 JUSH1.16 PC206.1 PC312.1 PJP21.1 PJP22.1 PJP102.2 PJP391.2 PJP501.1 PJP505.1 PL405.1 PL406.1 PL502.1 PR1.1 PR107.1 PR113.1 PR205.2 PR307.1 PR404.1 PR410.1 PR413.1 PR414.1 PR417.1 PR418.1 PR517.2 PR933.1 PR1229.2 PR1233.2 PR1260.2 PR1263.2 PR1264.2 PR1265.2 PR1267.2 PR1268.2 PR1271.2 PR1272.2 PR1291.2 PU200.13 PU301.15 QC7.3 QZ2.2 RC68.2 RC214.2 RC431.2 RC432.1 RC507.1 RE5.2 RE8.2 RE10.2 RE11.2 RE12.2 RE21.2 RE25.1 RE35.2 RE37.2 RE38.2 RE43.2 RE63.2 RE68.2 RE69.1 RE71.1 RE72.1 RE73.1 RE74.1 RE75.1 RE79.1 RE83.2 RE84.2 RE91.2 RE92.2 RE300.1 RE301.2 RE302.2 RE303.2 RE343.2 RE362.2 RE365.2 RE500.1 RE502.1 RE504.1 RE505.2 RE519.2 RE520.2 RE521.1 RE526.2 RE527.1 RE532.2 RE561.2 RE562.2 RPE7.5 RPE7.6 RPE7.7 RPE7.8 RPE9.5 RPE9.6 RPE9.7 RPE9.8 RPE11.5 RPE11.6 RPE11.7 RPE11.8 RPE12.5 RPE12.6 RPE12.7 RPE12.8 RT48.2 RT68.2 RT164.2 RT451.1 RT453.1 RV312.1 RZ8.1 RZ9.1 RZ369.1 RZ518.1 UE2.18 UE3.5 UE4.5 UE5.5 UE6.5 UT32.5 UT33.5 UV24.5 UZ1.2 UZ2.1 UZ2.2 UZ2.6 UZ2.7 UZ3.6 UZ3.7 UZ4.6 UZ4.7 UZ6.5 UZ28.2 UZ34.5 UZ35.5
+3.3V_ALW2: PR104.2 RE57.2
+3.3V_ALW_DSW: CC279.1 CC280.1 RC67.2 RC72.2 RC214.1 RC241.2 RC243.2 RC323.2 RC439.1 RC440.1 UC1.AD17 UC1.AD18 UC1.AJ17
+3.3V_ALW_DSW_R: QC7.1 RC439.2
+3.3V_ALW_PCH: CC209.1 CC215.1 CC223.1 CC224.1 JAPS1.1 JSPI1.5 LC1.1 PJP38.2 RC12.2 RC14.2 RC15.2 RC17.2 RC23.2 RC25.2 RC41.1 RC73.2 RC74.2 RC133.2 RC183.2 RC184.2 RC187.2 RC211.1 RC222.2 RC235.1 RC283.2 RC288.2 RC305.1 RC306.1 RC307.1 RC308.1 RC317.2 RC330.2 RC331.2 RC344.2 RC346.2 RC347.2 RC348.2 RC371.2 RC387.2 RC400.2 RC440.2 RC503.2 RC553.2 RC555.2 RC557.2 RC559.2 RPC3.5 RPC3.6 RPC3.7 RPC3.8 RT391.2 RZ69.1 RZ368.1 UC1.AJ21 UC1.AK17 UC1.V19 UC7.5
+3.3V_ALW_PCH_UZ3: CZ112.1 PJP38.1 UZ2.8 UZ2.9
+3.3V_ALW_UE1: CE13.1 CE14.1 CE15.1 CE19.1 CE20.1 CE23.1 PJP22.2 RE314.2 UE1.B7 UE1.G8 UE1.H1 UE1.K2 UE1.M9
+3.3V_ALW_UZ12: CZ51.1 CZ52.1 PJP391.1 UZ12.1
+3.3V_ALWP: PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PC129.1 PC161.1 PC162.1 PJP102.1 PL100.2 PR108.2 PU100.14
+3.3V_CAM: CV22.1 CV23.1 CZ1.1 JEDP1.6 QZ1.1
+3.3V_EC_PLL: CE17.1 CE18.1 RE314.1 UE1.F1
+3.3V_HDD_M2: CN60.1 CN61.1 CN62.1 CN63.1 CN64.1 JNGFF3.2 JNGFF3.4 JNGFF3.12 JNGFF3.14 JNGFF3.16 JNGFF3.18 JNGFF3.70 JNGFF3.72 JNGFF3.74 PJP31.1 RN37.1
+3.3V_M_TPM: CZ59.1 CZ60.1 RZ366.2 RZ367.1 RZ368.2 RZ369.2
+3.3V_MMI_IN: CR1.1 CR2.1 CR3.1 CR4.1 CR25.1 CR26.1 CR29.1 CR30.1 PJP14.2 RR3.1 RR22.1 UR1.8 UR1.11 UR1.27
+3.3V_PDA_VOUT: CT83.1 UT5.H2
+3.3V_PDB_VOUT: CT152.1 UT11.H2
+3.3V_PGPPB: CC265.1 RC305.2 UC1.AG15
+3.3V_PGPPC: CC207.1 RC306.2 UC1.Y16
+3.3V_PGPPD: RC307.2 UC1.Y15
+3.3V_PGPPE: CC208.1 RC308.2 UC1.T16
+3.3V_RTC_LDO: PD3.3 PR105.2
+3.3V_RUN: CA7.1 CC30.1 CZ67.1 CZ72.1 CZ168.1 CZ169.1 JEDP1.5 JESPI.1 JESPI.2 JSEN2.1 JUSH1.19 LGA1.9 PJP5.1 PJP14.1 PJP18.1 PJP31.2 PJP35.1 PJP39.2 PR612.1 QC2.2 QC2.5 QV3.2 QV3.5 QV5.2 QZ1.3 QZ10.2 QZ10.5 QZ14.2 QZ14.5 RA58.1 RC47.2 RC50.2 RC51.2 RC59.2 RC137.2 RC175.2 RC176.2 RC177.2 RC178.2 RC186.2 RC189.2 RC190.2 RC225.2 RC237.2 RC267.2 RC272.2 RC278.2 RC279.2 RC282.2 RC287.2 RC291.2 RC292.2 RC318.2 RC319.2 RC345.2 RC358.2 RC359.2 RC360.2 RC361.2 RC402.2 RC403.2 RC512.1 RC513.1 RC551.2 RD83.2 RE48.1 RE51.1 RE67.2 RE555.2 RE557.2 RPC4.5 RPC4.6 RPC4.7 RPC4.8 RPC5.6 RPC5.8 RV8.2 RV18.1 RV19.2 RV20.2 RV326.1 RZ89.1 RZ362.1 RZ365.2 RZ505.2 RZ506.2 RZ507.2 RZ508.2 RZ509.1 RZ514.2 RZ515.2 UC8.14 UC12.5 UZ5.6 UZ5.7 UZ41.1 UZ41.2
+3.3V_RUN_AUDIO: CA67.1 CA68.1 LA12.1 LA14.1 PJP16.2 PJP18.2 RA18.2 RA59.1 RA61.1
+3.3V_RUN_AUDIO_DVDD: CA10.1 CA61.1 LA14.2 UA1.4
+3.3V_RUN_AUDIO_IO: CA55.1 CA56.1 LA12.2 UA1.12
+3.3V_RUN_AUDIO_UZ5: CZ128.1 PJP16.1 UZ5.8 UZ5.9
+3.3V_RUN_CARD: CR17.2 CR18.2 JSD1.4 UR1.12
+3.3V_RUN_UZ3: CZ115.1 PJP39.1 UZ3.8 UZ3.9
+3.3V_SPI: CC9.1 CC10.1 JSPI1.6 RC30.2 RC31.2 RC41.2 UC1.AJ16 UC5.8 UC6.8
+3.3V_TBT: CT43.1 CT44.1 CT45.1 CT46.1 CT47.1 LT2.2 PJP5.2 RT11.2 RT12.2 RT13.2 RT14.2 RT15.2 RT49.2 RT336.2 RT337.2 UT1.A2 UT1.A3 UT1.B3 UT1.H9
+3.3V_TBT_FLASH_R: CT1.1 RT1.2 RT2.2 RT3.2 RT4.2 RT9.2 RT10.2 UT2.8
+3.3V_TBT_LC: CT41.1 RT5.2 RT6.2 RT7.2 RT8.2 RT9.1 UT1.R6
+3.3V_TBT_S0: CT67.1 CT68.1 CT69.1 LT2.1 UT1.R13
+3.3V_TBT_SX: CT42.1 PJP6.2 RT16.2 RT17.2 RT18.2 RT19.2 RT20.2 RT48.1 RT49.1 RT338.2 RT371.2 RT372.2 RT455.2 UT1.F8
+3.3V_TBTA_FLASH: CT84.1 RT10.1 RT66.2 RT67.2 RT76.2 RT95.2 RT98.2 RT106.2 RT107.2 RT221.2 UT5.G1
+3.3V_TBTB_FLASH: CT70.1 CT153.1 RT50.2 RT51.2 RT52.2 RT53.2 RT162.2 RT163.2 RT172.2 RT192.2 RT199.2 RT200.2 RT204.2 UT6.8 UT11.G1
+3.3V_TP: CZ83.1 CZ90.1 JKBTP1.12 PJP35.2 RZ18.1 RZ19.1 RZ20.1 RZ21.1 RZ116.1 RZ117.1
+3.3V_TSP: CV18.1 CV19.1 CZ2.1 JTS1.1 RV98.2 RV99.2 RV311.2 RZ516.2
+3.3V_TSP_UZ41: CZ305.1 RZ516.1 UZ41.7 UZ41.8
+3.3V_VCCHDA: CC313.1 CC324.1 LC1.2 UC1.AJ19
+3.3V_VDD_PIC: CT91.1 CT92.1 PC949.2 PC1207.2 PC1219.2 PJP6.1 PR950.2 PR1205.2 PR1213.2 PR1216.1 PR1228.1 PR1239.2 PR1249.2 PR1253.1 PR1258.1 PR1278.1 PR1281.1 PR1283.1 PR1284.1 PU903.5 PU1201.8 PU1202.5 PU1203.5 QT1.2 QT1.5 QT2.2 QT2.5 RT389.1 RT450.1 RT452.1 UT7.1
+3.3V_VDD_PIC_PDA: CT74.1 RT450.2 RT451.2 UT5.B1 UT5.H1
+3.3V_VDD_PIC_PDB: CT150.1 RT452.2 RT453.2 UT11.B1 UT11.H1
+3.3V_WLAN: CZ27.1 CZ28.1 CZ29.1 CZ30.1 CZ31.1 CZ32.1 CZ33.1 CZ34.1 CZ35.1 CZ36.1 JNGFF1.2 JNGFF1.4 JNGFF1.72 JNGFF1.74 PJP36.2
+3.3V_WLAN_UZ2: CZ122.1 PJP36.1 UZ2.13 UZ2.14
+3.3V_WWAN: CZ17.1 CZ18.1 CZ19.1 CZ20.1 CZ21.1 CZ23.1 CZ24.1 CZ25.1 CZ26.1 CZ154.1 CZ155.1 CZ164.1 JNGFF2.2 JNGFF2.4 JNGFF2.70 JNGFF2.72 JNGFF2.74 JSAR1.1 PJP41.2 QZ13.2 QZ13.5 RZ43.2 RZ331.2 RZ332.2 RZ350.2 RZ351.2 UZ29.1 UZ29.6 UZ29.10
+3.3V_WWAN_AUX: CZ181.1 CZ187.1 JTUN1.2 RZ332.1
+3.3V_WWAN_MAIN: CZ180.1 CZ186.1 JTUN1.1 RZ331.1
+3.3V_WWAN_UZ4: CZ119.1 CZ124.1 PJP41.1 UZ4.8 UZ4.9
+5V_ALW: CI6.1 CI7.1 CI19.1 CI31.1 CI33.1 CI34.1 CZ64.1 CZ69.1 DT1.2 JLED1.1 JPWR1.1 JSEN2.10 JUSH1.18 PC661.1 PC685.1 PC1336.1 PC1337.1 PJP8.2 PJP10.2 PJP103.2 PL407.1 PL408.1 PR602.2 PR615.2 PR634.2 PR686.1 PR688.1 PR689.1 PR691.1 PR1298.1 PR1300.1 PU610.15 PU612.15 PU613.15 PU614.6 RA54.2 RI13.2 RV313.1 UI1.5 UI3.1 UI3.7 UI3.8 UZ2.4 UZ3.4 UZ4.1 UZ4.2 UZ4.4 UZ5.4 UZ8.4 UZ19.3 UZ21.3 UZ26.3 UZ41.4
+5V_ALW2: PC126.1 PU102.15
+5V_ALW_PDA: CT75.1 CT76.1 CT77.1 CT78.1 PJP8.1 UT5.A11 UT5.B11 UT5.C11 UT5.D11 UT5.H10
+5V_ALW_PDB: CT142.1 CT143.1 CT144.1 CT145.1 PJP10.1 UT11.A11 UT11.B11 UT11.C11 UT11.D11 UT11.H10
+5V_ALWP: PC120.1 PC121.1 PC122.1 PC123.1 PC124.1 PC130.1 PC150.1 PC151.1 PC163.1 PC164.1 PJP103.1 PL101.2 PR117.2 PU102.14
+5V_PD_VDD: CT88.1 CT89.1 DT1.1 DT2.1 RT111.1 RT393.1 UT7.8
+5V_RUN: CE32.1 CZ66.1 CZ71.1 CZ92.1 DE1.1 JFAN1.4 JKBTP1.5 JUSH1.20 PJP17.1 PJP40.2 RV314.1 RZ370.1 UZ5.1 UZ5.2
+5V_RUN_AUDIO: CA59.1 CA60.1 CA63.1 CA64.1 LA5.2 LA13.2 PJP15.1 PJP17.2
+5V_RUN_AUDIO_UZ5: CZ125.1 PJP15.2 UZ5.13 UZ5.14
+5V_RUN_CHG: QZ4.1 RZ370.2
+5V_RUN_PVDD_L: CA45.1 CA46.1 CA47.1 CA48.1 LA13.1 UA1.41 UA1.46
+5V_RUN_UZ4: CZ116.1 PJP40.1 UZ4.13 UZ4.14
+5V_TBT_VBUS: CT93.1 DT2.2 DT3.1 DT38.1
+5V_TBTA_VBUS_D: DT3.2 UT8.3
+5V_TBTB_VBUS_D: DT38.2 UT12.3
+5V_USB_CHG_PWR: CI14.1 CI17.1 CI32.1 CI43.1 CI44.1 JUSB1.1 UI3.12
+VCC1V8A_TBTA_LDO: CT73.1 UT5.K1
+VCC1V8A_TBTB_LDO: CT149.1 UT11.K1
+VCC1V8D_TBTA_LDO: CT72.1 RT97.1 UT5.A2
+VCC1V8D_TBTB_LDO: CT148.1 RT191.1 UT11.A2
+VCC3V3_ANA_PCIE: CT63.1 UT1.L16
+VCC3V3_ANA_USB2: CT64.1 UT1.J16
+VCC_1P8: CC222.1 RC313.2 UC1.U11 UC1.U12
+VCC_CORE: PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1030.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1035.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1061.1 PC1062.1 PC1064.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PC1097.1 PC1098.1 PC1099.1 PC1126.1 PC1127.1 PC1321.1 PL610.1 PL613.1 PR682.1 PR684.1 RC140.2 UC1.A30 UC1.A34 UC1.A39 UC1.A44 UC1.AK33 UC1.AK35 UC1.AK37 UC1.AK38 UC1.AK40 UC1.AL33 UC1.AL37 UC1.AL40 UC1.AM32 UC1.AM33 UC1.AM35 UC1.AM37 UC1.AM38 UC1.G30 UC1.G32 UC1.G33 UC1.G35 UC1.G37 UC1.G38 UC1.G40 UC1.G42 UC1.J30 UC1.J33 UC1.J37 UC1.J40 UC1.K33 UC1.K35 UC1.K37 UC1.K38 UC1.K40 UC1.K42 UC1.K43
+VCC_CORE_G0: T122.1(TP-1) UC1.K32
+VCC_CORE_G1: T123.1(TP-1) UC1.AK32
+VCC_GT: PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1055.1 PC1056.1 PC1063.1 PC1128.1 PC1129.1 PC1132.1 PC1133.1 PC1134.1 PC1136.1 PC1137.1 PC1175.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PC1328.1 PC1329.1 PL612.1 PR683.1 RC161.2 RC437.1 RC438.2 UC1.A58 UC1.A62 UC1.A66 UC1.AA63 UC1.AA64 UC1.AA66 UC1.AA67 UC1.AA69 UC1.AA70 UC1.AA71 UC1.AC64 UC1.AC65 UC1.AC66 UC1.AC67 UC1.AC68 UC1.AC69 UC1.AC70 UC1.AC71 UC1.J53 UC1.J55 UC1.J56 UC1.J58 UC1.J60 UC1.K53 UC1.K55 UC1.K56 UC1.K58 UC1.K60 UC1.L62 UC1.L63 UC1.L64 UC1.L65 UC1.L66 UC1.L67 UC1.L68 UC1.L69 UC1.L70 UC1.L71 UC1.M62 UC1.N63 UC1.N64 UC1.N66 UC1.N67 UC1.N69 UC1.N70 UC1.N71 UC1.R63 UC1.R64 UC1.R65 UC1.R66 UC1.R67 UC1.R68 UC1.R69 UC1.R70 UC1.R71 UC1.T62 UC1.U65 UC1.U68 UC1.U71 UC1.W63 UC1.W64 UC1.W65 UC1.W66 UC1.W67 UC1.W68 UC1.W69 UC1.W70 UC1.W71 UC1.Y62
+VCC_GT_+VCC_CORE: PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1330.1 PC1331.1 PC1332.1 PC1333.1 PC1334.1 PR682.2 PR683.2 PR684.2 UC1.A48 UC1.A53 UC1.AK42 UC1.AK43 UC1.AK45 UC1.AK46 UC1.AK48 UC1.AK50 UC1.AL43 UC1.AL46 UC1.AL50 UC1.AM48 UC1.AM50 UC1.AM52 UC1.J43 UC1.J45 UC1.J46 UC1.J48 UC1.J50 UC1.J52 UC1.K48 UC1.K50
+VCC_GTUS: UC1.AK53 UC1.AK55 UC1.AK56 UC1.AK58 UC1.AK60 UC1.AL53 UC1.AL56 UC1.AL60 UC1.AM53 UC1.AM56 UC1.AM58
+VCC_SA: PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1149.1 PC1150.1 PC1151.1 PC1152.1 PC1153.1 PL614.1 RC168.1 UC1.AK23 UC1.AK25 UC1.G23 UC1.G25 UC1.G27 UC1.G28 UC1.J22 UC1.J23 UC1.J27 UC1.K23 UC1.K25 UC1.K27 UC1.K28 UC1.K30
+VCC_SFR_OC: CC288.1 CC322.1 CZ103.1 RZ119.2 UC1.AL23 UZ26.6
+VDD_IO: CZ170.1 LGA1.2 LGA1.10 RZ121.1 RZ509.2 RZ510.2
+VDDA_AVDD1: CA8.1 CA9.1 LA5.1 UA1.40
+VSS_PLL: CE17.2 CE18.2 UE1.G1
