# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_C_DTX_N1: length 3.7
  BOTTOM w0.076: UT1.V22 35.91,53.88 arc(35.99,53.76) 36.02,53.62 36.02,53.46 arc(36.01,53.42) 36,53.38 arc(35.98,53.34) 35.96,53.32 35.89,53.25 35.89,53.07 35.9,53.07 35.9,53.05
  BOTTOM w0.088: 35.9,53.05 35.9,52.97 36.71,52.16 37,52.16 37.31,51.85 37.31,51.44 CT7.1
PCIE_PRX_C_DTX_N2: length 3.3
  BOTTOM w0.076: 34.05,53.04 34.05,53.06 34.05,53.07 34.05,53.24 34.12,53.32 arc(34.16,53.38) 34.18,53.46 34.18,53.62 arc(34.15,53.76) 34.07,53.88 UT1.P22
  BOTTOM w0.088: 34.05,53.04 34.05,52.52 34.4,52.17 34.4,52.11 34.76,51.75 34.76,51.45 CT9.1
PCIE_PRX_C_DTX_N3: length 3
  BOTTOM w0.076: 32.22,53.04 32.22,53.06 32.21,53.07 32.21,53.25 32.28,53.32 arc(32.32,53.38) 32.34,53.46 32.34,53.62 arc(32.31,53.76) 32.23,53.88 UT1.K22
  BOTTOM w0.088: CT128.1 32.09,51.46 32.09,51.86 32.13,51.9 32.13,52.48 32.11,52.5 32.11,52.62 32.22,52.73 32.22,53.04
PCIE_PRX_C_DTX_N4: length 3.6
  BOTTOM w0.076: UT1.F22 30.39,53.88 arc(30.47,53.76) 30.5,53.62 30.5,53.46 arc(30.48,53.38) 30.44,53.32 30.31,53.19 30.31,52.76 30.32,52.76 30.32,52.74
  BOTTOM w0.088: CT130.1 29.23,51.45 29.23,51.7 29.61,52.08 29.8,52.08 30.32,52.59 30.32,52.74
PCIE_PRX_C_DTX_P1: length 3.7
  BOTTOM w0.076: UT1.V23 35.79,53.63 arc(35.68,53.74) 35.57,53.63 35.57,53.48 arc(35.58,53.38) 35.64,53.3 35.72,53.21 35.72,53.07 35.72,53.05
  BOTTOM w0.088: CT6.1 37.14,51.47 37.14,51.78 36.93,51.99 36.63,51.99 35.72,52.9 35.72,53.05
PCIE_PRX_C_DTX_P2: length 3.3
  BOTTOM w0.076: UT1.P23 33.95,53.63 arc(33.84,53.74) 33.73,53.63 33.73,53.48 arc(33.74,53.38) 33.8,53.3 33.89,53.21 33.89,53.07 33.88,53.06 33.88,53.04
  BOTTOM w0.088: 33.88,53.04 33.88,52.39 v7(34.04,52.23) 34.59,51.68 34.59,51.46 CT8.1
PCIE_PRX_C_DTX_P3: length 3
  BOTTOM w0.076: 32.05,53.04 32.05,53.06 32.05,53.06 32.05,53.11 32.05,53.11 32.05,53.2 31.96,53.3 arc(31.9,53.38) 31.89,53.48 31.89,53.63 arc(31.92,53.71) 32,53.74 arc(32.08,53.71) 32.11,53.63 UT1.K23
  BOTTOM w0.088: CT127.1 31.92,51.45 v7(31.92,52.19) 31.92,52.67 32.05,52.81 32.05,53.04
PCIE_PRX_C_DTX_P4: length 3.6
  BOTTOM w0.076: 30.15,52.74 30.15,52.76 30.15,52.76 30.15,53.26 30.12,53.3 arc(30.06,53.38) 30.05,53.48 30.05,53.66 arc(30.08,53.74) 30.15,53.77 arc(30.23,53.73) 30.27,53.65 UT1.F23
  BOTTOM w0.088: CT129.1 29.06,51.44 29.06,51.77 29.54,52.25 29.73,52.25 v7(29.91,52.43) 30.15,52.67 30.15,52.74
PCIE_PRX_DTX_N1: length 158.2
  IN2 w0.083: v4(148.44,76.95) 148.5,77 arc(148.6,77.08) 148.72,77.12 arc(148.8,77.15) 148.87,77.2 arc(148.96,77.33) 148.99,77.49 148.99,78.83 146.72,81.1 145.25,81.1 143.13,83.22 139.84,83.22 139.14,83.93 130.15,83.93 129.08,85 125.32,85 124.49,85.83 114.17,85.83 112,88 97.06,88 93.94,84.88 79.73,84.88 78.53,86.07 66.62,86.07 64.93,84.39 60.46,84.39 58.79,82.72 50.41,82.72 48.24,80.55 45.27,80.55 44.38,79.66 44.38,77.17 40.47,73.26 39.1,73.26 38.75,72.91 38.75,68.37 39,68.11 39,66.93 39.76,66.17 39.76,66.16 39.76,65.14 38.78,64.16 38.78,64.12 38.78,64.12 38.78,52.8 40.45,51.12 40.45,49.31 38.51,47.36 37.33,47.36 37.26,47.43 37.26,47.64 v4(37.41,47.79)
  GND5 w0.081: v4(148.44,76.95) 148.44,76.92 148.68,76.69 arc(148.72,76.66) 148.77,76.65 v5(148.9,76.65)
  GND5 w0.088: v4(37.41,47.79) 37.26,47.93 37.26,48.33 37.41,48.47 v5(37.41,48.55)
  BOTTOM w0.088: CT7.2 37.29,50.46 37.29,48.83 arc(37.32,48.68) v5(37.41,48.55)
PCIE_PRX_DTX_N2: length 159
  IN2 w0.083: v4(34.94,50.17) 34.87,50.11 34.87,49.23 35.7,48.4 38.72,48.4 39.87,49.54 39.87,50.89 38.19,52.57 38.19,64.45 38.43,64.69 38.43,67.87 38.18,68.12 38.18,73.16 38.88,73.87 39.63,73.87 43.75,77.99 43.75,79.92 44.97,81.14 48.02,81.14 50.17,83.29 58.53,83.29 60.22,84.97 64.68,84.97 66.48,86.78 70.86,86.78 71.49,87.41 79.03,87.41 80.99,85.45 93.7,85.45 96.83,88.57 112.92,88.57 115.09,86.4 124.73,86.4 125.55,85.58 129.38,85.58 130.46,84.5 139.38,84.5 140.07,83.8 143.59,83.8 144.76,82.63 146.54,82.63 149.91,79.26 149.91,78.22 arc(149.9,78.12) 149.88,78.01 149.8,77.94 arc(149.76,77.91) 149.72,77.88 149.69,77.86 arc(149.69,77.86) 149.68,77.86 arc(149.54,77.76) 149.41,77.65 v4(149.36,77.6)
  GND5 w0.088: v4(34.94,50.17) 34.96,50.19 v5(34.96,50.67) ; v5(149.82,77.3) 149.52,77.6 v4(149.36,77.6)
PCIE_PRX_DTX_N3: length 159.9
  IN2 w0.083: v4(146.62,76.91) 146.62,76.93 arc(146.69,77.1) 146.85,77.17 arc(147.03,77.22) 147.13,77.37 147.13,77.37 arc(147.15,77.45) 147.16,77.53 147.16,78.04 147.12,78.08 arc(147.04,78.2) 147.01,78.34 147.01,79.47 146.1,80.37 144.93,80.37 143.97,81.34 143.08,81.34 141.83,82.58 139.26,82.58 138.79,83.05 132.71,83.05 130.99,81.32 128.19,81.32 124.25,85.26 113.75,85.26 111.58,87.43 97.3,87.43 94.18,84.3 79.48,84.3 78.33,85.45 66.84,85.45 65.17,83.78 60.67,83.78 59.02,82.13 50.63,82.13 48.47,79.97 45.55,79.97 44.99,79.41 44.99,76.97 40.37,72.34 40.37,70.87 39.82,70.32 39.82,66.95 40.37,66.4 40.37,62.98 39.84,62.44 39.84,53.97 40.3,53.51 40.3,52.15 41.03,51.42 41.03,49.07 38.73,46.78 36.44,46.78 33.8,49.41 32.41,49.41 32.23,49.59 32.23,49.95 v4(32.3,50.02)
  GND5 w0.081: v4(146.62,76.91) 146.81,76.71 arc(146.88,76.67) 146.97,76.65 v5(147.07,76.65)
  GND5 w0.088: v5(32.29,50.67) 32.29,50.03 v4(32.3,50.02)
PCIE_PRX_DTX_N4: length 164.9
  IN2 w0.083: v4(29.32,50.01) 29.37,50.01 29.58,49.8 29.58,49.63 29.5,49.54 29.08,49.54 29,49.46 29,49.32 29.08,49.24 31.75,49.24 32.92,48.07 34.15,48.07 36.52,45.7 38.47,45.7 41.65,48.88 41.65,51.64 40.9,52.39 40.9,53.81 40.43,54.28 40.43,62.16 40.96,62.69 40.96,66.67 40.39,67.23 40.39,69.98 40.96,70.55 40.96,72.13 45.54,76.71 47.73,76.71 49.69,78.67 49.69,80.38 50.85,81.54 59.25,81.54 60.9,83.19 66.82,83.19 68.5,84.87 78,84.87 79.14,83.73 94.41,83.73 97.54,86.86 111.25,86.86 113.42,84.68 122.84,84.68 124.86,82.67 125.99,82.67 127.93,80.73 131.58,80.73 132.17,81.32 134.99,81.32 135.15,81.17 139.95,81.17 140.71,81.93 141.6,81.93 142.8,80.73 143.18,80.73 144.39,79.52 145,79.52 145.34,79.18 145.34,78.19 146.22,77.31 146.22,76.95 arc(146.34,76.64) 146.65,76.51 147.54,76.51 arc(147.65,76.54) 147.74,76.6 147.87,76.73 arc(147.89,76.75) 147.9,76.78 147.9,77.05 arc(147.88,77.12) 147.84,77.18 147.78,77.24 arc(147.75,77.26) 147.71,77.27 arc(147.56,77.24) 147.49,77.1 147.49,77.02 v4(147.54,76.97)
  GND5 w0.081: v5(147.99,77.3) 147.92,77.3 arc(147.87,77.29) 147.83,77.27 v4(147.54,76.97)
  GND5 w0.088: v5(29.43,50.66) 29.43,50.12 v4(29.32,50.01)
PCIE_PRX_DTX_N5: length 137.3
  IN1 w0.062: v4(147.53,78.24) 146.93,78.24 146.79,78.38 146.79,79.12 147.27,79.6 156.85,79.6 159.31,77.13 160.35,77.13 163.85,73.63 164.52,73.63 167.26,70.9 167.26,69.04 171.04,65.26 171.04,61.35 172.24,60.14 172.24,54.5 179.47,47.28 179.47,46.31 180.9,44.88 184.28,44.88 186.06,43.11 190.48,43.11 191.64,41.94 216.77,41.94 218.41,43.58 218.41,44.37 220.4,46.36 223.8,46.36 226.98,43.18 229.83,43.18 236.22,36.79 240,36.79 241.23,38.01 241.23,41.45 240.51,42.16 240.51,42.91 240.94,43.34 240.94,45.24 240.5,45.68 240.41,45.68 240.34,45.6 240.19,45.6 240.14,45.55 240.14,45.28 v4(240.18,45.24)
  GND5 w0.076: v4(240.18,45.24) 240.18,45.39 240.04,45.53 v5(239.68,45.53)
  GND5 w0.081: v5(147.07,77.95) 147.22,77.95 147.51,78.24 v4(147.53,78.24)
  BOTTOM w0.088: JNGFF1.43 240.01,45.65 239.85,45.49 239.72,45.49 v5(239.68,45.53)
PCIE_PRX_DTX_N7: length 117
  TOP w0.088: UZ29.14 226.98,59.75 227.15,59.58 227.15,58.97 227.33,58.79 227.33,55.76 227.28,55.72 227.28,55.13 227.33,55.08 227.33,53.91 226.56,53.14 v7(226.56,53.14) 222.7,49.28 214.7,49.28 210.74,45.32 198.03,45.32 196.91,46.43 192.93,46.43 191.55,47.81 187.25,47.81 186.86,47.42 181.48,47.42 181.27,47.22 181.27,47.03 v2(181.07,46.82)
  IN4 w0.062: v4(144.75,78.25) 145.05,78.25 145.14,78.33 145.14,78.62 145.29,78.77 145.29,79.12 145.77,79.6 150.95,79.6 151.15,79.41 158.74,79.41 160.19,77.96 160.19,76.46 163.03,73.62 164,73.62 166.06,71.56 167.78,71.56 172.54,66.81 172.54,64.78 174.03,63.28 174.03,62.46 174.63,61.87 174.63,60.37 176.7,58.3 176.7,57.06 177.97,55.79 177.97,50.53 181.28,47.22 181.28,47.03 v2(181.07,46.82)
  GND5 w0.081: v5(145.24,77.95) 144.95,78.25 v4(144.75,78.25)
PCIE_PRX_DTX_N8: length 143.4
  IN1 w0.062: v4(218.86,46.86) 218.74,46.73 218.74,45.42 218.03,44.71 218.03,43.8 216.54,42.31 191.94,42.31 190.68,43.57 186.14,43.57 183.83,45.88 180.58,45.88 179.93,46.53 179.93,48.06 172.61,55.38 172.61,60.48 171.88,61.21 171.88,65.32 172.34,65.78 172.34,67.01 168.12,71.23 167.46,71.23 164.43,74.25 163.75,74.25 158.03,79.98 147.1,79.98 146.47,79.34 146.47,78.82 145.39,77.74 144.28,77.74 144.25,77.77 144,77.77 v4(143.82,77.58)
  IN2 w0.083: v4(228.44,78.09) 228.24,78.29 227.27,78.29 227.04,78.07 227.04,74.18 226.95,74.08 226.95,65.85 225.91,64.8 225.91,60.91 226.15,60.67 226.15,53.51 222.66,50.02 222.09,50.02 219.85,47.79 218.81,47.79 218.46,47.43 218.46,47.26 218.53,47.18 218.77,47.18 218.86,47.1 v4(218.86,46.86)
  GND5 w0.076: v5(144.33,77.3) 144.05,77.58 v4(143.82,77.58)
  GND5 w0.088: v4(228.44,78.09) 228.65,78.31 228.84,78.31 v5(228.95,78.19)
  BOTTOM w0.088: JNGFF2.43 229.42,78.15 229.25,78.32 229.08,78.32 v5(228.95,78.19)
PCIE_PRX_DTX_N9: length 181.9
  IN1 w0.062: v4(141.36,79.64) 141.14,79.42 140.97,79.42 140.17,80.22 140.17,82.07 139.46,82.78 135.05,82.78 134.83,83 132.48,83 132.35,82.87 129.85,82.87 129.32,83.4 129.32,84.5 128.94,84.88 112.36,84.88 110.12,87.12 94.83,87.12 92.89,85.17 78.4,85.17 77.25,85.65 65.83,85.65 64.86,84.68 58.71,84.68 57.34,83.3 51.33,83.3 48.37,80.34 46.64,80.34 45.49,79.19 45.49,76.78 41.29,72.57 41.29,61.76 41.72,61.32 41.72,56.27 41.94,56.05 41.94,52.39 41.61,52.05 41.61,47.9 41.01,47.3 41.01,46.47 39.58,45.04 39.58,44.31 38.82,43.54 38.82,41.02 37.6,39.81 37.6,39.11 37.26,38.77 37.26,34.86 30.64,28.24 30.64,24.97 30.29,24.63 30.29,22.72 30.13,22.55 29.88,22.55 v4(29.66,22.77)
  GND5 w0.076: v4(141.36,79.64) 141.51,79.64 v5(141.96,79.2)
  GND5 w0.088: v5(30.14,22.67) 30.07,22.59 29.84,22.59 v4(29.66,22.77)
  BOTTOM w0.076: v5(141.96,79.2) 142.09,79.07 142.87,79.07 143.09,78.85 143.09,78.69 143.18,78.6 UC1.E22
  BOTTOM w0.088: JNGFF3.5 33.35,16.45 33.16,16.64 33.16,16.67 32.74,17.09 32.71,17.09 32.6,17.2 v7(32.6,18.16) 32.6,18.63 32.05,19.18 32.05,21.31 30.71,22.65 30.29,22.65 30.27,22.66 30.14,22.66 v5(30.14,22.67)
PCIE_PRX_DTX_N10: length 183.2
  IN1 w0.062: v4(28.55,20.98) 28.29,21.24 28.29,22.14 28.59,22.44 28.59,29.44 31.23,32.08 31.23,32.09 35.94,36.8 35.94,38.11 36.12,38.29 36.12,39.56 37.92,41.36 37.92,43.89 38.7,44.67 38.7,45.41 40.13,46.84 40.13,47.66 40.73,48.27 40.73,51.92 40.43,52.22 40.43,54.18 40.04,54.57 40.04,61.32 40.41,61.68 40.41,73 44.47,77.07 44.47,79.64 46.22,81.38 48.09,81.38 50.92,84.21 57,84.21 58.35,85.56 63.33,85.56 64.3,86.53 71.23,86.53 71.95,87.25 83.52,87.25 84.44,86.33 92.79,86.33 94.47,88 110.67,88 112.91,85.76 129.3,85.76 130.77,84.29 134.86,84.29 135.47,83.68 139.88,83.68 141.75,81.81 141.75,78.65 142.15,78.25 142.15,78.07 142.23,77.98 v4(142.48,77.98)
  GND5 w0.076: v4(142.48,77.98) 142.47,77.98 142.25,78.19 141.83,78.19 v5(141.59,77.95)
  GND5 w0.088: v5(28.49,20.02) 28.49,20.17 28.37,20.29 28.37,20.82 28.53,20.98 v4(28.55,20.98)
  BOTTOM w0.088: JNGFF3.17 30.35,14.99 30.19,15.15 30.19,15.83 29.87,16.15 29.87,18.24 v7(29.48,18.63) 28.4,19.71 28.4,19.84 28.49,19.93 v5(28.49,20.02)
PCIE_PRX_DTX_N11: length 191.3
  IN1 w0.062: v4(140.24,78.88) 140.39,79.03 140.6,79.03 140.68,78.95 140.68,78.48 140.77,78.38 141.14,78.38 141.29,78.23 141.29,77.63 141.73,77.18 142.24,77.18 142.84,77.78 142.84,78.8 143.31,79.27 143.31,80.37 142.79,80.89 142.79,82.24 140.31,84.72 135.91,84.72 135.27,85.37 131.14,85.37 129.73,86.78 124.16,86.78 122.89,88.05 112.23,88.05 111.26,89.02 94.04,89.02 92.72,87.7 87.17,87.7 86.6,88.27 71.52,88.27 70.91,87.66 63.92,87.66 62.84,86.58 57.93,86.58 56.58,85.23 50.49,85.23 47.8,82.53 45.86,82.53 40.09,76.77 40.09,75.06 38.95,73.92 38.95,52.24 39.71,51.48 39.71,48.69 39.11,48.09 39.11,47.36 38.38,46.64 37.49,46.64 37.04,46.19 37.04,44.55 35.1,42.6 35.1,39.14 34.08,38.12 34.08,36.39 30.2,32.51 30.2,32.5 26.92,29.22 26.92,23.53 25.97,22.58 25.97,21.01 26.03,20.95 26.17,20.95 26.23,20.89 v4(26.23,20.63)
  GND5 w0.076: v5(139.76,78.6) 140.04,78.88 v4(140.24,78.88)
  GND5 w0.088: v4(26.23,20.63) 26.05,20.45 26.05,20.18 26.15,20.08 v5(26.15,19.95)
  BOTTOM w0.088: v5(26.15,19.95) 26.15,19.89 26.05,19.79 26.05,19.13 26.16,19.02 26.22,19.02 26.64,18.6 26.64,18.53 27.19,17.99 27.19,16.32 27.19,16.32 27.19,15.15 27.35,14.99 JNGFF3.29
PCIE_PRX_DTX_N12: length 172.9
  IN1 w0.062: v4(23.78,16.95) 24,16.73 24,16.52 24.15,16.37 27.19,16.37 31.63,20.82 31.63,24.06 31.71,24.15 31.72,24.15 32.01,24.44 32.01,27 33.45,28.44 33.45,29.35 41.74,37.64 41.74,41.05 41.89,41.2 41.89,42.94 43.6,44.66 43.6,46.22 44.7,47.32 44.7,70.85 53.36,79.51 57.85,79.51 59.57,81.22 68.8,81.22 69.77,82.19 93.94,82.19 95.52,83.77 109.19,83.77 112.08,80.88 112.08,80.45 112.9,79.63 115.96,79.63 116.37,79.22 132.16,79.22 132.63,78.75 135.55,78.75 136.04,79.24 138.94,79.24 139.14,79.04 139.14,78.63 138.99,78.48 138.79,78.48 138.72,78.54 138.72,78.76 138.65,78.83 v2(138.37,78.83)
  GND5 w0.088: v4(23.78,16.95) 24,16.73 24,15.99 23.91,15.9 v5(23.91,15.82)
  BOTTOM w0.076: UC1.E30 v2(138.37,78.83)
  BOTTOM w0.088: v5(23.91,15.82) 23.91,15.72 24.01,15.61 24.01,15.27 23.85,15.11 JNGFF3.43
PCIE_PRX_DTX_P1: length 158.2
  IN2 w0.083: v4(36.82,47.79) 37.08,47.53 37.08,47.35 37.25,47.18 38.58,47.18 40.64,49.23 40.64,51.2 38.96,52.87 38.96,64.04 38.96,64.04 38.96,64.08 39.95,65.06 39.95,66.24 39.18,67.01 39.18,68.19 38.93,68.44 38.93,72.83 39.18,73.08 40.55,73.08 44.57,77.1 44.57,79.59 45.35,80.37 48.32,80.37 50.48,82.53 58.87,82.53 60.54,84.2 65.01,84.2 66.69,85.89 78.46,85.89 79.65,84.69 94.01,84.69 97.14,87.82 111.92,87.82 114.09,85.65 124.41,85.65 125.24,84.81 129.01,84.81 130.08,83.74 139.06,83.74 139.77,83.03 143.05,83.03 145.17,80.91 146.64,80.91 148.8,78.75 148.8,77.49 arc(148.79,77.4) 148.73,77.33 arc(148.71,77.31) 148.69,77.3 148.65,77.29 arc(148.51,77.33) 148.44,77.47 v4(148.44,77.66)
  GND5 w0.081: v4(148.44,77.66) 148.77,77.33 arc(148.8,77.31) 148.84,77.3 v5(148.9,77.3)
  GND5 w0.088: v4(36.82,47.79) 36.82,47.79 37.09,48.06 37.09,48.43 v5(37,48.52)
  BOTTOM w0.088: CT6.2 37.12,50.48 37.12,48.83 arc(37.12,48.81) 37.12,48.79 arc(37.08,48.65) v5(37,48.52)
PCIE_PRX_DTX_P2: length 159
  IN2 w0.083: v4(34.36,50.17) 34.36,49.91 34.44,49.83 34.61,49.83 34.69,49.74 34.69,49.15 35.63,48.21 38.8,48.21 40.05,49.47 40.05,50.96 38.37,52.65 38.37,64.37 38.61,64.61 38.61,67.95 38.36,68.2 38.36,73.09 38.96,73.68 39.71,73.68 43.93,77.91 43.93,79.85 45.05,80.96 48.1,80.96 50.25,83.1 58.61,83.1 60.29,84.79 64.76,84.79 66.56,86.59 70.93,86.59 71.57,87.23 78.95,87.23 80.91,85.26 93.78,85.26 96.9,88.39 112.84,88.39 115.01,86.22 124.65,86.22 125.47,85.4 129.3,85.4 130.39,84.31 139.3,84.31 139.99,83.62 143.51,83.62 144.68,82.45 146.46,82.45 149.73,79.18 149.73,78.22 arc(149.72,78.17) 149.71,78.11 149.67,78.07 arc(149.65,78.05) 149.63,78.04 149.6,78.03 arc(149.58,78.01) 149.55,78.01 149.55,78.01 arc(149.49,78.02) 149.43,78.06 149.36,78.13 v4(149.36,78.25)
  GND5 w0.081: v5(149.82,77.95) 149.73,77.95 arc(149.66,77.96) 149.6,78 v4(149.36,78.25)
  GND5 w0.088: v5(34.38,50.67) 34.38,50.2 v4(34.36,50.17)
PCIE_PRX_DTX_P3: length 159.9
  IN2 w0.083: v4(146.6,77.58) 146.6,77.43 arc(146.62,77.38) 146.68,77.35 146.85,77.35 arc(146.92,77.37) 146.96,77.43 146.96,77.43 arc(146.97,77.48) 146.98,77.53 146.98,77.96 arc(146.86,78.14) 146.82,78.34 146.82,79.39 146.02,80.19 144.86,80.19 143.89,81.16 143,81.16 141.76,82.4 139.18,82.4 138.72,82.86 132.79,82.86 131.06,81.14 128.11,81.14 124.17,85.07 113.68,85.07 111.5,87.24 97.38,87.24 94.25,84.12 79.4,84.12 78.25,85.27 66.91,85.27 65.24,83.6 60.75,83.6 59.1,81.95 50.71,81.95 48.55,79.78 45.63,79.78 45.18,79.33 45.18,76.9 40.55,72.27 40.55,70.79 40,70.25 40,67.03 40.56,66.47 40.56,62.9 40.02,62.37 40.02,54.05 40.48,53.59 40.48,52.23 41.21,51.5 41.21,48.99 38.81,46.59 36.36,46.59 33.73,49.23 32.33,49.23 32.05,49.51 32.05,49.62 31.96,49.71 31.81,49.71 31.72,49.8 v4(31.72,50.02)
  GND5 w0.081: v4(146.6,77.58) 146.82,77.36 arc(146.89,77.32) 146.97,77.3 v5(147.07,77.3)
  GND5 w0.088: v4(31.72,50.02) 31.72,50.02 v5(31.72,50.67)
PCIE_PRX_DTX_P4: length 165
  IN2 w0.083: v4(147.54,77.62) 147.63,77.52 arc(147.69,77.48) 147.76,77.45 arc(147.84,77.42) 147.91,77.37 147.97,77.31 arc(148.05,77.19) 148.08,77.05 148.08,76.78 arc(148.06,76.68) 148,76.59 147.88,76.47 arc(147.72,76.37) 147.54,76.33 146.65,76.33 arc(146.21,76.51) 146.03,76.95 146.03,77.24 145.15,78.11 145.15,79.1 144.92,79.33 144.31,79.33 143.1,80.55 142.72,80.55 141.52,81.75 140.78,81.75 140.02,80.98 135.07,80.98 134.92,81.14 132.25,81.14 131.66,80.55 127.86,80.55 125.92,82.48 124.78,82.48 122.76,84.5 113.34,84.5 111.17,86.67 97.61,86.67 94.49,83.55 79.06,83.55 77.92,84.69 68.57,84.69 66.9,83.01 60.98,83.01 59.33,81.36 50.93,81.36 49.88,80.31 49.88,78.59 47.81,76.52 45.62,76.52 41.15,72.05 41.15,70.48 40.58,69.9 40.58,67.31 41.14,66.74 41.14,62.61 40.61,62.09 40.61,54.35 41.08,53.88 41.08,52.47 41.83,51.72 41.83,48.8 38.55,45.52 36.44,45.52 34.07,47.89 32.84,47.89 31.67,49.05 29.01,49.05 28.82,49.24 28.82,49.92 v4(28.73,50.01)
  GND5 w0.081: v4(147.54,77.62) 147.83,77.92 arc(147.87,77.94) 147.92,77.95 v5(147.99,77.95)
  GND5 w0.088: v4(28.73,50.01) 28.86,50.14 v5(28.86,50.66)
PCIE_PRX_DTX_P5: length 137.3
  IN1 w0.062: v4(240.18,45.99) 240.33,45.83 240.34,45.83 240.56,45.83 241.09,45.3 241.09,43.28 240.66,42.85 240.66,42.22 241.37,41.51 241.37,37.95 240.06,36.64 236.16,36.64 229.77,43.03 226.92,43.03 223.74,46.21 220.46,46.21 218.56,44.31 218.56,43.52 216.83,41.79 191.58,41.79 190.42,42.96 186,42.96 184.22,44.74 180.84,44.74 179.32,46.25 179.32,47.22 172.1,54.44 172.1,60.08 170.89,61.29 170.89,65.2 167.11,68.98 167.11,70.84 164.46,73.49 163.79,73.49 160.29,76.99 159.25,76.99 156.79,79.46 147.33,79.46 146.93,79.06 146.93,78.44 146.99,78.39 147.14,78.39 147.21,78.45 147.21,78.85 147.29,78.94 147.47,78.94 v4(147.53,78.88)
  GND5 w0.076: v5(239.69,45.92) 239.77,45.83 240.07,45.83 240.18,45.94 v4(240.18,45.99)
  GND5 w0.081: v5(147.07,78.6) 147.26,78.6 v4(147.53,78.88)
  BOTTOM w0.088: v5(239.69,45.92) 239.84,45.92 240.08,46.15 JNGFF1.41
PCIE_PRX_DTX_P7: length 117
  TOP w0.088: UZ29.15 227.48,59.79 227.32,59.63 227.32,59.04 227.5,58.86 227.5,55.42 v7(227.5,55.42) 227.5,55.42 227.5,53.84 226.93,53.27 226.93,53.19 226.51,52.77 226.44,52.77 222.78,49.11 214.77,49.11 210.81,45.14 197.96,45.14 196.84,46.26 192.85,46.26 191.48,47.63 187.32,47.63 186.94,47.25 181.55,47.25 181.45,47.15 181.45,47.03 v2(181.65,46.82)
  IN4 w0.062: v4(144.75,78.9) 144.91,78.74 145.05,78.74 145.15,78.83 145.15,79.18 145.71,79.75 151.02,79.75 151.21,79.55 158.8,79.55 160.33,78.02 160.33,76.52 163.1,73.76 164.06,73.76 166.12,71.71 167.84,71.71 172.68,66.87 172.68,64.84 174.18,63.34 174.18,62.52 174.78,61.93 174.78,60.43 176.84,58.36 176.84,57.12 178.11,55.85 178.11,50.59 181.42,47.28 181.42,47.05 v2(181.65,46.82)
  GND5 w0.081: v5(145.24,78.6) 144.95,78.9 v4(144.75,78.9)
PCIE_PRX_DTX_P8: length 143.4
  IN1 w0.062: v4(218.28,46.86) 218.59,46.54 218.59,45.48 217.88,44.77 217.88,43.86 216.47,42.45 192,42.45 190.74,43.72 186.2,43.72 183.89,46.03 180.64,46.03 180.08,46.59 180.08,48.12 172.76,55.44 172.76,60.54 172.03,61.27 172.03,65.26 172.48,65.72 172.48,67.07 168.18,71.37 167.52,71.37 164.49,74.4 163.81,74.4 158.09,80.12 147.04,80.12 146.32,79.4 146.32,78.88 145.33,77.89 144.34,77.89 144.32,77.91 143.95,77.91 143.82,78.04 v4(143.82,78.22)
  IN2 w0.083: v4(228.44,78.68) 228.24,78.48 227.19,78.48 226.86,78.14 226.86,74.25 226.76,74.16 226.76,65.92 225.72,64.88 225.72,60.83 225.96,60.59 225.96,53.59 222.58,50.21 222.01,50.21 219.78,47.97 218.74,47.97 218.28,47.51 v4(218.28,46.86)
  GND5 w0.081: v4(143.82,78.22) 144.06,78.22 v5(144.33,77.95)
  GND5 w0.088: v4(228.44,78.68) 228.64,78.48 228.8,78.48 v5(228.95,78.63)
  BOTTOM w0.088: JNGFF2.41 229.43,78.65 229.27,78.49 229.09,78.49 v5(228.95,78.63)
PCIE_PRX_DTX_P9: length 181.9
  IN1 w0.062: v4(141.36,79.06) 141.14,79.28 140.91,79.28 140.03,80.16 140.03,82.01 139.4,82.64 134.99,82.64 134.77,82.85 132.54,82.85 132.41,82.73 129.79,82.73 129.18,83.34 129.18,84.44 128.88,84.74 112.3,84.74 110.06,86.97 94.89,86.97 92.95,85.03 78.37,85.03 77.22,85.51 65.89,85.51 64.92,84.53 58.77,84.53 57.4,83.16 51.39,83.16 48.43,80.2 46.7,80.2 45.64,79.13 45.64,76.72 41.43,72.51 41.43,61.82 41.87,61.38 41.87,56.33 42.09,56.11 42.09,52.33 41.76,51.99 41.76,47.84 41.15,47.24 41.15,46.41 39.73,44.98 39.73,44.25 38.96,43.48 38.96,40.96 37.75,39.75 37.75,39.05 37.4,38.71 37.4,34.8 30.78,28.18 30.78,24.91 30.44,24.57 30.44,22.66 30.19,22.4 29.88,22.4 v4(29.66,22.18)
  GND5 w0.076: v4(141.36,79.06) 141.4,79.1 141.64,79.1 141.96,78.78 v5(141.96,78.77)
  GND5 w0.088: v4(29.66,22.18) 29.84,22.36 30.07,22.36 v5(30.14,22.28)
  BOTTOM w0.076: UC1.E23 142.63,78.48 142.81,78.48 142.93,78.59 142.93,78.78 142.8,78.9 142.09,78.9 v5(141.96,78.77)
  BOTTOM w0.088: JNGFF3.7 32.85,15.1 32.94,15.2 33.09,15.2 33.18,15.29 33.18,16.34 v7(32.79,16.73) 32.43,17.09 32.43,17.81 32.38,17.86 32.38,18.6 31.87,19.1 31.87,21.24 30.64,22.48 30.39,22.48 30.2,22.28 v5(30.14,22.28)
PCIE_PRX_DTX_P10: length 183.2
  IN1 w0.062: v4(142.48,78.56) 142.38,78.46 142.15,78.46 141.9,78.71 141.9,81.87 139.94,83.83 135.53,83.83 134.92,84.43 130.83,84.43 129.36,85.9 112.97,85.9 110.73,88.14 94.41,88.14 92.73,86.47 84.5,86.47 83.58,87.39 71.89,87.39 71.17,86.67 64.24,86.67 63.27,85.7 58.29,85.7 56.94,84.35 50.86,84.35 48.03,81.53 46.16,81.53 44.33,79.7 44.33,77.13 40.26,73.06 40.26,61.74 39.9,61.38 39.9,54.5 40.28,54.12 40.28,52.16 40.59,51.86 40.59,48.33 39.99,47.72 39.99,46.9 38.56,45.47 38.56,44.73 37.77,43.95 37.77,41.42 35.97,39.62 35.97,38.35 35.79,38.17 35.79,36.86 31.08,32.15 31.08,32.14 28.45,29.5 28.45,22.5 28.15,22.2 28.15,21.15 v4(27.97,20.98)
  GND5 w0.076: v5(141.59,78.6) 141.84,78.35 142.27,78.35 v4(142.48,78.56)
  GND5 w0.088: v4(27.97,20.98) 28.2,20.75 28.2,20.24 28.11,20.15 v5(28.11,20.02)
  BOTTOM w0.088: v5(28.11,20.02) 28.11,19.94 28.23,19.82 28.23,19.64 29.12,18.75 29.12,18.69 29.53,18.27 29.59,18.27 29.7,18.17 29.7,16.08 30.02,15.76 30.02,15.13 29.85,14.96 JNGFF3.19
PCIE_PRX_DTX_P11: length 191.3
  IN1 w0.062: v4(140.26,78.28) 140.29,78.24 141.07,78.24 141.14,78.17 141.14,77.57 141.67,77.04 142.3,77.04 142.99,77.72 142.99,78.74 143.46,79.21 143.46,80.43 142.93,80.95 142.93,82.3 140.37,84.87 135.97,84.87 135.33,85.51 131.2,85.51 129.79,86.93 124.22,86.93 122.95,88.2 112.29,88.2 111.32,89.17 93.98,89.17 92.66,87.84 87.23,87.84 86.66,88.42 71.46,88.42 70.85,87.81 63.86,87.81 62.78,86.72 57.87,86.72 56.52,85.38 50.43,85.38 47.74,82.68 45.8,82.68 39.95,76.83 39.95,75.12 38.8,73.98 38.8,52.18 39.56,51.42 39.56,48.75 38.96,48.15 38.96,47.42 38.32,46.78 37.43,46.78 36.9,46.25 36.9,44.61 34.95,42.66 34.95,39.2 33.93,38.18 33.93,36.45 30.06,32.57 30.06,32.56 26.77,29.28 26.77,23.59 25.82,22.64 25.82,20.81 v4(25.65,20.63)
  GND5 w0.076: v4(140.26,78.28) 140.42,78.28 140.67,78.53 v5(140.67,78.6)
  GND5 w0.088: v5(25.77,19.95) 25.77,20.07 25.87,20.18 25.87,20.41 v4(25.65,20.63)
  BOTTOM w0.088: JNGFF3.31 26.85,14.96 27.01,15.12 27.01,16.25 27.01,17.91 v7(26.28,18.65) 25.87,19.05 25.87,19.77 25.77,19.87 v5(25.77,19.95)
PCIE_PRX_DTX_P12: length 172.9
  IN1 w0.062: v4(24.37,16.95) 24.15,16.73 24.15,16.58 24.21,16.52 27.13,16.52 31.48,20.88 31.48,24.12 31.57,24.21 31.65,24.29 31.66,24.29 31.87,24.5 31.87,27.06 33.3,28.5 33.3,29.41 41.59,37.7 41.59,41.11 41.74,41.26 41.74,43 43.46,44.72 43.46,46.28 44.56,47.38 44.56,70.91 53.3,79.65 57.79,79.65 59.51,81.37 68.74,81.37 69.71,82.33 93.88,82.33 95.46,83.92 109.25,83.92 112.23,80.94 112.23,80.51 112.96,79.78 116.02,79.78 116.43,79.37 132.22,79.37 132.69,78.89 135.48,78.89 135.98,79.38 139,79.38 139.28,79.1 139.28,78.57 139.05,78.33 138.52,78.33 v2(138.38,78.2)
  GND5 w0.088: v4(24.37,16.95) 24.17,16.76 24.17,16.01 24.29,15.89 v5(24.29,15.82)
  BOTTOM w0.076: UC1.F30 138.84,77.96 v2(138.38,78.2)
  BOTTOM w0.088: v5(24.29,15.82) 24.29,15.72 24.18,15.62 24.18,15.27 24.35,15.11 JNGFF3.41
PCIE_PRX_L_DTX_N7: length 5.4
  TOP w0.088: v2(227.63,81.04) 227.63,80.86 227.7,80.78 227.91,80.78 227.96,80.72 227.96,80.48 227.73,80.24 227.58,80.24 227.53,80.3 227.52,80.3 227.35,80.48 LI16.2 226.99,80.58 RI27.2
  BOTTOM w0.088: v2(227.63,81.04) 227.73,81.14 227.73,81.63 227.94,81.84 228.6,81.84 228.8,81.65 JNGFF2.29
PCIE_PRX_L_DTX_P7: length 5.4
  TOP w0.088: v2(228.21,81.05) 228.13,80.98 228.13,80.41 227.8,80.07 227.42,80.07 227.33,79.98 LI16.3 226.99,79.87 RI28.2
  BOTTOM w0.088: JNGFF2.31 229.48,81.15 229.15,81.48 228.72,81.48 228.53,81.67 228.01,81.67 227.9,81.56 227.9,81.43 228.01,81.31 228.13,81.31 228.21,81.24 v2(228.21,81.05)
PCIE_PRX_SW_DTX_N7: length 26.5
  TOP w0.088: v3(225.14,80.44) 225.28,80.31 225.43,80.31 225.6,80.48 LI16.1 225.85,80.48 RI27.1 ; UZ29.4 228.48,63.19 228.62,63.34 228.62,63.6 v2(228.42,63.81)
  GND1 w0.088: v4(225.83,80.49) 225.63,80.3 225.29,80.3 v3(225.14,80.44)
  IN1 w0.062: v4(225.83,80.49) 225.66,80.32 225.19,80.32 225,80.14 225,79.62 225.38,79.24 226.22,79.24 226.99,78.47 226.99,76.84 227.44,76.39 228.72,76.39 228.87,76.55 229.17,76.55 229.41,76.31 229.41,76.01 229.41,76.01 229.41,75.99 229.18,75.76 229.16,75.76 228.44,75.04 228.44,73.31 228.26,73.14 227.55,73.14 226.84,72.42 226.84,66.66 227.58,65.92 228.03,65.92 228.49,65.46 228.49,63.88 v2(228.42,63.81)
PCIE_PRX_SW_DTX_P7: length 26.5
  TOP w0.088: UZ29.3 228.98,63.17 228.8,63.36 228.8,63.6 v2(229,63.81) ; RI28.1 LI16.4 225.64,79.98 225.48,80.13 225.27,80.13 v3(225.14,80.01)
  GND1 w0.088: v3(225.14,80.01) 225.25,80.12 225.61,80.12 v4(225.83,79.91)
  IN1 w0.062: v2(229,63.81) 228.64,64.18 228.64,65.53 228.09,66.07 227.64,66.07 226.98,66.72 226.98,72.36 227.61,72.99 228.32,72.99 228.58,73.25 228.58,74.98 229.22,75.62 229.24,75.62 229.56,75.93 229.56,75.95 229.56,75.95 229.56,76.37 229.23,76.69 228.81,76.69 228.66,76.54 227.5,76.54 227.14,76.9 227.14,78.53 226.28,79.38 225.44,79.38 225.14,79.68 225.14,80.08 225.24,80.17 225.41,80.17 225.47,80.11 225.47,79.98 225.54,79.91 v4(225.83,79.91)
PCIE_PTX_C_DRX_N1: length 4.1
  BOTTOM w0.076: 36.81,53.04 36.81,53.06 36.81,53.06 36.81,53.24 36.88,53.31 arc(36.92,53.38) 36.94,53.46 36.94,53.62 arc(36.91,53.76) 36.83,53.88 UT1.Y22
  BOTTOM w0.088: CT3.2 38.7,51.55 38.7,52 38.57,52.12 38.48,52.21 arc(37.82,52.65) 37.04,52.81 36.92,52.81 36.81,52.91 36.81,53.04
PCIE_PTX_C_DRX_N2: length 3.4
  BOTTOM w0.076: 34.98,53.05 34.98,53.07 34.97,53.07 34.97,53.17 arc(34.98,53.24) 35.03,53.3 35.04,53.32 arc(35.08,53.38) 35.1,53.46 35.1,53.62 arc(35.07,53.76) 34.99,53.88 UT1.T22
  BOTTOM w0.088: 34.98,53.05 34.98,53.03 35.16,52.84 35.26,52.8 35.7,52.36 35.7,52.3 36.01,51.99 36.01,51.48 CT5.2
PCIE_PTX_C_DRX_N3: length 3.1
  BOTTOM w0.076: UT1.M22 33.15,53.88 arc(33.23,53.76) 33.26,53.62 33.26,53.46 arc(33.24,53.38) 33.2,53.32 33.13,53.25 33.13,53.24 33.13,53.07 33.14,53.06 33.14,53.04
  BOTTOM w0.088: CT124.2 33.45,51.5 33.45,52.26 33.14,52.57 33.14,53.04
PCIE_PTX_C_DRX_N4: length 3.3
  BOTTOM w0.076: UT1.H22 31.31,53.88 arc(31.39,53.76) 31.42,53.62 31.42,53.46 arc(31.4,53.38) 31.36,53.32 31.35,53.3 arc(31.3,53.23) 31.28,53.14 31.28,53.02 31.28,53.02 31.28,53
  BOTTOM w0.088: 31.28,53 31.28,52.49 30.67,51.87 30.67,51.44 CT126.2
PCIE_PTX_C_DRX_N5: length 4.6
  BOTTOM w0.088: CZ13.2 238.85,49.82 238.97,49.82 239.06,49.73 239.06,47.71 239.43,47.35 239.87,47.35 240.07,47.15 JNGFF1.37
PCIE_PTX_C_DRX_N8: length 5.2
  TOP w0.088: CZ10.2 227.38,75.94 227.47,76.03 227.47,76.35 227.57,76.46 227.82,76.46 228.14,76.14 228.14,76.01 v2(227.94,75.81)
  BOTTOM w0.088: v2(227.94,75.81) 228,75.87 228,76.41 228.73,77.15 JNGFF2.47
PCIE_PTX_C_DRX_N9: length 2.9
  BOTTOM w0.088: JNGFF3.11 31.85,14.94 31.66,15.13 31.66,15.45 31.2,15.91 31.2,16.43 CN65.1
PCIE_PTX_C_DRX_N10: length 2.8
  BOTTOM w0.088: JNGFF3.23 28.85,14.96 28.69,15.12 28.69,16.06 28.52,16.22 28.52,16.42 CN67.1
PCIE_PTX_C_DRX_N11: length 2.8
  BOTTOM w0.088: JNGFF3.35 25.85,14.94 25.68,15.11 25.68,16.12 25.59,16.21 25.59,16.41 CN69.1
PCIE_PTX_C_DRX_N12: length 2.7
  BOTTOM w0.088: JNGFF3.47 22.85,15.04 22.68,15.2 22.68,16.42 CN71.1
PCIE_PTX_C_DRX_P1: length 4.1
  BOTTOM w0.076: UT1.Y23 36.71,53.62 arc(36.6,53.73) 36.49,53.62 36.49,53.48 arc(36.5,53.38) 36.56,53.3 36.65,53.21 36.65,53.06 36.64,53.06 36.64,53.04
  BOTTOM w0.088: 36.64,53.04 36.64,52.84 36.85,52.64 37.04,52.64 arc(37.75,52.5) 38.36,52.09 38.4,52.05 38.4,52.05 38.52,51.93 38.52,51.6 CT2.2
PCIE_PTX_C_DRX_P2: length 3.3
  BOTTOM w0.076: UT1.T23 34.87,53.62 arc(34.83,53.71) 34.75,53.74 arc(34.68,53.71) 34.65,53.63 34.65,53.48 arc(34.66,53.38) 34.72,53.3 34.76,53.26 arc(34.79,53.21) 34.8,53.15 34.8,53.07 34.8,53.05
  BOTTOM w0.088: 34.8,53.05 34.8,52.95 v7(35.34,52.42) 35.84,51.92 35.84,51.5 CT4.2
PCIE_PTX_C_DRX_P3: length 3.1
  BOTTOM w0.076: 32.97,53.04 32.97,53.06 32.97,53.07 32.97,53.2 32.88,53.3 arc(32.82,53.38) 32.81,53.48 32.81,53.64 arc(32.92,53.75) 33.03,53.64 UT1.M23
  BOTTOM w0.088: 32.97,53.04 32.97,52.5 33.28,52.19 33.28,51.48 CT123.2
PCIE_PTX_C_DRX_P4: length 3.3
  BOTTOM w0.076: 31.11,53 31.11,53.02 31.12,53.02 31.12,53.11 arc(31.1,53.21) 31.04,53.3 arc(30.98,53.38) 30.97,53.48 30.97,53.64 arc(31,53.71) 31.07,53.75 arc(31.15,53.71) 31.19,53.63 UT1.H23
  BOTTOM w0.088: CT125.2 30.5,51.45 30.5,51.95 31.11,52.56 31.11,53
PCIE_PTX_C_DRX_P5: length 4.6
  BOTTOM w0.088: JNGFF1.35 240.09,47.65 239.96,47.52 239.5,47.52 239.23,47.79 239.23,49.8 239.05,49.99 238.91,49.99 CZ12.2
PCIE_PTX_C_DRX_P8: length 5.1
  TOP w0.088: v2(228.52,75.81) 228.31,76.02 228.31,76.21 227.89,76.63 227.25,76.63 CZ11.2
  BOTTOM w0.088: v2(228.52,75.81) 228.17,76.16 228.17,76.34 228.8,76.98 229.13,76.98 229.46,76.65 JNGFF2.49
PCIE_PTX_C_DRX_P9: length 2.9
  BOTTOM w0.088: CN66.1 31.03,16.4 31.03,15.84 31.49,15.38 31.49,15.12 31.35,14.98 JNGFF3.13
PCIE_PTX_C_DRX_P10: length 2.8
  BOTTOM w0.088: CN68.1 28.35,16.41 28.35,16.15 28.52,15.99 28.52,15.13 28.35,14.96 JNGFF3.25
PCIE_PTX_C_DRX_P11: length 2.8
  BOTTOM w0.088: CN70.1 25.42,16.42 25.42,16.14 25.51,16.04 25.51,15.12 25.35,14.96 JNGFF3.37
PCIE_PTX_C_DRX_P12: length 2.7
  BOTTOM w0.088: CN72.1 22.51,16.41 22.51,15.2 22.35,15.04 JNGFF3.49
PCIE_PTX_C_SW_DRX_N7: length 2.1
  TOP w0.088: UZ29.12 225.98,59.73 226.14,59.57 226.14,59.22 226.22,59.13 226.22,58.69 CZ153.2
PCIE_PTX_C_SW_DRX_P7: length 2.1
  TOP w0.088: UZ29.13 226.48,59.76 226.31,59.6 226.31,59.29 226.4,59.2 226.4,58.69 CZ152.2
PCIE_PTX_DRX_N1: length 153.7
  IN2 w0.083: v4(147.87,85.56) 147.66,85.34 147.66,85.14 147.36,84.84 142.31,84.84 141.42,85.73 139.8,85.73 139.53,85.46 130.98,85.46 129.84,86.59 126,86.59 124.5,88.09 114.91,88.09 113.47,89.53 96.43,89.53 93.3,86.41 84.32,86.41 83.23,87.51 80.56,87.51 79.65,88.42 70.88,88.42 70.25,87.78 64.71,87.78 62.96,86.03 59.2,86.03 57.42,84.25 49.77,84.25 47.63,82.11 44.5,82.11 43.35,80.95 41.46,80.95 40.52,80.02 40.52,79.37 37.2,76.06 37.2,67.73 37.47,67.47 37.47,65.09 37.21,64.84 37.21,52.13 38.68,50.66 38.68,50.42 v4(38.88,50.22)
  GND5 w0.081: v5(147.77,85.07) 147.71,85.13 arc(147.68,85.18) 147.66,85.24 147.66,85.27 arc(147.68,85.34) 147.72,85.4 v4(147.87,85.56)
  GND5 w0.088: v4(38.88,50.22) 38.66,50.44 38.66,50.51 38.9,50.76 v5(38.9,50.76)
  BOTTOM w0.076: UC1.B17 arc(146.72,81.03) 146.85,81.42 arc(146.85,81.43) 146.86,81.44 arc(146.87,81.51) 146.87,81.58 146.87,81.74 146.87,82.83 arc(146.97,83.33) 147.25,83.75 147.44,83.93 arc(147.67,84.26) 147.79,84.65 arc(147.8,84.86) v5(147.77,85.07)
PCIE_PTX_DRX_N2: length 160.9
  IN2 w0.083: v4(148.23,86.08) 148.59,85.72 148.59,85.36 147.67,84.44 140.25,84.44 139.61,85.07 130.81,85.07 129.72,86.17 125.77,86.17 124.96,86.97 115.4,86.97 113.23,89.15 96.59,89.15 93.46,86.02 81.22,86.02 79.23,88.02 71.09,88.02 70.45,87.38 64.86,87.38 63.12,85.64 59.36,85.64 57.58,83.86 49.93,83.86 47.79,81.72 44.66,81.72 41.74,78.8 41.14,78.8 37.6,75.26 37.6,67.88 37.85,67.63 37.85,64.93 37.6,64.68 37.6,52.31 39.29,50.63 39.29,49.79 38.5,49.01 36.34,49.01 35.91,49.43 35.91,49.61 35.99,49.7 36.34,49.7 36.44,49.79 36.44,49.97 v4(36.21,50.19)
  GND5 w0.081: v4(148.23,86.08) 148.45,85.85 148.45,85.42 v5(148.36,85.32)
  GND5 w0.088: v5(36.2,50.71) 36,50.51 36,50.4 v4(36.21,50.19)
  BOTTOM w0.076: UC1.D16 146.88,80.14 146.84,80.23 arc(146.82,80.29) 146.81,80.35 146.81,80.43 arc(146.83,80.53) 146.87,80.62 arc(146.91,80.73) 146.94,80.85 arc(146.95,80.9) 146.96,80.94 arc(146.99,81.02) 147.01,81.09 arc(147.06,81.3) 147.07,81.51 147.07,82.62 arc(147.13,82.91) 147.29,83.15 148.31,84.18 148.31,84.18 arc(148.4,84.35) 148.43,84.54 148.43,84.94 arc(148.43,84.99) 148.44,85.05 148.44,85.12 arc(148.42,85.23) v5(148.36,85.32)
PCIE_PTX_DRX_N3: length 163.8
  IN2 w0.083: v4(146.3,86.67) 146.3,87 146.36,87.06 146.6,87.06 146.68,87.14 146.68,87.33 146.14,87.87 140.02,87.87 138.78,86.62 131.43,86.62 130.31,87.75 126.47,87.75 123.28,90.94 107.61,90.94 107.08,91.47 96.74,91.47 92.83,87.55 87.45,87.55 86.25,88.75 80.94,88.75 80.07,89.61 63.9,89.61 62,87.72 58.79,87.72 57.99,86.91 57.99,86.47 56.91,85.39 49.3,85.39 47.22,83.31 42.16,83.31 39.83,80.98 37.17,80.98 35.83,79.64 35.83,77.41 36.05,77.2 36.05,70.56 35.61,70.12 35.61,67.97 35.9,67.69 35.9,67.42 36.32,66.99 36.32,65.8 33.72,63.2 33.11,63.2 32.51,62.59 31.57,62.59 30.95,61.98 30.95,61.22 31.51,60.66 31.51,58.84 30.93,58.25 30.93,56.84 32.25,55.52 32.25,53.43 33.27,52.4 33.27,51.79 33.34,51.73 33.59,51.73 33.67,51.65 v4(33.67,51.37)
  GND5 w0.081: v5(146.4,86.09) 146.46,86.15 arc(146.49,86.2) 146.51,86.26 146.51,86.34 arc(146.48,86.46) 146.42,86.55 v4(146.3,86.67)
  GND5 w0.088: v4(33.67,51.37) 33.47,51.17 33.47,50.9 v5(33.66,50.71)
  BOTTOM w0.076: v5(146.4,86.09) arc(146.48,85.96) 146.51,85.82 146.51,84.39 arc(146.51,84.35) 146.48,84.32 146.44,84.27 arc(146.38,84.19) 146.36,84.09 146.36,81.92 arc(146.34,81.82) 146.28,81.72 146.22,81.65 arc(146.11,81.44) 146.11,81.2 arc(146.13,81.05) 146.12,80.9 arc(146.1,80.73) 146.11,80.55 146.14,80.41 arc(146.14,80.32) 146.12,80.23 arc(146.1,80.16) 146.08,80.09 arc(146.08,79.92) 146.11,79.76 arc(146.12,79.74) 146.13,79.71 arc(146.14,79.7) 146.15,79.68 146.15,79.68 arc(146.26,79.57) 146.42,79.52 146.5,79.44 arc(146.52,79.41) UC1.D17
PCIE_PTX_DRX_N4: length 158.8
  IN2 w0.083: v4(31.08,50.04) 31.08,50.31 31.03,50.37 30.74,50.37 30.68,50.43 30.68,50.69 30.81,50.82 32.04,50.82 32.18,50.68 33.89,50.68 34.39,51.18 34.39,56.49 33.55,57.33 33.55,61.12 33.98,61.55 34.25,61.55 34.63,61.92 34.63,62.43 34.36,62.7 34.36,63.03 36.89,65.56 36.89,67.23 36.49,67.63 36.49,67.93 36.21,68.22 36.21,69.89 36.62,70.3 36.62,76.34 39.77,79.49 39.77,80.07 41.34,81.64 43.23,81.64 44.31,82.73 47.44,82.73 49.53,84.82 57.18,84.82 58.97,86.62 62.72,86.62 64.46,88.36 64.47,88.36 65.51,88.36 66.15,89 79.87,89 80.71,88.17 86.02,88.17 87.21,86.98 93.06,86.98 96.19,90.11 113.74,90.11 115.17,88.67 124.73,88.67 126.23,87.17 130.07,87.17 131.22,86.03 139.2,86.03 140.45,87.28 144.87,87.28 144.93,87.23 144.93,87.06 144.86,87 144.63,87 144.53,86.9 v4(144.53,86.66)
  GND5 w0.081: v4(144.53,86.66) 144.72,86.47 144.72,86.28 v5(144.58,86.14)
  GND5 w0.088: v4(31.08,50.04) 30.9,50.22 v5(30.9,50.63)
  BOTTOM w0.076: UC1.B19 145.17,80.68 144.95,81.16 arc(144.93,81.21) 144.92,81.27 144.92,81.39 arc(144.92,81.4) 144.93,81.42 144.97,81.59 arc(144.98,81.62) 144.99,81.65 arc(144.99,81.71) 145,81.77 145,82.32 arc(144.97,82.44) 144.9,82.55 144.82,82.63 arc(144.71,82.79) 144.68,82.97 144.68,85.9 arc(144.65,86.03) v5(144.58,86.14)
PCIE_PTX_DRX_N5: length 127.3
  IN1 w0.062: v4(145.08,83.54) 145.15,83.47 145.15,82.79 145.42,82.53 154.73,82.53 156.14,81.11 157.8,81.11 161.11,77.81 163.12,77.81 169.26,71.67 169.26,70.93 173.45,66.74 173.45,55.92 173.45,55.82 182,47.27 183.18,47.27 186.37,44.09 190.89,44.09 191.42,43.55 197.44,43.55 197.97,43.02 197.99,43.02 198.01,42.99 198.08,42.99 198.09,42.98 215.05,42.98 216.63,44.56 216.63,46.7 217.19,47.26 225.92,47.26 226.43,46.74 232.63,46.74 233.2,47.31 235.42,47.31 v2(235.63,47.1)
  GND5 w0.081: v4(145.08,83.54) 145.48,83.14 v5(145.48,82.79)
  BOTTOM w0.076: UC1.C19 145.16,80.02 arc(145.07,79.86) 145.21,79.74 145.22,79.74 arc(145.28,79.74) 145.34,79.76 arc(145.42,79.81) 145.47,79.89 arc(145.47,80) 145.45,80.11 arc(145.41,80.35) 145.46,80.59 arc(145.48,80.68) 145.47,80.78 arc(145.44,80.87) 145.43,80.97 145.43,82.27 arc(145.46,82.4) 145.53,82.52 145.55,82.53 arc(145.57,82.56) 145.58,82.59 145.58,82.61 145.57,82.61 arc(145.56,82.68) 145.52,82.74 v5(145.48,82.79)
  BOTTOM w0.088: v2(235.63,47.1) 235.86,47.32 236.51,47.32 236.82,47.63 236.82,48.96 236.86,49 236.86,49.73 236.98,49.85 237.25,49.85 CZ13.1
PCIE_PTX_DRX_N7: length 125.8
  TOP w0.088: v2(185.78,48.85) 185.78,48.61 185.67,48.49 185.46,48.49 185.37,48.41 185.37,48.23 185.48,48.12 186.47,48.12 186.84,48.49 192.13,48.49 193.53,47.09 197.14,47.09 198.36,45.88 210.46,45.88 214.44,49.86 222.3,49.86 226.32,53.89 226.32,54.25 226.27,54.3 226.27,54.89 226.32,54.94 v7(226.32,56.1) 226.32,56.8 226.24,56.88 225.9,56.88 225.84,56.95 CZ153.1
  IN4 w0.062: v4(143.66,86.63) 143.41,86.37 143.41,85.79 143.68,85.51 146.35,85.51 147.06,84.8 164.27,84.8 165.69,83.39 168.86,83.39 170.99,81.26 170.99,79.95 172.19,78.75 172.19,75.82 176.26,71.75 176.26,66.08 177.91,64.44 177.91,63.79 178.84,62.86 178.84,61.04 180.18,59.7 180.18,58.58 181.54,57.22 181.54,53.89 185.58,49.86 185.58,49.05 v2(185.78,48.85)
  GND5 w0.081: v4(143.66,86.63) 143.46,86.43
  GND5 w0.088: 143.46,86.43 143.46,86.08 v5(143.58,85.97)
  BOTTOM w0.076: v5(143.58,85.97) 143.56,85.95 arc(143.48,85.83) 143.45,85.68 143.45,85.39 143.45,84.01 arc(143.46,83.93) 143.5,83.86 arc(143.61,83.65) 143.67,83.43 143.71,83.31 arc(143.82,83.06) 144.01,82.84 arc(144.26,82.51) 144.35,82.1 144.35,81.6 arc(144.27,81.11) UC1.B21
PCIE_PTX_DRX_N8: length 149
  TOP w0.088: CZ10.1 225.68,76.33 225.51,76.33 v3(225.38,76.2)
  GND1 w0.088: v3(225.38,76.2) 225.51,76.33 225.67,76.33 v4(225.87,76.12)
  IN1 w0.062: v4(215.58,48.56) 215.79,48.35 215.79,47.78 215.48,47.48 214.47,47.48 211.67,44.68 198.8,44.68 198.2,45.29 192.13,45.29 189.54,47.88 188.09,47.88 178.67,57.29 178.67,59.99 175.14,63.52 175.14,68.95 172.32,71.77 172.32,79.94 167.92,84.34 157.14,84.34 154.18,87.3 142.76,87.3 142.28,86.83 142.28,86.39 v4(142.05,86.16)
  IN2 w0.083: v4(215.58,48.56) 215.58,48.84 215.63,48.89 215.91,48.89 215.98,48.96 215.98,49.3 216.25,49.57 220.56,49.57 221.78,50.78 222.34,50.78 225.39,53.83 225.39,60.36 225.15,60.6 225.15,65.2 226.19,66.25 226.19,74.4 226.29,74.49 226.29,74.67 226.27,74.69 226.27,76.21 226.18,76.3 226.05,76.3 v4(225.87,76.12)
  GND5 w0.081: v4(142.05,86.16) 142.22,85.98 142.22,85.84 v5(142.09,85.7)
  BOTTOM w0.076: v5(142.09,85.7) arc(142.14,85.63) 142.16,85.54 142.16,84.26 arc(142.16,84.26) 142.16,84.25 arc(142.19,84.09) 142.29,83.95 142.84,83.39 arc(143.02,83.17) 143.13,82.92 arc(143.3,82.57) 143.57,82.29 arc(143.73,82.09) 143.76,81.84 arc(143.72,81.7) 143.67,81.58 arc(143.61,81.34) 143.64,81.09 arc(143.66,80.97) 143.65,80.86 arc(143.63,80.73) 143.63,80.61 arc(143.64,80.53) 143.66,80.46 arc(143.68,80.36) 143.66,80.25 arc(143.61,80.1) 143.59,79.93 143.59,79.93 arc(143.6,79.8) 143.64,79.67 arc(143.69,79.61) 143.75,79.55 143.85,79.46 arc(143.94,79.4) UC1.D21
PCIE_PTX_DRX_N9: length 176
  IN1 w0.062: v4(29.48,21.27) 29.48,21.2 29.31,21.03 29.21,21.03 29.07,21.17 29.07,22.17 29.15,22.26 29.15,29.23 31.74,31.82 31.74,31.88 36.45,36.59 36.45,37.75 36.63,37.94 36.63,39.35 38.45,41.17 38.45,43.7 39.21,44.46 39.21,45.2 40.64,46.63 40.64,47.45 41.24,48.05 41.24,52.13 40.94,52.43 40.94,54.43 40.64,54.73 40.64,61.1 40.92,61.38 40.92,72.75 45.11,76.94 45.11,79.38 46.55,80.83 48.33,80.83 51.19,83.69 57.21,83.69 58.56,85.04 64.71,85.04 65.68,86.02 83.75,86.02 83.97,85.8 92.99,85.8 94.68,87.49 110.46,87.49 112.7,85.25 129.09,85.25 130.58,83.75 134.64,83.75 135.23,83.16 139.68,83.16 140.79,82.04 140.79,81.25 140.96,81.08 140.96,80.65 141.02,80.59 141.25,80.59 v4(141.35,80.69)
  GND5 w0.076: v4(141.35,80.69) 141.35,80.7 141.7,81.05 142.21,81.05 v5(142.36,80.9)
  GND5 w0.088: v4(29.48,21.27) 29.69,21.06 29.91,21.06 v5(29.99,21.14)
  BOTTOM w0.088: UC1.B23 142.47,80.9 v5(142.36,80.9) ; v5(29.99,21.14) 30.03,21.14 30.13,21.03 30.44,21.03 31.32,20.16 31.32,19.3 31.37,19.25 31.37,18.66 31.32,18.61 31.32,17.91 CN65.2
PCIE_PTX_DRX_N10: length 180
  IN1 w0.062: v4(142.92,79.48) 142.63,79.48 142.54,79.57 142.54,79.79 142.27,80.07 142.27,82.04 140.1,84.2 135.67,84.2 135.05,84.83 130.96,84.83 129.51,86.27 113.16,86.27 110.92,88.51 94.26,88.51 92.93,87.18 87.38,87.18 87.38,87.18 86.96,87.18 86.38,87.76 71.73,87.76 71.01,87.04 64.09,87.04 63.12,86.07 58.14,86.07 56.79,84.72 50.71,84.72 47.92,81.94 45.99,81.94 43.93,79.87 43.93,77.94 39.9,73.91 39.9,61.93 39.51,61.54 39.51,52.4 40.22,51.69 40.22,48.48 39.62,47.88 39.62,47.07 38.12,45.57 38.12,44.91 37,43.78 37,41.17 35.61,39.78 35.61,38.52 34.74,37.65 34.74,36.33 30.71,32.3 30.71,32.29 28.06,29.63 28.06,23.45 26.94,22.34 26.94,21.98 v4(27.17,21.75)
  GND5 w0.076: v5(142.31,79.37) 142.42,79.48 v4(142.92,79.48)
  GND5 w0.088: v5(27.07,21.27) 27.07,21.3 26.95,21.41 26.95,21.53 v4(27.17,21.75)
  BOTTOM w0.088: v5(27.07,21.27) 27.07,21.19 26.96,21.09 26.96,19.78 v7(28.02,18.72) 28.51,18.23 28.51,18.05 CN67.2 ; v5(142.31,79.37) UC1.D23
PCIE_PTX_DRX_N11: length 183.2
  IN1 w0.062: v2(140.73,85.27) 140.96,85.51 140.96,85.63 140.67,85.92 131.31,85.92 129.94,87.3 124.37,87.3 123.1,88.56 112.44,88.56 111.47,89.54 93.83,89.54 92.5,88.21 87.38,88.21 86.73,88.86 66.23,88.86 65.54,88.17 63.62,88.17 63.13,87.68 56.98,87.68 55.35,86.05 50.06,86.05 47.09,83.07 45.68,83.07 39.51,76.91 39.51,76.35 38.18,75.01 38.18,70.91 38.35,70.74 38.35,51.19 37.91,50.75 37.91,48.96 38.6,48.27 38.6,47.58 38.18,47.16 37.25,47.16 36.38,46.29 36.38,44.61 34.56,42.79 34.56,39.33 33.16,37.92 33.16,36.19 29.69,32.73 29.69,32.71 25.89,28.91 25.89,26.41 26.19,26.11 26.19,23.57 24.99,22.36 24.99,19.95 25.36,19.58 25.36,19.19 25.44,19.11 25.8,19.11 25.9,19.01 25.9,18.74 v4(25.8,18.64)
  GND5 w0.088: v4(25.8,18.64) 25.59,18.43 25.59,17.78 25.68,17.69 v5(25.95,17.69)
  BOTTOM w0.076: UC1.D24 arc(141.91,79.97) 141.83,80.31 141.83,80.86 arc(141.85,80.94) 141.9,81.01 arc(141.93,81.06) 141.95,81.11 arc(141.96,81.26) 141.97,81.4 141.97,82.55 arc(141.95,82.63) 141.91,82.7 141.13,83.48 arc(140.99,83.69) 140.94,83.94 140.94,84.34 140.94,84.76 arc(140.88,85.04) v2(140.73,85.27)
PCIE_PTX_DRX_N12: length 175.6
  IN1 w0.062: v2(138.96,81.84) 138.96,81.53 139.02,81.47 139.33,81.47 139.38,81.42 139.38,81.05 138.23,79.9 135.67,79.9 135.25,79.49 132.86,79.49 132.46,79.89 117.73,79.89 117.06,80.56 115.53,80.56 114.56,81.54 112.37,81.54 109.45,84.46 95.28,84.46 93.67,82.85 69.49,82.85 69.07,82.42 64.86,82.42 64.32,81.88 59.3,81.88 57.59,80.17 53.1,80.17 44.05,71.12 44.05,47.6 42.95,46.5 42.95,44.93 40.78,42.76 40.78,39.29 41,39.08 41,37.84 32.79,29.63 32.79,28.71 31.25,27.17 31.25,24.85 30.9,24.5 30.9,21.03 27.7,17.82 22.65,17.82 22.52,17.95 22.52,18.09 22.84,18.41 v4(22.88,18.41)
  GND5 w0.088: v4(22.88,18.41) 22.67,18.21 22.67,18.05 v5(23.03,17.69)
  BOTTOM w0.076: UC1.A25 141.57,81.32 arc(141.55,81.21) 141.48,81.11 141.47,81.11 141.46,81.11 arc(141.35,81.13) 141.28,81.22 arc(141.13,81.62) 140.87,81.96 arc(140.86,81.97) 140.85,81.98 arc(140.45,82.29) 139.99,82.49 arc(139.69,82.53) 139.4,82.47 arc(139.39,82.47) 139.38,82.46 arc(139.33,82.44) 139.28,82.4 arc(139.21,82.35) 139.15,82.3 arc(139.1,82.22) 139.08,82.14 139.07,82.07 arc(139.03,81.94) v2(138.96,81.84)
PCIE_PTX_DRX_P1: length 153.7
  IN2 w0.083: v4(147.29,85.56) 147.48,85.37 147.48,85.21 147.29,85.02 142.39,85.02 141.5,85.91 139.72,85.91 139.45,85.64 131.05,85.64 129.92,86.78 126.08,86.78 124.58,88.27 114.99,88.27 113.54,89.72 96.35,89.72 93.23,86.59 84.4,86.59 83.3,87.69 80.64,87.69 79.72,88.6 70.81,88.6 70.17,87.97 64.64,87.97 62.88,86.22 59.12,86.22 57.34,84.43 49.69,84.43 47.55,82.29 44.43,82.29 43.27,81.14 41.38,81.14 40.34,80.09 40.34,79.45 37.02,76.13 37.02,67.66 37.28,67.39 37.28,65.17 37.03,64.91 37.03,52.05 38.5,50.58 38.5,50.42 v4(38.3,50.22)
  GND5 w0.081: v4(147.29,85.56) 147.44,85.4 arc(147.48,85.34) 147.5,85.27 147.5,85.24 arc(147.48,85.18) 147.45,85.13 v5(147.39,85.07)
  GND5 w0.088: v4(38.3,50.22) 38.49,50.41 38.49,50.56 38.29,50.76 v5(38.27,50.76)
  BOTTOM w0.076: v5(147.39,85.07) 147.34,85.07 arc(147.23,85.07) 147.16,85 147.13,84.93 arc(147.13,84.85) 147.18,84.79 147.18,84.79 arc(147.34,84.75) 147.5,84.77 147.51,84.77 arc(147.6,84.75) 147.63,84.67 arc(147.53,84.33) 147.32,84.05 147.14,83.87 arc(146.82,83.39) 146.71,82.83 146.71,81.74 146.71,81.58 arc(146.71,81.53) 146.7,81.48 arc(146.7,81.47) 146.7,81.46 arc(146.63,81.36) UC1.A17
PCIE_PTX_DRX_P2: length 161
  IN2 w0.083: v4(35.62,50.19) 35.73,50.09 35.73,49.36 36.26,48.82 38.57,48.82 39.47,49.72 39.47,50.71 37.79,52.39 37.79,64.6 38.04,64.85 38.04,67.71 37.79,67.96 37.79,75.19 41.22,78.62 41.82,78.62 44.74,81.54 47.87,81.54 50.01,83.68 57.66,83.68 59.44,85.46 63.2,85.46 64.94,87.2 70.53,87.2 71.16,87.84 79.15,87.84 81.15,85.84 93.54,85.84 96.66,88.96 113.16,88.96 115.33,86.79 124.89,86.79 125.7,85.98 129.64,85.98 130.74,84.89 139.54,84.89 140.17,84.25 147.74,84.25 148.77,85.28 148.77,86.04 v4(148.81,86.08)
  GND5 w0.081: v5(148.74,85.32) 148.62,85.44 148.62,85.88 v4(148.81,86.08)
  GND5 w0.088: v4(35.62,50.19) 35.83,50.4 35.83,50.51 v5(35.63,50.71)
  BOTTOM w0.076: v5(148.74,85.32) 148.65,85.18 arc(148.63,85.15) 148.62,85.11 arc(148.61,85.07) 148.6,85.03 arc(148.59,84.98) 148.59,84.94 148.59,84.54 arc(148.55,84.3) 148.44,84.09 148.43,84.08 arc(148.4,84.04) 148.37,84 147.41,83.04 arc(147.28,82.85) 147.23,82.62 147.23,81.51 arc(147.22,81.28) 147.17,81.05 arc(147.14,80.96) 147.11,80.88 arc(147.1,80.86) 147.1,80.84 147.1,80.78 arc(147.13,80.69) 147.21,80.65 arc(147.3,80.6) 147.35,80.5 147.4,80.28 arc(147.4,80.27) 147.4,80.26 arc(147.39,80.25) 147.39,80.25 arc(147.19,80.15) 147.09,80.35 UC1.C16
PCIE_PTX_DRX_P3: length 163.8
  IN2 w0.083: v4(146.88,86.67) 146.87,86.69 146.87,87.4 146.22,88.05 139.95,88.05 138.7,86.81 131.51,86.81 130.39,87.93 126.55,87.93 123.36,91.12 107.69,91.12 107.15,91.65 96.66,91.65 92.75,87.74 87.52,87.74 86.33,88.93 81.01,88.93 80.15,89.8 63.82,89.8 61.92,87.9 58.71,87.9 57.8,86.99 57.8,86.55 56.83,85.58 49.22,85.58 47.14,83.5 42.09,83.5 39.76,81.17 37.09,81.17 35.65,79.72 35.65,77.33 35.86,77.12 35.86,70.63 35.42,70.2 35.42,67.9 35.71,67.61 35.71,67.34 36.14,66.91 36.14,65.88 33.64,63.38 33.04,63.38 32.44,62.78 31.49,62.78 30.77,62.06 30.77,61.15 31.33,60.59 31.33,58.91 30.74,58.33 30.74,56.76 32.07,55.44 32.07,53.35 33.09,52.33 v4(33.09,51.37)
  GND5 w0.081: v4(146.88,86.67) 146.76,86.55 arc(146.7,86.46) 146.67,86.34 146.67,86.26 arc(146.69,86.2) 146.72,86.15 v5(146.78,86.09)
  GND5 w0.088: v5(33.09,50.71) 33.3,50.92 33.3,51.16 v4(33.09,51.37)
  BOTTOM w0.076: v5(146.78,86.09) 146.72,86.03 arc(146.69,85.98) 146.67,85.91 146.67,84.39 arc(146.65,84.29) 146.6,84.21 146.55,84.16 arc(146.53,84.13) 146.52,84.09 146.52,81.92 arc(146.49,81.76) 146.4,81.62 146.34,81.55 arc(146.27,81.4) 146.27,81.23 arc(146.29,81.05) 146.27,80.87 arc(146.26,80.73) 146.27,80.58 146.3,80.44 arc(146.3,80.31) 146.27,80.17 arc(146.26,80.12) 146.24,80.06 arc(146.24,79.93) 146.26,79.81 arc(146.27,79.8) 146.28,79.78 146.28,79.78 arc(146.36,79.7) 146.48,79.71 146.49,79.71 arc(146.58,79.81) 146.57,79.94 UC1.C17
PCIE_PTX_DRX_P4: length 158.8
  IN2 w0.083: v4(145.11,86.66) 145.11,87.31 144.95,87.47 140.38,87.47 139.12,86.22 131.29,86.22 130.15,87.36 126.31,87.36 124.81,88.86 115.25,88.86 113.82,90.29 96.11,90.29 92.99,87.17 87.28,87.17 86.1,88.35 80.79,88.35 79.95,89.19 66.08,89.19 65.43,88.54 64.4,88.54 64.4,88.54 64.39,88.54 62.65,86.8 58.89,86.8 57.1,85.01 49.46,85.01 47.37,82.91 44.24,82.91 43.15,81.83 41.26,81.83 39.58,80.15 39.58,79.56 36.43,76.41 36.43,70.37 36.03,69.97 36.03,68.14 36.31,67.86 36.31,67.55 36.71,67.15 36.71,65.64 34.17,63.1 34.17,62.63 34.44,62.36 34.44,62 34.17,61.73 33.9,61.73 33.37,61.2 33.37,57.25 34.21,56.41 34.21,51.26 33.81,50.87 32.25,50.87 32.11,51.01 30.74,51.01 30.5,50.77 v4(30.5,50.04)
  GND5 w0.081: v5(144.96,86.14) 144.9,86.2 144.9,86.45 v4(145.11,86.66)
  GND5 w0.088: v4(30.5,50.04) 30.27,50.27 v5(30.27,50.63)
  BOTTOM w0.076: v5(144.96,86.14) 145.11,86.14 arc(145.23,86.12) 145.33,86.05 145.33,86.05 arc(145.37,85.94) 145.33,85.84 145.33,85.84 arc(145.28,85.81) 145.23,85.8 144.97,85.8 arc(144.94,85.79) 144.91,85.77 144.87,85.74 arc(144.85,85.7) 144.84,85.66 144.84,85.66 144.84,82.97 arc(144.86,82.85) 144.93,82.75 145.02,82.66 arc(145.12,82.5) 145.16,82.32 145.16,81.75 arc(145.16,81.68) 145.15,81.62 145.12,81.51 arc(145.13,81.41) UC1.A19
PCIE_PTX_DRX_P5: length 127.2
  IN1 w0.062: v2(235.63,47.68) 235.4,47.46 233.14,47.46 232.57,46.89 226.49,46.89 225.98,47.41 217.13,47.41 216.48,46.76 216.48,44.62 214.99,43.13 198.15,43.13 198.14,43.14 198.07,43.14 198.05,43.17 198.03,43.17 197.5,43.7 191.48,43.7 190.95,44.23 186.43,44.23 183.24,47.42 182.06,47.42 173.6,55.88 173.6,55.98 173.59,55.98 173.59,66.8 169.4,70.99 169.4,71.73 163.18,77.95 161.17,77.95 157.86,81.26 156.2,81.26 154.79,82.67 145.48,82.67 145.3,82.85 145.3,83.14 145.36,83.2 145.57,83.2 145.66,83.3 v4(145.66,83.54)
  GND5 w0.081: v5(145.86,82.79) 145.85,82.8 145.85,82.85 145.64,83.06 145.64,83.21 145.58,83.27 145.58,83.46 v4(145.66,83.54)
  BOTTOM w0.076: v5(145.86,82.79) 145.77,82.7 145.75,82.66 arc(145.74,82.64) 145.74,82.61 145.74,82.59 arc(145.72,82.5) 145.67,82.42 145.65,82.4 arc(145.61,82.34) 145.59,82.27 145.59,80.97 arc(145.6,80.9) 145.62,80.83 arc(145.64,80.68) 145.61,80.52 arc(145.57,80.35) 145.6,80.17 arc(145.63,80.02) 145.62,79.86 arc(145.54,79.7) 145.39,79.6 arc(145.35,79.59) 145.31,79.58 145.23,79.51 arc(145.19,79.45) UC1.D19
  BOTTOM w0.088: v2(235.63,47.68) 235.82,47.49 236.44,47.49 236.65,47.71 v7(236.65,49.3) 236.65,49.76 236.91,50.02 237.25,50.02 CZ12.1
PCIE_PTX_DRX_P7: length 125.8
  TOP w0.088: v2(185.2,48.85) 185.2,48.16 185.41,47.95 186.54,47.95 186.91,48.32 192.06,48.32 193.45,46.92 197.07,46.92 198.28,45.71 210.53,45.71 214.51,49.69 222.37,49.69 226.5,53.82 v7(226.5,54.59) 226.5,55.75 226.55,55.8 226.55,56.39 226.5,56.44 226.5,57.09 CZ152.1
  IN4 w0.062: v4(143.07,86.63) 143.26,86.44 143.26,85.73 143.62,85.37 146.28,85.37 146.99,84.66 164.21,84.66 165.63,83.24 168.8,83.24 170.84,81.2 170.84,79.89 172.05,78.69 172.05,75.75 176.12,71.69 176.12,66.02 177.76,64.38 177.76,63.73 178.69,62.8 178.69,60.98 180.03,59.64 180.03,58.52 181.4,57.16 181.4,53.83 185.43,49.8 185.43,49.09 v2(185.2,48.85)
  GND5 w0.088: v5(143.17,85.96) 143.29,86.08 143.29,86.41 v4(143.07,86.63)
  BOTTOM w0.076: v5(143.17,85.96) 143.17,85.97 142.92,85.97 arc(142.86,85.94) 142.83,85.88 142.83,85.73 arc(142.85,85.68) 142.91,85.65 143.2,85.65 arc(143.23,85.65) 143.25,85.63 arc(143.28,85.59) 143.29,85.54 143.29,84.31 143.29,84.01 arc(143.31,83.88) 143.37,83.76 arc(143.39,83.74) 143.4,83.71 arc(143.47,83.56) 143.52,83.4 143.52,83.4 143.55,83.27 arc(143.69,82.97) 143.9,82.72 arc(144.11,82.44) 144.19,82.1 144.19,81.6 arc(144.19,81.52) 144.18,81.43 arc(144.14,81.36) 144.05,81.32 UC1.A21
