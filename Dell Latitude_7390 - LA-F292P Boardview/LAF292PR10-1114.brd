# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_CAB2: length 45.9
  IN1 w0.08: v2(129.24,62.75) 128.84,62.34 128.84,61.08 130.97,58.95 130.97,49.41 128.4,46.84 128.4,38.97 123.31,33.88 118.62,33.88 117.89,34.61 116.12,34.61 115.59,35.13 v2(115.59,35.32)
  BOTTOM w0.076: UC1.AT46 v2(129.24,62.75)
  BOTTOM w0.127: UD2.N2 115.77,35.5 v2(115.59,35.32) 115.69,35.22 115.69,34.62 117.38,32.94 RD13.2
DDR_A_CAB3: length 45.5
  IN1 w0.08: v2(128.33,61.46) 128.33,61.18 130.7,58.81 130.7,49.52 128.11,46.93 128.11,39.07 123.19,34.15 118.76,34.15 118.01,34.9 116.24,34.9 116,35.14 116,35.74 v2(115.42,36.32)
  BOTTOM w0.076: UC1.AU50 v2(128.33,61.46) ; 115.24,34.55 115.24,35.47 115.42,35.66 v2(115.42,36.32) UD2.N3
  BOTTOM w0.127: 115.24,34.55 116.42,33.36 RD14.2
DDR_A_CAB4: length 45.8
  IN1 w0.08: v2(127.41,61.49) 127.41,60.94 128.31,60.04 129.03,60.04 130.42,58.64 130.42,57.16 129.74,56.47 129.74,53.04 130.43,52.35 130.43,49.64 127.82,47.02 127.82,39.16 123.08,34.42 119.39,34.42 118,35.82 116.57,35.82 v2(116.08,36.31)
  BOTTOM w0.076: 116.17,34.78 116.05,34.9 116.05,35.45 116.08,35.48 v2(116.08,36.31) 116.08,36.37 UD2.M3 ; v2(127.41,61.49) 127.39,61.49 127.36,61.52 UC1.AU52
  BOTTOM w0.127: RD15.2 118.33,32.98 117.03,34.28 116.67,34.28 116.17,34.78
DDR_A_CAB5: length 45.9
  IN1 w0.08: v2(128.39,53.35) 128.07,53.35 127.99,53.27 127.99,53.02 127.86,52.89 127.86,52.76 127.99,52.63 127.99,52.22 127.7,51.94 127.7,51.77 127.82,51.65 127.82,51.5 127.93,51.39 128.16,51.39 128.24,51.47 128.24,51.6 128.34,51.7 128.49,51.7 128.59,51.6 128.59,51.06 128.48,50.95 127.52,50.95 127.4,50.84 127.4,50.67 127.52,50.55 128.48,50.55 128.59,50.44 128.59,50.27 128.48,50.15 127.52,50.15 127.4,50.04 127.4,49.87 127.52,49.75 128.48,49.75 128.59,49.64 128.59,49.47 128.48,49.35 127.52,49.35 127.4,49.24 127.4,49.07 127.52,48.95 127.65,48.95 127.73,48.87 127.73,48.72 127.59,48.58 127.39,48.58 127.22,48.75 127.07,48.75 125.77,47.45 125.77,38.64 124.5,37.38 123.72,37.38 123.61,37.27 123.61,36.93 123.74,36.8 123.74,36.61 123.54,36.41 123.4,36.41 123.32,36.49 123.32,36.61 123.22,36.71 122.45,36.71 122.33,36.6 122.33,35.92 122.12,35.7 121.28,35.7 121.15,35.82 120.39,35.82 120.33,35.88 119.7,35.88 119.6,35.98 119.6,36.25 119.68,36.33 v2(120.02,36.33)
  BOTTOM w0.076: UD2.F3 v2(120.02,36.33) 120.02,36.31 120.02,36.31 120.02,35.79 120.21,35.6 120.21,35.01 ; UC1.AY51 127.27,60.19 arc(127.3,60.07) 127.36,59.97 127.42,59.92 arc(127.48,59.82) 127.5,59.71 127.5,59.6 arc(127.5,59.59) 127.5,59.58 127.46,59.45 arc(127.45,59.43) 127.45,59.41 127.45,59.3 arc(127.45,59.29) 127.45,59.27 127.5,59.11 arc(127.52,59.07) 127.54,59.04 127.55,59.02 arc(127.59,58.98) 127.6,58.92 127.6,56.6 127.84,56.36
  BOTTOM w0.127: 127.84,56.36 127.9,56.3 127.9,53.84 v2(128.39,53.35) ; 120.21,35.01 120.97,34.25 121.74,34.25 RD16.2
DDR_A_CAB6: length 46
  IN1 w0.08: v2(128.33,62.19) 128.01,62.51 127.24,62.51 126.98,62.25 126.98,62.01 126.71,61.75 126.71,60.43 128.2,58.95 128.36,58.95 128.58,59.16 128.75,59.16 128.87,59.04 128.87,58.88 128.65,58.66 128.65,58.5 128.9,58.25 129.01,58.25 129.13,58.13 129.13,57.96 129.01,57.85 128.9,57.85 128.78,57.73 128.78,57.56 128.9,57.45 129.14,57.45 129.25,57.33 129.25,57.16 129.14,57.05 128.9,57.05 128.78,56.93 128.78,56.76 128.9,56.65 129.06,56.65 129.18,56.53 129.18,56.36 129.06,56.25 128.9,56.25 128.78,56.13 128.78,56 129.19,55.59 129.19,49.17 128.07,48.04 127.38,48.04 127.27,47.94 127.27,44.56 127.17,44.46 126.72,44.46 126.64,44.38 126.64,43.75 126.74,43.65 127.19,43.65 127.27,43.56 127.27,43.32 127.19,43.24 126.74,43.24 126.64,43.14 126.64,42.51 126.75,42.39 127.15,42.39 127.27,42.28 127.27,42.11 127.15,41.99 126.75,41.99 126.64,41.88 126.64,40.67 126.84,40.47 126.84,40.3 126.31,39.76 126.31,38.41 122.86,34.96 121.83,34.96 121.73,35.06 v2(121.73,35.29)
  BOTTOM w0.076: v2(128.33,62.19) 128.72,62.42 UC1.AT48 ; UD2.E3 121.32,36.36 121.32,35.79 121.73,35.38 v2(121.73,35.29)
  BOTTOM w0.127: RD17.2 124.96,32.9 123.66,34.2 122.64,34.2 121.73,35.11 v2(121.73,35.29)
DDR_A_CAB7: length 45.2
  IN1 w0.08: v2(127.42,62.1) 127.01,61.69 127.01,60.77 128.01,59.77 128.91,59.77 130.15,58.53 130.15,57.27 129.47,56.58 129.47,52.59 129.58,52.47 129.9,52.47 130.01,52.36 130.01,52.19 129.9,52.07 129.58,52.07 129.47,51.96 129.47,51.79 129.58,51.67 130.02,51.67 130.14,51.56 130.14,51.39 130.02,51.27 129.58,51.27 129.47,51.16 129.47,50.99 129.58,50.87 130.02,50.87 130.14,50.76 130.14,50.59 130.02,50.47 129.58,50.47 129.47,50.36 129.47,50.19 129.58,50.07 130.02,50.07 130.14,49.96 130.14,49.79 130.02,49.67 129.58,49.67 129.47,49.56 129.47,49.05 128.18,47.77 127.65,47.77 127.55,47.66 127.55,40.06 127.45,39.96 126.89,39.96 126.58,39.65 126.58,38.3 122.97,34.69 121.04,34.69 120.88,34.86 120.88,35.05 v2(121.15,35.32)
  BOTTOM w0.076: v2(127.42,62.1) 127.43,62.12 127.43,62.13 UC1.AT50
  BOTTOM w0.127: UD2.E2 120.97,35.5 v2(121.15,35.32) 121.15,35.04 121.59,34.59 121.83,34.59 122.67,33.76 123.34,33.76 124.04,33.06 RD18.2
DDR_A_CAB8: length 43.7
  IN1 w0.08: v2(122.34,35.37) 122.55,35.37 122.63,35.45 122.63,36.29 122.73,36.39 122.93,36.39 123.03,36.29 123.03,35.84 123.13,35.73 123.25,35.73 124.02,36.51 124.02,36.89 124.16,37.04 124.55,37.04 126.04,38.53 126.04,39.95 126.15,40.06 126.21,40.06 126.33,40.18 126.33,40.35 126.21,40.46 126.15,40.46 126.04,40.58 126.04,40.75 126.15,40.86 126.21,40.86 126.33,40.98 126.33,41.15 126.21,41.26 126.15,41.26 126.04,41.38 126.04,41.55 126.15,41.66 126.21,41.66 126.33,41.78 126.33,41.95 126.21,42.06 126.15,42.06 126.04,42.18 126.04,42.35 126.15,42.46 126.21,42.46 126.33,42.58 126.33,42.75 126.21,42.86 126.15,42.86 126.04,42.98 126.04,43.15 126.15,43.26 126.21,43.26 126.33,43.38 126.33,43.55 126.21,43.66 126.15,43.66 126.04,43.78 126.04,43.95 126.15,44.06 126.21,44.06 126.33,44.18 126.33,44.35 126.21,44.46 126.15,44.46 126.04,44.58 126.04,44.76 126.15,44.88 126.88,44.88 126.99,44.99 126.99,45.16 126.88,45.28 126.15,45.28 126.04,45.39 126.04,45.56 126.15,45.68 126.88,45.68 126.99,45.79 126.99,45.96 126.88,46.08 126.12,46.08 126.04,46.16 126.04,46.37 126.13,46.47 126.92,46.47 127,46.55 127,46.78 126.92,46.87 126.11,46.87 126.04,46.95 126.04,47.19 126.13,47.28 126.81,47.28 126.91,47.37 126.91,47.6 126.83,47.68 126.66,47.68 126.58,47.76 126.58,47.88 127.01,48.31 127.96,48.31 128.26,48.61 128.26,48.98 128.37,49.08 128.73,49.08 128.92,49.28 128.92,52.05 128.8,52.18 128.8,52.41 128.92,52.54 128.92,52.87 128.77,53.02 128.77,53.22 128.92,53.38 128.92,55.2 128.8,55.32 128.12,55.32 127.9,55.54 127.9,56.31 128,56.41 v2(128.37,56.41)
  BOTTOM w0.076: UC1.BB50 127.9,56.88 v2(128.37,56.41) ; v2(122.34,35.37) UD2.D2
  BOTTOM w0.127: RD19.2 124.12,34.73 122.78,34.73 122.34,35.17 v2(122.34,35.37)
DDR_A_CAB9: length 44.2
  IN1 w0.08: v2(128.31,57.67) 127.92,58.05 127.71,58.05 127.6,57.95 127.6,57.35 127.73,57.22 127.82,57.22 127.92,57.12 127.92,56.92 127.82,56.81 127.71,56.81 127.61,56.71 127.61,55.27 127.75,55.13 127.91,55.13 128.02,55.01 128.02,54.76 127.92,54.66 127.22,54.66 127.12,54.56 127.12,54.35 127.22,54.25 127.95,54.25 128.06,54.15 128.06,53.95 127.95,53.85 127.22,53.85 127.12,53.74 127.12,53.54 127.22,53.44 127.6,53.44 127.7,53.34 127.7,53.13 127.6,53.03 127.22,53.03 127.12,52.93 127.12,52.73 127.22,52.63 127.6,52.63 127.7,52.53 127.7,52.32 127.6,52.22 127.21,52.22 127.1,52.11 127.1,51.77 127.22,51.66 127.43,51.66 127.55,51.54 127.55,51.37 127.43,51.26 127.22,51.26 127.1,51.14 127.1,49.17 125.5,47.56 125.5,38.75 124.41,37.67 121.79,37.67 121.69,37.57 121.69,37.27 121.96,37 121.96,36.89 121.76,36.69 120.55,36.69 120.44,36.58 120.44,36.31 120.54,36.2 121.81,36.2 v2(121.93,36.32)
  BOTTOM w0.076: v2(128.31,57.67) 128.66,58.02 128.66,58.43 128.59,58.5 128.59,59.04 128.17,59.46 128.17,59.83 128.01,60 UC1.AY50 ; v2(121.93,36.32) UD2.C2
  BOTTOM w0.127: UD2.C2 122.4,35.91 122.8,35.52 124.28,35.52 RD20.2
DDR_A_CKE0: length 43.5
  IN2 w0.089: v2(102.64,35.42) 102.64,35.71 102.8,35.86 105.08,35.86 105.45,36.23 105.45,36.43 105.82,36.8 106.23,36.8 109.15,39.72 109.15,40.4 109.34,40.59 109.34,43.39 116.11,50.16 122.61,50.16 124.12,51.67 124.12,53.42 124.36,53.67 v2(124.73,53.67)
  BOTTOM w0.076: 124.09,55.15 124.09,58.19 123.96,58.32 123.96,58.83 123.97,58.85 123.97,58.86 124.06,59.04 124.22,59.2 UC1.BA56 ; UD1.K3 102.15,36.42 102.48,36.08 102.48,35.58 v2(102.64,35.42)
  BOTTOM w0.127: 124.09,55.15 124.09,54.01 124.44,53.67 v2(124.73,53.67) ; RD24.1 102.14,33.14 102.67,33.67 102.67,35.39 v2(102.64,35.42)
DDR_A_CKE1: length 43.6
  IN2 w0.089: v2(102.04,35.43) 102.04,35.95 102.29,36.2 104.37,36.2 105.4,37.23 106.18,37.23 108.86,39.91 108.86,40.51 109.06,40.71 109.06,43.51 115.99,50.44 122.5,50.44 123.84,51.79 123.84,53.54 124.04,53.74 124.04,54.13 124.33,54.43 124.58,54.68 124.6,54.68 v2(124.75,54.83)
  BOTTOM w0.076: UD1.K4 101.85,37.21 101.85,35.74 102.01,35.57 102.01,35.45 v2(102.04,35.43) ; UC1.BB56 124.13,58.61 124.13,58.39 124.26,58.26 124.26,55.33 v2(124.75,54.83)
  BOTTOM w0.127: v2(102.04,35.43) 102.04,34.35 101.18,33.5 RD25.1
DDR_A_CKE2: length 47.5
  IN1 w0.08: v2(118.02,37.1) 118.41,37.5 118.88,37.5 118.88,37.5 119.48,37.5 119.77,37.79 119.77,38.14 119.88,38.24 120.16,38.24 120.26,38.34 120.26,38.54 120.16,38.65 119.88,38.65 119.77,38.75 119.77,39.11 119.96,39.29 120.22,39.29 120.39,39.12 120.96,39.12 121.06,39.22 121.06,39.41 121.16,39.51 121.41,39.51 121.51,39.41 121.51,39.18 121.62,39.08 121.82,39.08 121.92,39.18 121.92,39.69 122.02,39.79 122.23,39.79 122.33,39.69 122.33,39.22 122.43,39.11 122.63,39.11 122.73,39.22 122.73,39.46 122.83,39.56 123.04,39.56 123.14,39.46 123.14,39.22 123.24,39.12 123.44,39.12 123.55,39.22 123.55,39.54 123.94,39.93 124.05,39.93 124.27,39.72 124.41,39.72 124.52,39.83 124.52,40.04 124.42,40.14 124.42,40.28 124.52,40.38 124.52,41.45 124.52,42.14 124.42,42.24 124.07,42.24 123.97,42.34 123.97,42.54 124.07,42.65 124.42,42.65 124.52,42.75 124.52,43.12 124.4,43.23 124.11,43.23 124,43.35 124,43.52 124.11,43.63 124.4,43.63 124.52,43.75 124.52,43.92 124.4,44.03 124.14,44.03 124.02,44.15 124.02,44.32 124.14,44.43 124.4,44.43 124.52,44.55 124.52,44.72 124.4,44.83 124.21,44.83 124.1,44.95 124.1,45.12 124.21,45.23 124.4,45.23 124.52,45.35 124.52,45.52 124.4,45.63 124.21,45.63 124.1,45.75 124.1,45.92 124.21,46.03 124.4,46.03 124.52,46.15 124.52,46.32 124.4,46.43 124.21,46.43 124.1,46.55 124.1,46.72 124.21,46.83 124.4,46.83 124.52,46.95 124.52,47.12 124.4,47.23 124.21,47.23 124.1,47.35 124.1,47.52 124.21,47.63 124.4,47.63 124.52,47.75 124.52,47.99 125.51,48.97 125.51,56.71 125.93,57.13 125.93,58.07 125.8,58.2 125.49,58.2 125.37,58.08 125.37,57.45 124.91,56.99 v2(124.68,56.99)
  BOTTOM w0.076: UC1.AW56 124.47,60.39 124.47,59.21 124.46,59.19 124.46,58.85 124.47,58.83 124.47,58.49 124.43,58.45 124.43,57.23 v2(124.68,56.99) ; v2(118.02,37.1) UD2.K3 117.72,36.61 117.42,36.31 117.42,35.74 117.42,35.53 117.48,35.47 117.48,35.22 117.76,34.94
  BOTTOM w0.127: 117.76,34.94 119.22,33.49 119.65,33.49 RD79.1
DDR_A_CKE3: length 47.7
  IN1 w0.08: v2(117.37,37.91) 117.37,37.61 117.47,37.51 118.01,37.51 118.3,37.79 118.3,38.3 118.2,38.4 117.92,38.4 117.8,38.53 117.8,39.27 117.95,39.42 118.21,39.42 118.49,39.14 119.36,39.14 119.65,39.43 119.65,39.71 119.76,39.82 120.28,39.82 120.39,39.72 120.39,39.53 120.49,39.43 120.69,39.43 120.79,39.53 120.79,39.72 120.89,39.82 121.64,39.82 121.77,39.95 121.77,40.56 121.88,40.67 122.72,40.67 122.83,40.57 122.83,39.95 122.93,39.85 123.46,39.85 123.67,40.06 123.67,41.23 123.4,41.5 122.99,41.5 122.89,41.59 122.52,41.59 122.39,41.72 122.39,42.12 122.52,42.26 122.95,42.26 123.02,42.33 123.43,42.33 123.67,42.57 123.67,43.29 123.55,43.4 122.92,43.4 122.8,43.52 122.8,43.69 122.92,43.8 123.55,43.8 123.67,43.92 123.67,47.52 125.21,49.06 125.21,56.22 124.86,56.58 124.51,56.58 124.27,56.82 124.27,58.59 123.89,58.96 123.41,58.96 123.17,58.72 123.17,57.79 v2(123.57,57.39)
  BOTTOM w0.076: v2(123.57,57.39) 123.93,57.74 123.93,58.12 123.77,58.28 123.77,58.78 123.81,58.89 123.82,58.92 123.92,59.16 123.95,59.24 123.95,59.53 124.22,59.79 UC1.AY56 ; v2(117.37,37.91) 117.72,37.55 UD2.K4 117.37,37.16 117.37,36.59 117.08,36.31 117.04,36.31 116.76,36.03 116.76,35.04 116.97,34.83
  BOTTOM w0.127: 116.97,34.83 117.5,34.83 119.28,33.05 RD80.1
DDR_A_CLK0: length 46.4
  IN2 w0.104: v2(126.5,62.1) 126.27,62.1 126.13,61.96 126.13,61.73 124.15,59.75 120.28,59.75 116.98,56.45 116.98,54.97 108.24,46.23 105.32,46.23 103.59,44.49 103.59,44.29 103.14,43.85 103.14,43.17 101.32,41.34 101.32,40.07 102.9,38.49 102.9,38.14 102.9,38.1 v2(103.1,37.9)
  BOTTOM w0.076: v2(103.1,37.9) 103.12,37.88 103.12,37.41 103.37,37.16 103.37,37.05 103.28,36.96 103.15,36.96 102.99,37.12 102.88,37.12 102.8,37.03 UD1.J3 102.8,36.52 103.11,36.21 103.11,35.69 103.33,35.47 103.33,35.23 103.35,35.21 103.35,35.19 ; UC1.AT53 v2(126.5,62.1)
  BOTTOM w0.13: RD27.1 103.67,33.28 103.67,34.25 103.35,34.56 103.35,35.19
DDR_A_CLK1: length 41.1
  IN1 w0.094: v2(124.63,62.1) 124.46,61.93 124.22,61.93 123.99,61.7 123.99,61.21 124.57,60.63 124.57,60.5 124.38,60.31 124.38,60.02 124.63,59.78 124.92,59.78 125.1,59.96 125.24,59.96 126.52,58.68 126.52,49.41 124.91,47.81 124.91,38.99 124.2,38.27 120.88,38.27 119.68,37.07 118.66,37.07 118.26,36.66 118.26,36.5 v2(118.05,36.29)
  BOTTOM w0.076: v2(124.63,62.1) 124.85,62.27 UC1.AT55 ; 118.4,34.98 118.39,34.99 118.39,35.02 118.28,35.13 118.28,35.36 118.26,35.58 118.05,35.79 v2(118.05,36.29) 118.37,36.61 UD2.J3
  BOTTOM w0.13: RD33.1 121.55,33.26 121.55,33.36 121.36,33.55 120.5,33.55 120.06,33.99 119.39,33.99 118.4,34.98
DDR_A_CLK#0: length 45.6
  IN2 w0.104: v2(102.46,37.91) 102.71,38.16 102.71,38.42 101.13,40 101.13,41.42 102.96,43.25 102.96,43.93 103.4,44.37 103.4,44.57 105.24,46.41 108.16,46.41 116.8,55.05 116.8,56.52 120.21,59.94 124.08,59.94 125.95,61.81 125.95,61.98 125.83,62.1 v2(125.59,62.1)
  BOTTOM w0.076: UC1.AU53 v2(125.59,62.1) ; v2(102.46,37.91) 102.46,36.58 102.8,36.24 UD1.J2 102.95,35.76 102.95,35.62 103.16,35.4 103.16,35.23 103.14,35.21 103.14,35.19
  BOTTOM w0.13: 103.14,35.19 103.14,34.47 103.43,34.18 103.43,33.24 RD26.1
DDR_A_CLK#1: length 40.6
  IN1 w0.094: v2(124.63,61.47) 124.63,61.55 124.44,61.74 124.3,61.74 124.18,61.62 124.18,61.29 124.76,60.71 124.76,60.42 124.57,60.23 124.57,60.1 124.71,59.97 124.84,59.97 125.03,60.15 125.32,60.15 126.71,58.76 126.71,49.34 125.1,47.73 125.1,38.91 124.27,38.08 120.96,38.08 119.76,36.88 118.74,36.88 118.45,36.58 118.45,36.43 118.55,36.33 v2(118.7,36.33)
  BOTTOM w0.076: UC1.AU55 124.85,61.63 v2(124.63,61.47) ; 118.58,35.09 118.55,35.09 118.45,35.2 118.45,35.36 118.41,35.72 118.41,35.88 UD2.J2 118.37,36.07 118.62,36.33 v2(118.7,36.33)
  BOTTOM w0.13: 118.58,35.09 119.48,34.2 120.15,34.2 120.58,33.76 121.44,33.76 121.76,33.44 121.76,33.26 122.12,32.9 RD30.1
DDR_A_CS#0: length 63.2
  IN1 w0.08: v2(100.55,37.12) 107.42,37.12 107.68,36.86 110.71,36.86 v2(110.79,36.94) 110.79,36.46 111.09,36.15 111.22,36.15 111.59,35.79 111.59,35.16 111.69,35.06 111.89,35.06 111.99,35.16 111.99,35.49 112.1,35.59 112.3,35.59 112.4,35.49 112.4,35.09 112.5,34.98 112.7,34.98 112.81,35.09 112.81,35.49 112.91,35.59 113.11,35.59 113.21,35.49 113.21,35.27 113.31,35.17 113.52,35.17 113.62,35.27 113.62,35.75 113.72,35.85 114.28,35.85 114.53,36.1 114.53,36.82 115.2,37.5 116.37,37.5 v2(116.74,37.13)
  IN2 w0.089: v2(110.79,36.94) 111.23,37.39 111.23,39.47 112.33,40.57 112.38,40.57 112.7,40.89 112.7,41.34 113.64,42.27 116.27,42.27 116.62,42.62 116.62,43.3 118.61,45.29 119.22,45.29 121.58,47.66 122.8,47.66 127.16,52.02 127.16,54.43 127.66,54.93 127.66,59 v2(130.14,61.48)
  BOTTOM w0.076: UD1.L3 101.09,37.12 v2(100.55,37.12) ; UD2.L3 v2(116.74,37.13) ; UC1.AU45 v2(130.14,61.48)
  BOTTOM w0.127: v2(110.79,36.94) 110.69,36.84 110.69,35.31 111.23,34.77 111.23,33.93 111.66,33.5 RD21.1
DDR_A_CS#1: length 62.5
  IN1 w0.08: v2(116.74,37.93) 116.14,37.93 114.95,39.11 113.96,39.11 113.5,38.65 113.5,38.24 113.6,38.14 113.83,38.14 113.94,38.04 113.94,37.71 113.83,37.61 113.65,37.61 113.54,37.51 113.54,36.31 113.13,35.9 111.94,35.9 111.65,36.19 v2(111.65,37.52) 111.26,37.91 107.71,37.91 107.28,37.47 102.28,37.47 v2(101.82,37.93)
  IN2 w0.089: v2(131.07,61.48) 131.07,60.87 131.3,60.64 131.3,60.28 130.76,59.74 130.44,59.74 129.1,58.4 129.1,57.41 129.2,57.3 129.2,55.5 128.89,55.19 128.89,52.03 123.21,46.34 122.12,46.34 121.46,45.68 120.61,45.68 119.42,44.5 119.04,44.5 118.22,43.68 118.22,41.94 116.92,40.64 115.75,40.64 115.48,40.37 115.48,40.35 114.5,39.37 114.2,39.37 113.12,38.28 112.41,38.28 v2(111.65,37.52)
  BOTTOM w0.076: UD1.L4 v2(101.82,37.93) ; v2(131.07,61.48) 131.15,61.54 UC1.AU43 ; UD2.L4 v2(116.74,37.93)
  BOTTOM w0.127: v2(111.65,37.52) 111.65,34.17 112.61,33.21 RD22.1
DDR_A_D0: length 36.3
  IN4 w0.08: v2(100.5,40.32) 101.34,40.59 101.54,40.63 101.77,40.65 102.09,40.65 102.57,40.73 102.68,40.78 102.79,40.85 103.53,41.75 103.96,42.34 104.01,42.5 104.01,43.11 104.05,43.6 104.12,43.77 104.31,43.96 104.85,44.4 107.4,46.95 107.4,47.69 109.4,49.68 109.4,49.68 109.4,50.79 114.41,55.8 114.41,62.47 114.22,63.67 114.1,64.17 113.96,64.45 113.82,64.59 113.64,64.73 113.33,64.9 v2(112.39,65.11)
  BOTTOM w0.076: v2(112.39,65.11) 112.97,65.44 115.42,65.44 UC1.AL71 ; UD1.M8 v2(100.5,40.32)
DDR_A_D1: length 36.7
  IN4 w0.08: v2(100.52,41.09) 100.72,40.89 101.02,40.89 101.66,41.53 102.73,41.53 103.71,42.52 103.71,43.78 104.18,44.24 104.18,44.88 104.42,45.12 105.19,45.12 107.13,47.06 107.13,47.8 108.57,49.23 108.57,49.36 108.32,49.61 108.32,49.74 108.42,49.83 108.55,49.83 108.79,49.59 108.93,49.59 109.13,49.79 109.13,50.93 114.12,55.93 114.12,62.18 113.65,62.66 v2(113.65,64.19)
  BOTTOM w0.076: UC1.AL68 117.46,64.87 117.25,64.66 117.13,64.6 116.35,64.6 116.32,64.61 115.99,64.61 115.91,64.59 115.74,64.59 115.68,64.61 115.68,64.61 114.06,64.61 v2(113.65,64.19) ; UD1.M9 v2(100.52,41.09)
DDR_A_D2: length 37.9
  IN4 w0.08: v2(100.54,43.52) 100.81,43.52 101.65,44.36 101.65,46.51 102.42,47.28 102.94,47.28 103.03,47.37 103.03,47.62 103.12,47.71 103.26,47.71 103.35,47.62 103.35,47.37 103.44,47.28 103.58,47.28 103.67,47.37 103.67,47.62 103.76,47.71 103.9,47.71 103.99,47.62 103.99,47.37 104.08,47.28 104.22,47.28 104.31,47.37 104.31,47.79 104.4,47.89 104.54,47.89 104.63,47.79 104.63,47.37 104.72,47.28 105.06,47.28 105.61,47.82 105.61,48.41 105.51,48.5 105.04,48.5 104.94,48.6 104.94,48.73 105.04,48.82 105.51,48.82 105.61,48.92 105.61,49.05 105.51,49.14 104.99,49.14 104.89,49.24 104.89,49.37 104.99,49.46 105.51,49.46 105.61,49.56 105.61,49.94 111.76,56.09 111.76,58.88 111.51,59.36 111.51,59.88 111.37,60.01 111.37,61.04 110.82,61.59 v2(110.82,61.85)
  BOTTOM w0.076: UD1.N11 100.5,43.47 v2(100.54,43.52) ; 111.23,62.49 111.5,62.75 111.92,62.75 112.11,62.95 113.61,62.95 114.43,63.77 116.16,63.77 116.38,64 116.88,64 UC1.AN68
  BOTTOM w0.127: v2(110.82,61.85) 110.82,61.92 111.23,62.33 111.23,62.49
DDR_A_D3: length 36.6
  IN4 w0.08: v2(99.88,41.11) 99.88,41.41 99.98,41.51 101.22,41.51 101.54,41.82 102.62,41.82 102.87,42.07 102.87,42.2 102.61,42.45 102.61,42.59 102.71,42.68 102.84,42.68 103.09,42.43 103.23,42.43 103.42,42.62 103.42,43.91 103.79,44.28 103.79,44.88 104.3,45.39 105.08,45.39 106.86,47.17 106.86,47.91 108.04,49.09 108.04,50.26 108.26,50.47 108.39,50.47 108.63,50.23 108.76,50.23 108.86,50.33 108.86,50.46 108.62,50.7 108.62,50.83 113.83,56.05 113.83,62.04 113.25,62.62 v2(113.25,63.76)
  BOTTOM w0.076: UC1.AN69 116.55,64.29 116.45,64.39 116.29,64.45 116.02,64.45 115.94,64.42 115.69,64.42 115.67,64.43 115.66,64.44 115.64,64.45 114.4,64.45 113.72,63.76 v2(113.25,63.76) ; UD1.P9 v2(99.88,41.11)
DDR_A_D4: length 36.9
  IN4 w0.08: v2(111.39,64.49) 111.39,64.04 110.12,62.78 110.12,61.46 110.79,60.79 110.79,59.83 110.97,59.65 110.97,59.2 111.19,58.76 111.19,56.35 105.83,50.99 105.2,50.99 104.92,50.71 104.78,50.71 104.6,50.89 104.47,50.89 104.37,50.8 104.37,50.66 104.56,50.48 104.56,50.35 104.46,50.25 104.33,50.25 104.15,50.44 104.01,50.44 103.92,50.34 103.92,50.21 104.1,50.03 104.1,49.89 104.01,49.8 103.88,49.8 103.69,49.98 103.56,49.98 103.47,49.89 103.47,49.76 103.65,49.57 103.65,49.44 103.56,49.35 103.42,49.35 103.24,49.53 103.11,49.53 103.01,49.44 103.01,49.3 103.2,49.12 103.2,48.99 100.24,46.03 100.24,43.8 100.13,43.69 100.13,43.07 v2(100.5,42.71)
  BOTTOM w0.076: UD1.M10 v2(100.5,42.71) ; 111.47,65.3 111.6,65.43 111.72,65.43 111.9,65.6 115.19,65.6 115.36,65.77 115.63,65.77 115.7,65.75 115.83,65.69 116.01,65.52 UC1.AL70
  BOTTOM w0.127: 111.47,65.3 111.39,65.22 v1(111.39,65.05) v2(111.39,64.49)
DDR_A_D5: length 37.6
  IN4 w0.08: v2(110.85,64.74) 110.46,64.35 110.46,63.57 109.83,62.94 109.83,61.34 110.5,60.67 110.5,59.74 110.7,59.54 110.7,59.04 110.9,58.64 110.9,56.47 105.82,51.39 104.54,51.39 102.61,49.46 102.61,49.33 102.69,49.25 102.69,49.11 102.6,49.02 102.47,49.02 102.38,49.1 102.25,49.1 102.16,49.01 102.16,48.88 102.24,48.79 102.24,48.66 102.14,48.57 102.01,48.57 101.93,48.65 101.8,48.65 101.7,48.56 101.7,48.42 101.79,48.34 101.79,48.21 101.69,48.12 101.56,48.12 101.48,48.2 101.34,48.2 99.9,46.75 99.9,44.16 99.84,44.1 99.84,42.66 99.86,42.64 v2(99.86,41.92)
  BOTTOM w0.076: UD1.N10 v2(99.86,41.92) ; 111.25,65.62 111.4,65.77 115.12,65.77 115.29,65.94 115.66,65.94 115.7,65.93 115.77,65.91 115.85,65.9 115.98,65.86 116.16,65.79 116.54,65.79 UC1.AL69
  BOTTOM w0.127: v2(110.85,64.74) 110.85,65.22 111.25,65.62
DDR_A_D6: length 36.2
  IN4 w0.08: v2(111.11,63.02) 110.78,63.02 110.42,62.66 110.42,61.58 111.08,60.91 111.08,59.92 111.24,59.77 111.24,59.28 111.49,58.8 111.49,56.23 105.97,50.72 105.31,50.72 104.11,49.52 104.11,49.39 104.65,48.85 104.65,48.71 104.56,48.62 104.43,48.62 103.89,49.16 103.75,49.16 103.66,49.07 103.66,48.93 104.29,48.3 104.29,48.17 104.2,48.08 104.06,48.08 103.94,48.2 103.81,48.2 103.57,47.95 103.43,47.95 103.34,48.05 103.34,48.18 103.59,48.42 103.59,48.56 103.43,48.71 103.3,48.71 102.85,48.26 102.85,48.03 102.71,47.89 102.48,47.89 101.36,46.76 101.36,45.62 v2(100.69,44.95)
  BOTTOM w0.076: UD1.M11 101.15,43.41 101.15,44.49 v2(100.69,44.95) ; v2(111.11,63.02) 111.21,62.92 111.85,62.92 112.04,63.11 113.54,63.11 114.36,63.94 115.9,63.94 UC1.AN70
DDR_A_D7: length 34.8
  IN4 w0.08: v2(112.71,63.47) 112.84,63.34 112.84,62.6 113.54,61.9 113.54,56.17 107.39,50.02 107.39,49.88 107.77,49.5 107.77,49.37 107.68,49.27 107.54,49.27 107.16,49.66 107.03,49.66 106.59,49.22 106.59,49.03 106.69,48.93 106.96,48.93 107.05,48.84 107.05,48.71 106.96,48.61 106.69,48.61 106.59,48.52 106.59,47.28 105.1,45.79 104.32,45.79 103.28,44.75 103.28,44.33 103.06,44.11 102.95,44.11 102.85,44.01 102.85,43.76 102.95,43.66 102.97,43.66 103.07,43.56 103.07,43.2 102.97,43.1 102.35,43.1 102.24,42.99 102.24,42.25 102.11,42.12 100.7,42.12 v2(100.52,41.94)
  BOTTOM w0.076: v2(100.52,41.94) 100.5,41.91 UD1.N9 ; v2(112.71,63.47) 112.77,63.41 113.6,63.41 114.38,64.19 UC1.AN71
DDR_A_D8: length 38.3
  IN1 w0.08: v2(111.78,61.22) 111.18,60.62 111.18,56.3 107.99,53.12 107.03,53.12 102.48,48.57 100.02,48.57 98.91,47.46 98.33,47.46 95.49,44.62 95.49,42.26 96.49,41.26 97.25,41.26 97.79,40.73 98.32,40.73 98.57,40.47 v2(98.57,40.31)
  BOTTOM w0.076: UD1.R8 v2(98.57,40.31) ; v2(111.78,61.22) 112.23,61.67 112.23,62.17 112.63,62.58 113.78,62.58 114.49,63.28 115.22,63.28 115.36,63.42 115.65,63.42 115.91,63.16 UC1.AR70
DDR_A_D9: length 39.8
  IN1 w0.08: v2(111.65,62.4) 111.23,61.98 111.23,61.69 110.91,61.36 110.91,56.42 107.88,53.39 106.92,53.39 102.37,48.84 99.91,48.84 98.8,47.73 98.21,47.73 95.22,44.73 95.22,42.15 97.05,40.32 v2(97.9,40.32)
  BOTTOM w0.076: v2(111.65,62.4) 112.22,62.4 112.56,62.74 113.71,62.74 114.42,63.45 115.15,63.45 115.29,63.58 115.72,63.58 115.89,63.42 116.35,63.42 116.41,63.36 116.93,63.36 UC1.AR68 ; UD1.T8 v2(97.9,40.32)
DDR_A_D10: length 36.6
  IN1 w0.08: v2(112.92,58.76) 112.92,58.63 113.58,57.97 113.58,55.62 105.99,48.03 105.71,48.03 103.97,46.29 103.42,46.29 102.99,45.86 102.66,45.86 102.41,46.11 102.41,46.24 102.23,46.41 101.44,46.41 101.34,46.31 101.34,46.16 101.44,46.06 101.92,46.06 102.46,45.53 102.46,45.1 102.27,44.92 102.14,44.92 101.36,45.69 101.23,45.69 101.13,45.6 101.13,45.47 101.91,44.69 101.91,44.56 101.82,44.46 101.69,44.46 101.29,44.86 101.16,44.86 101.06,44.77 101.06,44.63 101.46,44.24 101.46,44.1 101.08,43.72 100.91,43.72 100.68,43.95 100.27,43.95 100.14,43.82 100.14,43.47 100.06,43.38 99.44,43.38 99.35,43.48 99.35,43.78 99.25,43.87 99.12,43.87 99.03,43.78 99.03,43.48 98.93,43.38 98.69,43.38 v2(98.56,43.52)
  BOTTOM w0.076: v2(112.92,58.76) 113.45,59.29 113.45,60.21 113.88,60.63 113.88,60.89 114.82,61.84 UC1.AU71 ; UD1.R11 v2(98.56,43.52)
DDR_A_D11: length 38.3
  IN1 w0.08: v2(112.92,61.89) 113.12,61.89 113.33,61.68 113.33,58.68 113.85,58.16 113.85,55.48 106.14,47.76 105.83,47.76 103.95,45.89 103.82,45.89 103.69,46.02 103.56,46.02 103.47,45.93 103.47,45.79 103.59,45.66 103.59,45.53 103.03,44.97 102.71,44.97 102.28,44.54 102.28,44.41 102.55,44.15 102.55,44.01 102.45,43.92 102.32,43.92 102.06,44.18 101.92,44.18 101.83,44.09 101.83,43.96 102.08,43.71 102.08,43.57 101.99,43.48 101.85,43.48 101.6,43.73 101.47,43.73 101.38,43.64 101.38,43.51 101.58,43.31 101.58,43.17 101.48,43.08 101.35,43.08 101.15,43.28 101.02,43.28 100.85,43.11 100.19,43.11 100.09,43.02 100.09,42.42 100,42.33 99.87,42.33 99.77,42.42 99.77,43.02 99.68,43.11 98.65,43.11 98.54,43.01 v2(98.54,42.73)
  BOTTOM w0.076: UC1.AU68 117.46,62.59 117.26,62.78 117,62.78 116.99,62.77 116.4,62.77 116.32,62.74 115.99,62.74 115.96,62.76 115.7,62.76 115.68,62.74 114.65,62.74 114.61,62.7 113.79,61.89 v2(112.92,61.89) ; UD1.R10 v2(98.54,42.73)
DDR_A_D12: length 37.1
  IN1 w0.08: v2(98.58,41.11) 98.47,41 97.9,41 97.37,41.53 96.6,41.53 95.76,42.37 95.76,44.51 98.44,47.19 99.02,47.19 100.13,48.3 102.59,48.3 106.53,52.23 107.49,52.23 107.61,52.35 107.61,52.49 107.49,52.61 107.49,52.74 107.58,52.84 107.71,52.84 107.84,52.71 107.97,52.71 111.45,56.19 111.45,60.51 111.58,60.64 v2(111.83,60.64)
  BOTTOM w0.076: v2(111.83,60.64) 112.39,61.2 112.39,61.49 112.4,61.5 112.4,62.11 112.7,62.41 113.85,62.41 114.53,63.1 115.44,63.1 UC1.AR71 ; UD1.T9 v2(98.58,41.11)
DDR_A_D13: length 38.3
  IN1 w0.08: v2(99.23,41.11) 99.23,41.26 98.77,41.72 97.56,41.72 97.46,41.82 96.7,41.82 96.54,41.97 96.54,42.1 96.68,42.23 96.68,42.37 96.58,42.46 96.45,42.46 96.32,42.33 96.18,42.33 96.03,42.48 96.03,44.39 98.53,46.9 99.12,46.9 100.18,47.96 102.73,47.96 106.72,51.95 107.62,51.95 111.74,56.07 111.74,59.28 v2(111.91,59.45)
  BOTTOM w0.076: UD1.R9 v2(99.23,41.11) ; UC1.AR69 116.74,63.06 116.29,62.91 116.02,62.91 115.99,62.92 115.66,62.92 115.64,62.91 114.58,62.91 113.91,62.24 112.77,62.24 112.56,62.04 112.56,61.43 112.55,61.42 112.55,60.09 v2(111.91,59.45)
DDR_A_D14: length 36.9
  IN1 w0.08: v2(97.93,42.74) 97.49,43.18 97.49,44.48 98.62,45.6 99.59,45.6 99.82,45.84 99.82,46.22 100.56,46.96 103.18,46.96 103.31,46.83 103.51,46.83 103.6,46.92 103.6,47.43 104.81,48.65 104.97,48.65 105.2,48.42 105.34,48.42 105.49,48.57 105.77,48.57 105.86,48.66 105.86,48.79 105.48,49.17 105.48,49.31 105.57,49.4 105.7,49.4 106.08,49.02 106.21,49.02 106.31,49.11 106.31,49.25 105.93,49.63 105.93,49.76 106.02,49.85 106.15,49.85 106.53,49.47 106.67,49.47 106.76,49.57 106.76,49.7 106.38,50.08 106.38,50.21 106.47,50.31 106.61,50.31 106.99,49.93 107.12,49.93 107.21,50.02 107.21,50.15 106.83,50.53 106.83,50.67 106.93,50.76 107.06,50.76 107.44,50.38 107.57,50.38 107.67,50.47 107.67,50.6 107.54,50.73 107.54,50.86 107.63,50.96 107.77,50.96 107.89,50.83 108.03,50.83 112.72,55.52 112.72,57.87 v2(112.91,58.07)
  BOTTOM w0.076: UC1.AU70 115.9,61.58 114.8,61.58 114.04,60.82 114.04,60.57 113.61,60.14 113.61,58.77 v2(112.91,58.07) ; UD1.T10 v2(97.93,42.74)
DDR_A_D15: length 37.4
  IN1 w0.08: v2(113.13,56.83) 113.31,56.65 113.31,56.42 113.22,56.33 113.09,56.33 113,56.24 113,56.1 113.09,56.01 113.22,56.01 113.31,55.92 113.31,55.73 105.88,48.3 105.6,48.3 105.28,47.99 105.15,47.99 105,48.14 104.87,48.14 104.77,48.04 104.77,47.91 104.92,47.76 104.92,47.63 104.83,47.53 104.7,47.53 104.55,47.69 104.41,47.69 104.32,47.59 104.32,47.46 104.47,47.31 104.47,47.17 104.38,47.08 104.25,47.08 104.09,47.23 103.96,47.23 103.87,47.14 103.87,47.01 104.02,46.85 104.02,46.72 103.86,46.56 103.2,46.56 103.07,46.69 100.68,46.69 100.09,46.11 100.09,45.98 100.25,45.83 100.25,45.68 100.15,45.59 99.96,45.59 99.87,45.5 99.87,45.36 99.96,45.27 100.15,45.27 100.25,45.18 100.25,45.04 100.15,44.95 99.96,44.95 99.87,44.86 99.87,44.72 99.96,44.63 100.15,44.63 100.25,44.54 100.25,44.31 100.09,44.15 99.11,44.15 99.01,44.25 99.01,45.23 98.92,45.32 98.79,45.32 98.69,45.23 98.69,44.89 98.62,44.81 98.32,44.81 98.24,44.74 98.24,44.56 98.32,44.48 98.62,44.48 98.69,44.41 98.69,44.01 98.61,43.93 98,43.93 97.92,43.85 v2(97.92,43.53)
  BOTTOM w0.076: UC1.AU69 116.39,61.42 114.87,61.42 114.21,60.76 114.21,60.5 113.78,60.07 113.78,57.48 v2(113.13,56.83) ; UD1.T11 v2(97.92,43.53)
DDR_A_D16: length 35.2
  IN4 w0.08: v2(119.72,67.41) 119.02,68.1 117.35,68.1 114.91,65.66 114.91,61.55 115.32,61.13 115.32,59.19 114.77,58.63 114.77,55.78 112.14,53.15 112.14,53.02 112.26,52.9 112.26,52.76 112.17,52.67 112.03,52.67 111.91,52.79 111.78,52.79 111.69,52.7 111.69,52.56 111.81,52.44 111.81,52.31 111.71,52.22 111.58,52.22 111.46,52.34 111.33,52.34 111.24,52.24 111.24,52.11 111.35,51.99 111.35,51.86 111.26,51.76 111.13,51.76 111.01,51.88 110.88,51.88 110.78,51.79 110.78,51.66 110.9,51.54 110.9,51.41 110.81,51.31 110.68,51.31 110.56,51.43 110.42,51.43 109.72,50.73 109.72,49.62 107.68,47.57 107.68,46.83 106.65,45.81 106.65,44.22 106.37,43.94 v2(106.37,43.53)
  BOTTOM w0.076: UC1.AF65 v2(119.72,67.41) ; UD1.C11 v2(106.37,43.53)
DDR_A_D17: length 33.6
  IN4 w0.08: v2(120.36,67.41) 119.9,66.95 117.43,66.95 115.79,65.3 115.79,61.97 116.2,61.56 116.2,58.82 115.64,58.27 115.64,54.6 113.58,52.53 113.58,51.72 111.97,50.11 111.36,50.11 108.58,47.33 108.58,45.14 108.32,44.89 108.02,44.89 107.76,45.15 v2(107.76,45.41)
  BOTTOM w0.076: UC1.AF64 v2(120.36,67.41) ; v2(107.76,45.41) 107.65,45.3 107.65,43.42 UD1.B11
DDR_A_D18: length 34.3
  IN4 w0.08: v2(119.72,65.58) 119.25,65.11 119.06,65.11 118.76,64.8 118.76,61.01 118.86,60.91 119.03,60.91 119.13,60.81 119.13,60.61 119.03,60.5 118.86,60.5 118.76,60.4 118.76,58.42 117.25,56.92 117.25,53.92 115.16,51.82 115.16,49.81 114.48,49.14 113.41,49.14 112.75,48.47 111.93,48.47 110.16,46.7 110.16,42.95 108.34,41.13 107.61,41.13 106.77,40.28 v2(106.38,40.28)
  BOTTOM w0.076: UD1.C8 v2(106.38,40.28) ; UC1.AK65 v2(119.72,65.58)
DDR_A_D19: length 35.1
  IN4 w0.08: v2(107.68,40.33) 108.1,40.33 108.31,40.12 108.45,40.12 108.59,40.26 108.59,40.41 108.38,40.62 108.38,40.76 108.53,40.9 108.67,40.9 108.88,40.69 109.03,40.69 109.17,40.84 109.17,40.98 108.96,41.19 108.96,41.34 109.1,41.48 109.25,41.48 109.33,41.4 109.47,41.4 109.62,41.54 109.62,41.68 109.53,41.77 109.53,41.91 110.45,42.82 110.45,45.79 113.53,48.87 114.95,48.87 115.45,49.37 115.45,51.7 117.54,53.79 117.54,56.8 119.54,58.79 119.54,59.52 119.44,59.63 119.2,59.63 119.1,59.73 119.1,59.93 119.2,60.03 119.44,60.03 119.55,60.14 119.55,64.77 v2(120.36,65.58)
  BOTTOM w0.076: UD1.B8 v2(107.68,40.33) ; UC1.AK64 v2(120.36,65.58)
DDR_A_D20: length 34.3
  IN4 w0.08: v2(119.09,67.41) 118.68,67.81 117.47,67.81 115.2,65.54 115.2,61.73 115.62,61.32 115.62,59.06 115.06,58.51 115.06,55.4 112.97,53.31 112.97,51.87 112.87,51.78 112.74,51.78 112.54,51.98 112.41,51.98 112.32,51.88 112.32,51.75 112.51,51.55 112.51,51.42 112.33,51.24 111.37,51.24 111.02,50.89 111.02,50.53 107.95,47.46 107.95,46.72 106.94,45.72 106.94,44.16 107.41,43.69 107.41,43.06 v2(107.06,42.71)
  BOTTOM w0.076: UC1.AF66 v2(119.09,67.41) ; UD1.C10 v2(107.06,42.71)
DDR_A_D21: length 34
  IN4 w0.08: v2(118.45,67.41) 117.48,67.41 115.49,65.42 115.49,61.85 115.91,61.44 115.91,58.94 115.35,58.39 115.35,54.71 115.17,54.53 115.04,54.53 114.9,54.67 114.77,54.67 114.68,54.57 114.68,54.44 114.81,54.31 114.81,54.17 114.72,54.08 114.59,54.08 114.45,54.21 114.32,54.21 114.23,54.12 114.23,53.99 114.36,53.85 114.36,53.72 114.27,53.63 114.13,53.63 114,53.76 113.87,53.76 113.77,53.67 113.77,53.54 113.91,53.4 113.91,53.27 113.81,53.18 113.68,53.18 113.55,53.31 113.41,53.31 113.32,53.22 113.32,53.08 113.45,52.95 113.45,52.82 113.24,52.6 113.24,51.76 111.85,50.38 111.24,50.38 108.24,47.37 108.24,46.47 107.35,45.58 107.35,44.34 107.81,43.88 107.81,42.83 v2(107.69,42.72)
  BOTTOM w0.076: UC1.AF67 v2(118.45,67.41) ; UD1.B10 v2(107.69,42.72)
DDR_A_D22: length 33
  IN4 w0.08: v2(118.45,65.58) 118.02,65.4 117.18,64.55 116.87,63.76 116.87,63.03 117.17,62.4 117.4,61.85 117.4,60.1 117.7,59.81 117.7,58.93 117.23,58.45 117.23,58.14 116.67,57.58 116.67,54.16 114.57,52.06 114.57,50.01 114.24,49.68 113.19,49.68 112.52,49.01 111.71,49.01 109.57,46.88 109.57,43.17 108.12,41.71 107.13,41.71 106.81,41.48 v2(106.35,41.1)
  BOTTOM w0.076: UC1.AK67 v2(118.45,65.58) ; UD1.C9 v2(106.35,41.1)
DDR_A_D23: length 33.5
  IN4 w0.08: v2(107.01,41.11) 107.33,41.42 108.22,41.42 109.86,43.07 109.86,46.79 111.82,48.74 112.64,48.74 113.3,49.41 114.37,49.41 114.86,49.91 114.86,51.94 116.96,54.04 116.96,57.35 117.52,57.91 117.52,58.33 117.99,58.81 117.99,59.07 118.09,59.17 118.32,59.17 118.42,59.27 118.42,59.48 118.32,59.58 118.1,59.58 117.99,59.68 117.99,59.88 118.09,59.98 118.13,59.98 118.23,60.09 118.23,60.29 118.13,60.39 118,60.39 117.86,60.52 117.86,64.82 118.1,65.06 118.57,65.06 v2(119.09,65.58)
  BOTTOM w0.076: UC1.AK66 v2(119.09,65.58) ; UD1.B9 v2(107.01,41.11)
DDR_A_D24: length 44.8
  IN1 w0.08: v2(105.68,41.12) 106.11,40.69 107.17,40.69 110.63,44.15 110.63,45.88 112.84,48.09 112.84,48.31 116.87,52.33 116.87,63.9 117.49,64.52 117.49,65.95 116.81,66.63 116.81,67.46 115.23,69.04 113.58,69.04 112.53,68.68 111.98,68.24 111.95,68.22 v2(111.64,67.93)
  BOTTOM w0.076: UD1.D9 v2(105.68,41.12) ; v2(111.64,67.93) 111.82,68.11 111.82,68.12 112.46,68.75 115.57,68.75 UC1.AF70
DDR_A_D25: length 46
  IN1 w0.08: v2(110.43,67.93) 110.05,67.55 110.05,66.31 110.84,65.52 112.9,65.52 114.05,64.36 114.05,64.01 113.3,63.25 113.3,62.09 113.62,61.77 113.62,58.81 114.12,58.3 114.12,55.34 113.97,55.18 113.97,55.04 114.07,54.93 114.07,54.79 113.93,54.65 113.78,54.65 113.68,54.75 113.54,54.75 106.28,47.49 105.94,47.49 103.32,44.87 103.32,41.4 104,40.72 104.68,40.72 v2(105.06,41.11)
  BOTTOM w0.076: UD1.E9 v2(105.06,41.11) ; 111.88,69.02 115.96,69.02 116.62,68.36 116.85,68.36 116.92,68.34 UC1.AF68
  BOTTOM w0.127: v2(110.43,67.93) 110.43,68.13 111.32,69.02 111.88,69.02
DDR_A_D26: length 43.6
  IN1 w0.08: v2(104.59,44.72) 104.3,44.43 104.3,44.07 104.45,43.92 104.71,43.92 105.24,44.44 105.24,45.55 106.15,46.47 106.86,46.47 107.01,46.31 107.19,46.31 107.51,46.64 107.51,46.8 107.22,47.1 107.22,47.26 107.33,47.38 107.5,47.38 107.79,47.09 107.96,47.09 108.08,47.2 108.08,47.37 107.78,47.66 107.78,47.83 107.9,47.95 108.07,47.95 108.36,47.65 108.53,47.65 108.64,47.77 108.64,47.94 108.35,48.23 108.35,48.4 108.47,48.51 108.63,48.51 108.93,48.22 109.09,48.22 109.21,48.34 109.21,48.5 108.91,48.8 108.91,48.96 109.03,49.08 109.2,49.08 109.49,48.78 109.66,48.78 109.78,48.9 110.22,48.9 110.38,49.07 110.38,49.23 110.3,49.31 109.54,49.31 109.46,49.39 109.46,49.53 109.63,49.7 110.42,49.7 110.97,50.25 111.14,50.25 111.37,50.02 111.5,50.02 111.6,50.12 111.6,50.27 112.12,50.79 112.26,50.79 112.36,50.9 112.36,51.04 112.06,51.34 112.06,51.5 112.84,52.28 113.32,52.28 113.47,52.43 113.47,52.92 113.98,53.43 114.47,53.43 114.57,53.53 114.57,53.98 115,54.41 115,58.67 114.49,59.17 114.49,61.31 114.61,61.43 114.89,61.43 115,61.54 115,61.71 114.89,61.83 114.61,61.83 114.49,61.94 114.49,62.11 114.61,62.23 114.89,62.23 115,62.34 115,62.51 114.89,62.63 114.61,62.63 114.49,62.74 114.49,62.92 115.02,63.44 115.02,64.62 114.7,64.93 114.7,65.09 114.78,65.17 114.94,65.17 115.02,65.25 115.02,65.6 114.9,65.72 113.98,65.72 113.87,65.82 113.87,66.02 113.98,66.12 114.9,66.12 115,66.22 115,66.45 v2(114.87,66.58)
  BOTTOM w0.076: v2(114.87,66.58) 115.24,66.58 UC1.AH71 ; UD1.F11 105.05,43.41 105.05,44.25 v2(104.59,44.72)
DDR_A_D27: length 45.9
  IN1 w0.08: v2(105.73,43.53) 106.17,43.97 106.55,43.97 106.66,44.07 106.66,45.09 106.76,45.2 106.96,45.2 107.06,45.09 107.06,44.07 107.16,43.97 107.37,43.97 107.47,44.07 107.47,44.62 107.57,44.73 107.77,44.73 107.87,44.62 107.87,44.28 107.96,44.19 108.27,44.19 108.45,44.37 108.45,44.52 108.27,44.7 108.27,44.84 108.41,44.99 108.56,44.99 108.74,44.8 108.88,44.8 109.06,44.98 109.06,45.35 108.96,45.45 108.25,45.45 108.15,45.55 108.15,45.76 108.25,45.86 108.93,45.86 109.03,45.96 109.03,46.72 109.14,46.82 109.34,46.82 109.44,46.72 109.44,46.46 109.54,46.36 109.96,46.36 110.08,46.48 110.08,46.64 109.57,47.14 109.57,47.31 109.69,47.43 109.86,47.43 110.36,46.92 110.53,46.92 110.88,47.28 110.88,47.41 110.76,47.53 110.35,47.53 110.23,47.64 110.23,47.81 110.35,47.93 110.76,47.93 110.88,48.04 110.88,48.19 111.45,48.76 112.15,48.76 115.99,52.61 115.99,67.04 114.87,68.17 114.45,68.17 v2(114.16,67.88)
  BOTTOM w0.076: v2(114.16,67.88) 114.44,68.16 114.86,68.16 115.27,67.75 115.67,67.75 115.73,67.77 115.93,67.77 115.98,67.75 116.32,67.75 116.35,67.76 117.17,67.76 117.25,67.7 117.46,67.5 UC1.AH68 ; UD1.E11 v2(105.73,43.53)
DDR_A_D28: length 43.5
  IN1 w0.08: v2(105.08,42.73) 105.5,42.3 105.88,42.3 105.99,42.2 105.99,41.58 106.07,41.5 106.67,41.5 106.8,41.63 106.8,41.69 106.9,41.79 107.1,41.79 107.2,41.69 107.2,41.63 107.3,41.52 107.59,41.52 110.36,44.3 110.36,46 111.42,47.05 111.42,47.96 111.68,48.22 112.37,48.22 116.58,52.42 116.58,63.99 117.22,64.64 117.22,65.84 116.54,66.52 116.54,67.32 115.11,68.75 113.82,68.75 113.43,68.36 112.69,68.36 v2(112.27,67.93)
  BOTTOM w0.076: v2(112.27,67.93) 112.8,68.46 v1(113.25,68.46) 113.86,68.46 113.89,68.49 115.19,68.49 UC1.AF71 ; UD1.F10 v2(105.08,42.73)
DDR_A_D29: length 45.2
  IN1 w0.08: v2(113.55,67.92) 114.09,68.46 114.99,68.46 116.27,67.18 116.27,66.4 116.95,65.72 116.95,64.75 116.29,64.08 116.29,52.52 112.26,48.49 111.56,48.49 111.15,48.08 111.15,47.17 110.07,46.09 109.45,46.09 109.35,45.99 109.35,45.78 109.45,45.68 109.97,45.68 110.08,45.58 110.08,45.37 109.97,45.27 109.47,45.27 109.35,45.15 109.35,44.91 109.44,44.81 109.94,44.81 110.09,44.66 110.09,44.41 109.71,44.03 109.46,44.03 109.02,44.46 108.88,44.46 108.74,44.32 108.74,44.17 109.22,43.69 109.22,43.55 109.07,43.41 108.93,43.41 108.44,43.9 108.29,43.9 108.15,43.76 108.15,43.61 108.63,43.13 108.63,42.99 108.49,42.84 108.34,42.84 107.74,43.44 107.57,43.44 107.24,43.11 105.81,43.11 105.71,43.01 v2(105.71,42.74)
  BOTTOM w0.076: UC1.AF69 116.7,67.97 116.44,67.97 116.29,67.92 116.02,67.92 115.96,67.94 115.7,67.94 115.64,67.92 115.34,67.92 114.93,68.32 113.95,68.32 v2(113.55,67.92) ; UD1.E10 v2(105.71,42.74)
DDR_A_D30: length 44.1
  IN1 w0.08: v2(105.08,41.93) 105.18,42.03 105.61,42.03 105.71,41.93 105.71,41.62 105.6,41.51 104.67,41.51 104.64,41.54 104.01,41.54 103.88,41.66 103.88,41.97 104.13,42.22 104.13,42.4 103.88,42.65 103.88,42.84 104.08,43.04 104.08,43.21 103.88,43.41 103.88,43.77 104.03,43.92 104.03,44.23 103.88,44.38 103.88,44.67 104.33,45.12 104.88,45.12 104.96,45.2 104.96,45.75 105.95,46.74 106.84,46.74 106.95,46.84 106.95,47.39 109.65,50.1 109.82,50.1 109.95,49.97 110.3,49.97 110.64,50.3 110.64,50.47 110.42,50.68 110.42,50.85 110.54,50.97 110.7,50.97 110.92,50.75 111.08,50.75 111.19,50.86 111.19,51.02 114.73,54.55 114.73,58.52 114.2,59.05 114.2,62.26 114.09,62.38 113.98,62.38 113.86,62.49 113.86,62.66 113.98,62.78 114.09,62.78 114.2,62.89 114.2,63.04 114.09,63.15 114.09,63.28 114.3,63.48 114.55,63.48 114.64,63.57 114.64,64.61 114.43,64.82 114.43,65.33 114.32,65.45 113.8,65.45 113.6,65.64 113.6,65.95 113.49,66.06 111.64,66.06 111.56,66.14 111.56,66.28 v2(111.8,66.52)
  BOTTOM w0.076: UC1.AH70 115.94,66.63 115.73,66.63 115.54,66.55 115.3,66.3 115.1,66.3 114.97,66.17 112.16,66.17 v2(111.8,66.52) ; UD1.F9 v2(105.08,41.93)
DDR_A_D31: length 45.1
  IN1 w0.08: v2(104.42,41.13) 104.01,41.13 103.61,41.53 103.61,44.78 105.83,47.01 106.58,47.01 106.68,47.1 106.68,47.51 110.43,51.26 111.02,51.26 111.16,51.4 111.16,51.55 111.03,51.68 111.03,51.83 111.17,51.97 111.32,51.97 111.45,51.84 111.6,51.84 111.74,51.98 111.74,52.12 111.6,52.26 111.6,52.4 111.75,52.55 111.89,52.55 112.03,52.41 112.17,52.41 112.31,52.55 112.31,52.7 112.18,52.83 112.18,52.98 112.32,53.12 112.47,53.12 112.6,52.99 112.75,52.99 112.89,53.13 112.89,53.27 112.75,53.41 112.75,53.55 112.9,53.7 113.04,53.7 113.19,53.55 113.34,53.55 113.48,53.69 113.48,53.83 113.31,54 113.31,54.11 113.47,54.27 113.62,54.27 113.78,54.11 113.9,54.11 114.46,54.67 114.46,58.41 113.91,58.96 113.91,61.86 113.57,62.2 113.57,63.14 114.37,63.94 114.37,64.5 114.16,64.7 114.16,65.06 114.05,65.17 113.65,65.17 113.04,65.79 111.53,65.79 111.39,65.92 111.23,65.92 111.09,65.79 110.96,65.79 110.62,66.12 v2(110.62,66.43)
  BOTTOM w0.076: UD1.F8 104.56,40.94 v2(104.42,41.13) ; UC1.AH69 116.42,66.46 115.75,66.46 115.64,66.41 115.36,66.13 115.18,66.13 115.05,66 111.06,66 v2(110.62,66.43)
DDR_A_D32: length 28.5
  IN4 w0.08: v2(118.95,57.12) 117.84,56.01 117.84,53.58 115.78,51.53 115.78,49.32 115.06,48.6 113.64,48.6 110.84,45.8 110.84,41.4 112.05,40.2 112.47,40.2 113.19,39.48 115.2,39.48 v2(115.91,40.19)
  BOTTOM w0.076: v2(115.91,40.19) 115.91,40.21 UD2.M8 ; UC1.BB65 119.21,58.65 119.21,57.39 v2(118.95,57.12)
DDR_A_D33: length 29.7
  IN4 w0.08: v2(119.96,57.54) 119.33,57.54 119.22,57.65 119.22,58.06 119.9,58.73 120.31,58.73 120.69,58.36 120.69,58.23 120.37,57.91 120.37,57.78 120.47,57.69 120.6,57.69 120.91,58 121.05,58 121.28,57.77 121.28,57.44 121.19,57.35 120.81,57.35 120.72,57.25 120.72,57.12 120.81,57.03 121.19,57.03 121.28,56.93 121.28,56.8 121.19,56.7 120.81,56.7 120.72,56.61 120.72,56.48 120.81,56.38 121.19,56.38 121.28,56.29 121.28,50.85 117.44,47.01 117.44,44.18 117.24,43.98 116.93,43.98 v2(116.47,44.44)
  BOTTOM w0.076: v2(119.96,57.54) 120.04,57.54 120.31,57.81 120.31,58.3 120.17,58.44 120.17,58.87 120.18,58.89 120.18,59.15 120.17,59.18 120.17,59.52 120.18,59.54 120.18,60.3 120.12,60.42 119.9,60.65 UC1.AW65 ; UD2.M10 116.76,42.65 116.76,44.15 v2(116.47,44.44)
DDR_A_D34: length 31.1
  IN4 w0.08: v2(115.45,43.54) 114.93,43.54 114.85,43.62 114.85,44.08 114.68,44.25 113.86,44.25 113.74,44.37 113.74,44.74 113.82,44.82 113.99,44.82 114.09,44.73 114.09,44.63 114.18,44.54 114.31,44.54 114.41,44.63 114.41,44.73 114.5,44.82 114.75,44.82 114.83,44.9 114.83,45.06 114.75,45.14 113.89,45.14 113.81,45.22 113.81,45.4 113.89,45.48 115.05,45.48 115.13,45.41 115.13,45.25 115.21,45.17 115.48,45.17 115.56,45.25 115.56,45.9 115.75,46.09 115.86,46.09 115.93,46.02 116.11,46.02 116.2,46.12 116.2,46.25 116.12,46.34 116.12,46.45 116.27,46.6 116.4,46.6 116.58,46.42 116.58,46.11 116.66,46.03 116.81,46.03 116.89,46.11 116.89,46.56 116.63,46.83 116.63,46.96 118.7,49.03 118.7,49.17 118.34,49.52 118.34,49.65 118.44,49.75 118.57,49.75 118.93,49.39 119.06,49.39 119.15,49.49 119.15,49.62 118.8,49.97 118.8,50.11 118.89,50.2 119.02,50.2 119.38,49.85 119.51,49.85 119.85,50.19 119.85,50.5 119.76,50.6 119.47,50.6 119.37,50.69 119.37,50.82 119.47,50.92 119.76,50.92 119.85,51.01 v2(119.85,51.53)
  BOTTOM w0.076: UD2.N11 v2(115.45,43.54) ; UC1.AW63 120.49,60.43 120.8,60.12 120.8,59.57 121.01,59.37 121.01,58.48 120.97,58.44 120.97,57.08 120.79,56.9 120.79,54.13 120.81,54.11
  BOTTOM w0.127: v2(119.85,51.53) 119.88,51.53 120.81,52.46 120.81,54.11
DDR_A_D35: length 29.8
  IN4 w0.08: v2(119.99,56.96) 120.44,56.51 120.44,56.14 120.99,55.59 120.99,53.06 120.89,52.97 120.41,52.97 120.31,52.88 120.31,52.74 120.41,52.65 120.89,52.65 120.99,52.56 120.99,52.42 120.89,52.33 120.48,52.33 120.39,52.24 120.39,52.1 120.48,52.01 120.89,52.01 120.99,51.92 120.99,51.78 120.89,51.69 120.48,51.69 120.39,51.6 120.39,51.46 120.48,51.37 120.89,51.37 120.99,51.28 120.99,50.94 120.75,50.71 120.62,50.71 120.35,50.97 120.22,50.97 120.13,50.88 120.13,50.75 120.39,50.48 120.39,50.35 117.17,47.12 117.17,44.65 117.06,44.54 116.91,44.54 116.82,44.63 116.82,45.65 116.74,45.73 116.58,45.73 116.5,45.65 116.5,45.01 116.41,44.92 116.27,44.92 116.18,45.01 116.18,45.65 116.1,45.73 115.94,45.73 115.86,45.65 115.86,45.01 115.72,44.87 115.53,44.87 115.45,44.79 115.45,44.16 115.55,44.06 116.35,44.06 116.5,43.91 116.5,43.64 116.37,43.51 v2(116.06,43.51)
  BOTTOM w0.076: UC1.AY63 120.39,59.9 120.39,59.64 120.33,59.49 120.33,59.22 120.34,59.18 120.34,58.85 120.33,58.83 120.33,58.53 120.47,58.39 120.47,57.44 v2(119.99,56.96) ; UD2.M11 v2(116.06,43.51)
DDR_A_D36: length 29.1
  IN4 w0.08: v2(118.93,55.95) 118.13,55.14 118.13,53.46 116.07,51.41 116.07,49.23 115.17,48.33 113.75,48.33 111.14,45.71 111.14,41.53 112.07,40.6 112.57,40.6 113.38,39.78 114.87,39.78 116.11,41.01 v2(116.11,41.11)
  BOTTOM w0.076: UC1.BA65 119.26,59.1 119.03,58.87 119.01,58.81 119.01,57.68 118.59,57.27 118.59,56.29 v2(118.93,55.95) ; UD2.N9 v2(116.11,41.11)
DDR_A_D37: length 29.3
  IN4 w0.08: v2(115.45,41.1) 115.45,40.81 115.34,40.71 113.31,40.71 112.6,41.42 111.8,41.42 111.43,41.79 111.43,45.62 111.58,45.77 111.71,45.77 111.98,45.5 112.11,45.5 112.2,45.6 112.2,45.73 111.93,46 111.93,46.13 113.86,48.06 115.28,48.06 116.37,49.14 116.37,51.28 118.45,53.37 118.45,53.78 118.54,53.87 118.63,53.87 118.71,53.95 118.71,54.11 118.63,54.19 118.54,54.19 118.45,54.28 118.45,54.81 v2(118.93,55.3)
  BOTTOM w0.076: UD2.P9 v2(115.45,41.1) ; UC1.AY65 119.26,59.79 118.85,59.38 118.85,58.87 118.84,58.86 118.84,57.75 118.43,57.34 118.43,55.8 v2(118.93,55.3)
DDR_A_D38: length 29.3
  IN4 w0.08: v2(119.83,52.71) 119.79,52.71 119.08,52 119.08,51.87 119.45,51.5 119.45,51.37 119.35,51.27 119.22,51.27 118.85,51.64 118.72,51.64 118.62,51.55 118.62,51.42 118.99,51.05 118.99,50.91 118.9,50.82 118.77,50.82 118.4,51.19 118.27,51.19 118.17,51.1 118.17,50.96 118.54,50.59 118.54,50.46 118.45,50.37 118.31,50.37 117.94,50.74 117.81,50.74 117.71,50.63 117.71,50.15 117.8,50.05 118.03,50.05 118.13,49.96 118.13,49.83 118.03,49.73 117.8,49.73 117.71,49.64 117.71,49.51 117.8,49.41 118.03,49.41 118.13,49.32 118.13,49.19 118.03,49.09 117.8,49.09 117.71,49 117.71,48.42 115.67,46.39 115.33,46.39 115.23,46.29 115.23,45.95 115.06,45.78 114.93,45.78 114.85,45.86 114.85,46.31 114.77,46.39 114.58,46.39 114.48,46.3 114.48,45.83 114.4,45.75 113.68,45.75 113.47,45.54 113.47,44.19 113.68,43.98 114.34,43.98 114.57,43.75 114.57,43.24 114.68,43.13 115.72,43.13 v2(116.13,42.72)
  BOTTOM w0.076: UD2.N10 v2(116.13,42.72) ; UC1.BA63 120.59,59.1 120.84,58.85 120.84,58.55 120.8,58.51 120.8,57.15 120.56,56.9 120.56,54.16 120.48,54.09
  BOTTOM w0.127: v2(119.83,52.71) 120.48,53.36 120.48,54.09
DDR_A_D39: length 28.3
  IN4 w0.08: v2(116.76,41.14) 116.76,41.18 116.31,41.62 113.02,41.62 112.38,42.26 112.07,42.26 111.83,42.5 111.83,43.01 111.92,43.11 112.17,43.11 112.26,43.2 112.26,43.33 112.17,43.43 111.92,43.43 111.83,43.52 111.83,43.65 111.92,43.75 112.17,43.75 112.26,43.84 112.26,43.97 112.17,44.07 111.92,44.07 111.83,44.16 111.83,44.72 112.5,45.38 112.5,46.31 113.97,47.78 115.46,47.78 116.7,49.03 116.7,51.11 119.58,53.99 v2(119.99,53.99)
  BOTTOM w0.076: v2(119.99,53.99) 120.39,54.39 120.39,56.97 120.64,57.21 120.64,58.65 UC1.BB63 ; UD2.M9 v2(116.76,41.14)
DDR_A_D40: length 24.9
  IN1 w0.08: v2(120,41.95) 119.85,41.8 119.43,41.8 119.09,42.14 119.09,42.39 118.84,42.64 118.7,42.64 118.61,42.55 118.47,42.55 118.32,42.69 118.32,42.84 118.41,42.92 118.41,43.07 118.12,43.36 118.12,43.69 118.25,43.82 118.25,44.15 118.12,44.29 118.12,44.58 118.28,44.74 118.28,44.94 118.12,45.1 118.12,45.34 118.25,45.47 118.73,45.47 118.99,45.74 119.13,45.74 119.26,45.88 119.26,45.99 118.97,46.28 118.97,46.4 119.22,46.64 119.22,46.77 119.12,46.87 118.63,46.87 118.51,46.98 118.51,47.15 118.63,47.27 119,47.27 119.12,47.38 119.12,47.76 122.7,51.34 122.7,52.55 122.44,52.81 v2(122.2,52.81)
  BOTTOM w0.076: UC1.BA61 121.62,59.12 121.34,58.85 121.34,58.34 121.3,58.3 121.3,57.08 121.41,56.97 121.41,52.84 121.57,52.68 122.07,52.68 v2(122.2,52.81) ; UD2.F9 v2(120,41.95)
DDR_A_D41: length 26.5
  IN1 w0.08: v2(122.16,51.65) 122.16,51.19 117.85,46.88 117.85,46.58 118,46.43 118,46.25 117.85,46.1 117.85,42.73 118.3,42.28 118.3,41.97 118.46,41.81 119.01,41.81 119.29,41.53 120.19,41.53 v2(120.61,41.11)
  BOTTOM w0.076: UC1.AW61 121.39,60.33 121.39,59.59 121.17,59.36 121.17,58.41 121.13,58.37 121.13,54.45 121.14,54.44 ; UD2.E9 v2(120.61,41.11)
  BOTTOM w0.127: 121.14,54.44 121.14,51.09 121.35,50.89 121.94,50.89 122.16,51.11 v2(122.16,51.65)
DDR_A_D42: length 24.7
  IN1 w0.08: v2(120.49,44.92) 120.49,45.24 120.88,45.63 121.2,45.63 121.61,46.04 121.61,46.39 121.38,46.62 121.13,46.62 121.04,46.7 121.04,47.92 121.19,48.07 121.37,48.07 121.46,47.99 121.46,47.57 121.54,47.49 122.04,47.49 122.12,47.58 122.12,47.7 122.04,47.79 122.04,47.94 122.12,48.02 122.12,48.14 121.75,48.51 121.75,48.62 121.93,48.8 122.04,48.8 122.55,48.29 122.66,48.29 122.81,48.44 122.81,48.6 122.36,49.06 122.36,49.22 122.48,49.34 122.64,49.34 123.1,48.89 123.26,48.89 123.38,49 123.38,49.17 122.92,49.62 122.92,49.79 123.04,49.91 123.21,49.91 123.66,49.45 123.83,49.45 123.96,49.58 123.96,53.1 123.57,53.49 v2(123.57,53.98)
  BOTTOM w0.076: UC1.BB59 122.89,58.64 122.89,56.25 123,56.14 123,54.56 v2(123.57,53.98) ; v2(120.49,44.92) 120.02,44.45 120.02,43.41 UD2.F11
DDR_A_D43: length 26.8
  IN1 w0.08: v2(122.13,57.31) 122.31,57.49 122.47,57.49 122.57,57.39 122.57,57.02 122.65,56.94 123.01,56.94 123.16,56.79 123.16,56.6 123.04,56.48 122.61,56.48 122.52,56.4 122.52,56.17 122.61,56.08 123.04,56.08 123.16,55.97 123.16,55.8 122.93,55.57 122.93,55.44 123.16,55.21 123.16,54.8 123.39,54.57 123.39,54.39 123.12,54.12 123.12,53.56 123.69,52.99 123.69,50.95 123.46,50.72 123.46,50.6 123.69,50.38 123.69,50.11 123.61,50.03 123.47,50.03 123.2,50.3 123.04,50.3 121.48,48.74 121.48,48.44 121.38,48.34 121.08,48.34 120.77,48.03 120.77,45.9 120.09,45.22 120.09,44.75 120.34,44.51 120.61,44.51 120.69,44.43 120.69,44.12 120.51,43.94 120.51,43.5 120.59,43.42 120.59,43.26 120.08,42.75 120.08,42.43 120.22,42.3 120.54,42.3 120.63,42.21 v2(120.63,41.93)
  BOTTOM w0.076: UC1.AW59 122.31,60.65 122.09,60.42 122.03,60.34 122.03,59.54 122.04,59.51 122.04,59.18 122.03,59.15 122.03,58.89 122.04,58.86 122.04,58.34 121.79,58.1 121.79,57.42 121.9,57.31 v2(122.13,57.31) ; UD2.F10 v2(120.63,41.93)
DDR_A_D44: length 24.3
  IN1 w0.08: v2(119.99,41.12) 119.85,40.99 119.35,40.99 119.2,41.14 119.2,41.2 118.89,41.52 118.5,41.52 118.34,41.36 118.2,41.36 117.78,41.78 117.78,41.94 117.93,42.09 117.93,42.24 117.79,42.38 117.64,42.38 117.47,42.21 117.35,42.21 116.98,42.59 116.98,43.69 117.24,43.95 117.49,43.95 117.58,44.04 117.58,44.49 117.34,44.73 117.34,44.9 117.58,45.13 117.58,45.29 117.34,45.53 117.34,45.7 117.58,45.93 117.58,46.09 117.34,46.33 117.34,46.5 117.58,46.73 117.58,46.99 121.73,51.14 121.73,52.92 122.11,53.29 v2(122.11,53.64)
  BOTTOM w0.076: 121.68,54.97 121.68,56.59 121.68,57 121.46,57.21 121.46,58.23 121.62,58.39 UC1.BB61 ; UD2.F8 v2(119.99,41.12)
  BOTTOM w0.127: 121.68,54.97 121.68,54.07 v2(122.11,53.64)
