# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_CLK0: length 60.1
  IN4 w0.094: v2(136.09,37.91) 136.37,38.19 136.37,38.37 136.58,38.58 136.97,38.58 137.1,38.7 137.1,38.93 136.99,39.04 136.34,39.04 135.84,38.54 135.46,38.54 135.24,38.75 135.24,39.21 135.09,39.37 134.83,39.37 134.54,39.08 134,39.08 133.38,39.69 133.18,39.69 132.85,40.03 132.85,40.34 132.7,40.49 132.6,40.49 132.27,40.81 132.27,41 132.18,41.09 131.49,41.09 130.87,41.71 130.87,43.34 131.12,43.6 131.12,44.87 131.03,44.96 130.65,44.96 130.44,45.17 130.44,45.51 130.65,45.72 131.24,45.72 131.34,45.81 131.34,46 131.24,46.09 130.64,46.09 130.43,46.3 130.43,46.65 130.64,46.85 131.24,46.85 131.33,46.95 131.33,47.24 131.18,47.4 130.64,47.4 130.43,47.6 130.43,48.02 130.64,48.23 131.23,48.23 131.33,48.33 131.33,48.9 134.06,51.64 134.06,58.44 134.68,59.05 135.66,59.05 136.65,58.06 137.13,58.06 137.26,58.19 137.26,58.34 136.1,59.5 135.42,59.5 135.2,59.73 135.2,60.72 135.08,60.84 134.75,60.84 134.65,60.74 134.65,59.8 134,59.16 133.71,59.16 133.37,59.5 133.37,59.81 133.72,60.17 133.72,60.68 133.56,60.84 133.14,60.84 132.88,60.58 132.88,60.04 132.67,59.84 132.29,59.84 131.86,60.27 131.86,60.77 132.28,61.19 132.28,61.85 132,62.14 131.69,62.14 131.11,62.72 130.79,62.72 130.48,63.03 130.48,63.87 130.33,64.02 v2(130.16,64.02)
  BOTTOM w0.076: UC1.AP45 v2(130.16,64.02) ; v2(136.09,37.91) 136.09,37.34 135.89,37.14 135.89,37.03 136.01,36.92 136.12,36.92 136.31,37.1 136.45,37.1 136.57,36.98 136.57,36.86 136.43,36.72 UD3.J3 136.12,36.41 136.12,35.78 136.38,35.52 136.38,35.27 136.39,35.06 136.37,35.04 136.37,35.02
  BOTTOM w0.13: 136.37,35.02 136.37,34.52 135.33,33.49 135.33,33.2 RD68.1
DDR_B_CLK1: length 61.6
  IN2 w0.104: v2(129.25,63.41) 129.52,63.68 129.64,63.68 130.1,63.21 130.32,63.21 130.94,62.59 131.22,62.59 132.35,61.45 132.35,60.54 133.35,59.55 133.79,59.55 136.32,57.02 136.32,54.82 136.53,54.61 137.01,54.61 137.11,54.51 137.11,54.3 137.01,54.19 136.53,54.19 136.32,53.98 136.32,52.57 137.27,51.62 137.6,51.62 138.23,52.25 138.4,52.25 138.52,52.12 138.52,51.95 137.89,51.32 137.89,51 138.68,50.22 141.87,50.22 142.74,51.09 142.74,51.39 142.08,52.05 142.08,52.19 142.23,52.34 142.37,52.34 143.03,51.68 143.33,51.68 143.52,51.87 143.74,51.87 143.92,51.7 143.92,51.53 142.09,49.7 142.09,49.37 145.32,46.13 145.32,42.72 146.49,41.56 146.9,41.56 147.13,41.78 147.13,41.95 147.25,42.07 147.61,42.07 147.73,41.95 147.73,41.78 147.96,41.56 148.47,41.56 148.7,41.78 148.7,41.95 148.82,42.07 149.17,42.07 149.29,41.95 149.29,41.78 149.52,41.56 150.14,41.56 150.41,41.82 150.41,41.99 150.53,42.11 150.98,42.11 151.1,41.99 151.1,41.57 150.87,41.33 150.87,40.92 151.22,40.56 151.22,39.75 152.18,38.8 152.18,37.72 152.03,37.57 151.75,37.57 151.63,37.69 v2(151.63,37.9)
  BOTTOM w0.076: v2(129.25,63.41) UC1.AP46 ; v2(151.63,37.9) 152.02,37.9 152.25,37.68 152.25,36.91 152.06,36.71 UD4.J3 152.25,36.42 152.25,35.85 152.3,35.8 152.3,35.68 152.48,35.5 152.48,34.87 152.5,34.84 152.5,34.82
  BOTTOM w0.13: 152.5,34.82 152.5,34.52 153.62,33.4 153.62,33.17 RD74.1
DDR_B_CLK#0: length 59.1
  IN4 w0.094: v2(136.78,37.9) 136.56,38.12 136.56,38.29 136.66,38.39 137.05,38.39 137.29,38.62 137.29,39.01 137.07,39.23 136.26,39.23 135.76,38.73 135.53,38.73 135.43,38.83 135.43,39.29 135.16,39.56 134.75,39.56 134.46,39.27 134.07,39.27 133.46,39.88 133.26,39.88 133.04,40.1 133.04,40.42 132.78,40.68 132.68,40.68 132.46,40.89 132.46,41.08 132.26,41.28 131.56,41.28 131.06,41.79 131.06,43.27 131.31,43.52 131.31,44.95 131.1,45.15 130.73,45.15 130.63,45.25 130.63,45.43 130.73,45.53 131.32,45.53 131.53,45.73 131.53,46.08 131.32,46.28 130.72,46.28 130.62,46.38 130.62,46.57 130.72,46.66 131.32,46.66 131.52,46.87 131.52,47.32 131.26,47.59 130.72,47.59 130.62,47.68 130.62,47.94 130.72,48.04 131.31,48.04 131.52,48.25 131.52,48.83 134.26,51.56 134.26,58.36 134.76,58.86 135.58,58.86 136.57,57.87 137.21,57.87 137.45,58.11 137.45,58.42 136.18,59.69 135.5,59.69 135.39,59.8 135.39,60.8 135.16,61.03 134.67,61.03 134.46,60.82 134.46,59.88 133.92,59.35 133.79,59.35 133.56,59.58 133.56,59.73 133.91,60.09 133.91,60.76 133.64,61.03 133.06,61.03 132.69,60.66 132.69,60.12 132.6,60.03 132.37,60.03 132.05,60.35 132.05,60.69 132.47,61.11 132.47,61.93 132.07,62.33 131.77,62.33 131.19,62.91 130.87,62.91 130.67,63.11 130.67,63.62 v2(131.07,64.02)
  BOTTOM w0.076: UC1.AN45 v2(131.07,64.02) ; 136.58,35.03 136.58,35.05 136.56,35.07 136.55,35.27 136.55,35.45 136.55,35.45 136.55,35.59 136.43,35.71 UD3.J2 136.73,36.22 136.73,37.84 136.78,37.88 v2(136.78,37.9)
  BOTTOM w0.13: RD67.1 135.54,33.15 135.54,33.4 136.58,34.44 136.58,35.03
DDR_B_CLK#1: length 60.7
  IN2 w0.104: v2(151.61,37.09) 151.61,37.22 151.78,37.39 152.11,37.39 152.36,37.64 152.36,38.88 151.41,39.83 151.41,40.64 151.05,40.99 151.05,41.26 151.29,41.49 151.29,42.06 151.05,42.3 150.45,42.3 150.22,42.07 150.22,41.9 150.07,41.74 149.6,41.74 149.48,41.86 149.48,42.03 149.25,42.26 148.74,42.26 148.51,42.03 148.51,41.86 148.39,41.74 148.03,41.74 147.91,41.86 147.91,42.03 147.69,42.26 147.17,42.26 146.95,42.03 146.95,41.86 146.83,41.74 146.56,41.74 145.51,42.79 145.51,46.21 142.27,49.45 142.27,49.62 144.1,51.45 144.1,51.77 143.82,52.06 143.44,52.06 143.26,51.87 143.11,51.87 142.45,52.53 142.15,52.53 141.89,52.27 141.89,51.97 142.55,51.31 142.55,51.16 141.79,50.4 138.75,50.4 138.08,51.08 138.08,51.25 138.71,51.87 138.71,52.2 138.48,52.43 138.15,52.43 137.52,51.8 137.35,51.8 136.5,52.65 136.5,53.9 136.61,54.01 137.08,54.01 137.3,54.22 137.3,54.58 137.08,54.79 136.61,54.79 136.5,54.9 136.5,57.1 133.87,59.73 133.42,59.73 132.54,60.62 132.54,61.53 131.29,62.77 131.02,62.77 130.4,63.39 130.18,63.39 129.71,63.86 129.41,63.86 129.39,63.88 129.38,63.88 v2(129.24,64.02)
  BOTTOM w0.076: v2(151.61,37.09) 151.65,37.06 151.65,36.53 151.95,36.22 UD4.J2 152.13,35.73 152.13,35.61 152.32,35.43 152.32,34.87 152.29,34.84 152.29,34.82 ; UC1.AN46 v2(129.24,64.02)
  BOTTOM w0.13: 152.29,34.82 152.29,34.43 153.41,33.32 153.41,33.18 RD69.1
DDR_B_CS#0: length 76.4
  IN1 w0.08: v2(134.78,37.11) 134.78,37.18 135.94,38.35 140.19,38.35 141.98,36.55 142.91,36.55 143.35,36.99 v2(143.35,37.07) 143.55,37.07 143.82,36.81 144.86,36.81 144.96,36.91 144.96,37.1 145.06,37.2 145.27,37.2 145.37,37.1 145.37,36.91 145.47,36.81 145.68,36.81 145.78,36.91 145.78,37.19 145.86,37.27 146.1,37.27 146.18,37.19 146.18,36.98 146.28,36.87 146.79,36.87 147.14,37.22 149.71,37.22 150.37,37.89 v2(150.96,37.89)
  IN2 w0.089: v2(143.35,37.07) 143.35,37.41 143.72,37.78 143.72,38 143.48,38.23 143.26,38.23 142.07,37.04 141.67,37.04 141.35,37.36 141.35,38.19 141.74,38.58 141.74,39.06 141.55,39.25 141.27,39.25 141.17,39.36 141.17,39.73 141.06,39.84 140.91,39.84 140.81,39.73 140.81,39.36 140.71,39.25 140.56,39.25 140.45,39.36 140.45,39.73 140.35,39.84 140.2,39.84 140.1,39.73 140.1,39.36 139.99,39.25 139.85,39.25 139.74,39.36 139.74,39.73 139.64,39.84 139.49,39.84 139.39,39.73 139.39,39.36 139.28,39.25 139.14,39.25 139.03,39.36 139.03,39.73 138.93,39.84 138.78,39.84 138.68,39.73 138.68,39.36 138.57,39.25 138.42,39.25 138.32,39.36 138.32,39.73 138.22,39.84 138.07,39.84 137.96,39.73 137.96,39.36 137.86,39.25 137.58,39.25 137.41,39.42 137.41,41.54 136.52,42.42 136.52,42.57 136.68,42.73 136.68,42.88 136.57,42.98 136.43,42.98 136.27,42.82 136.12,42.82 136.02,42.93 136.02,43.07 136.17,43.23 136.17,43.38 136.07,43.48 135.92,43.48 135.77,43.33 135.62,43.33 133.85,45.09 133.85,45.59 133.95,45.7 134.39,45.7 134.49,45.59 134.49,45.3 134.59,45.19 134.74,45.19 134.84,45.3 134.84,45.59 134.95,45.7 135.41,45.7 135.5,45.78 135.5,45.96 135.41,46.05 133.95,46.05 133.85,46.16 133.85,46.58 133.75,46.68 131.74,46.68 131.64,46.78 131.64,46.93 131.74,47.04 133.36,47.04 133.47,47.14 133.47,47.29 133.36,47.39 131.74,47.39 131.64,47.5 131.64,47.64 131.74,47.75 132.81,47.75 132.91,47.85 132.91,48 132.81,48.1 131.74,48.1 131.64,48.21 131.64,49.16 131.9,49.42 131.9,54.6 132.41,55.1 132.41,55.82 132.27,55.95 132.27,56.22 132.41,56.35 132.41,56.53 132.32,56.62 132.11,56.62 132.02,56.71 132.02,56.89 132.11,56.97 132.32,56.97 132.41,57.06 132.41,57.34 132.98,57.91 v2(133.15,57.91)
  BOTTOM w0.076: v2(150.96,37.89) 151,37.85 151,37.39 151,37.39 151,37.07 150.83,36.91 150.83,36.9 UD4.L3 ; v2(133.15,57.91) 132.86,57.91 132.78,57.99 132.78,58.63 UC1.BB42 ; UD3.L3 135.13,36.76 v2(134.78,37.11)
  BOTTOM w0.127: RD62.1 143.81,33.11 143.81,33.27 143.29,33.78 143.29,37.02 v2(143.35,37.07)
DDR_B_CS#1: length 78
  IN1 w0.08: v2(134.82,38.69) 140.6,38.69 142.3,36.99 v2(142.76,36.99) 142.76,37.62 142.93,37.79 146.99,37.79 147.6,38.4 150.02,38.4 150.32,38.7 v2(150.34,38.7)
  IN2 w0.089: v2(131.82,61.4) 131.82,58.56 131.56,58.3 131.56,49.64 131.34,49.42 131.34,47.74 131.23,47.64 130.02,47.64 129.91,47.54 129.91,47.39 130.02,47.28 131.23,47.28 131.34,47.18 131.34,47.03 131.23,46.93 130.02,46.93 129.91,46.82 129.91,46.68 130.02,46.57 131.23,46.57 131.34,46.47 131.34,46.32 131.23,46.22 130.02,46.22 129.91,46.11 129.91,45.97 130.02,45.86 131.23,45.86 131.34,45.76 131.34,45.61 131.23,45.51 130.02,45.51 129.91,45.4 129.91,45.25 130.02,45.15 131.23,45.15 131.34,45.05 131.34,41.13 131.81,40.65 132.18,40.65 132.36,40.83 132.36,41.37 132.48,41.5 132.83,41.5 133.02,41.32 133.02,40.43 132.37,39.78 132.37,39.44 132.52,39.29 133.13,39.29 133.29,39.44 133.29,39.69 133.44,39.85 133.74,39.85 133.9,39.69 133.9,39.44 134.05,39.29 134.4,39.29 134.56,39.44 134.56,39.74 134.71,39.9 135.04,39.9 135.2,39.74 135.2,38.99 135.38,38.81 135.62,38.81 135.77,38.96 135.77,39.05 135.93,39.2 136.23,39.2 136.55,38.88 140.86,38.88 141.01,38.73 141.01,37.22 141.71,36.52 142.13,36.52 142.6,36.99 v2(142.76,36.99)
  BOTTOM w0.076: v2(131.82,61.4) 132.12,61.4 132.43,61.08 132.43,60.45 132.71,60.17 UC1.AY42 ; UD4.L4 150.34,37.82 v2(150.34,38.7) ; UD3.L4 135.13,37.79 134.83,38.09 134.83,38.68 v2(134.82,38.69)
  BOTTOM w0.127: v2(142.76,36.99) 142.8,36.95 142.8,33.84 143.46,33.18 143.46,32.61 143.84,32.23 RD63.1
DDR_B_D0: length 28.1
  IN1 w0.08: v2(133.19,56.14) 133.48,56.14 133.6,56.02 133.6,52.43 133.31,52.14 133.31,49.92 129.7,46.31 129.7,40.12 129.93,39.89 130.32,39.89 130.55,40.12 130.55,40.92 130.63,41 131.48,41 131.56,41.08 131.56,41.43 131.48,41.51 v2(130.5,41.51)
  BOTTOM w0.076: v2(133.19,56.14) 133.55,56.51 133.55,58.87 arc(133.56,58.9) 133.58,58.93 arc(133.6,58.96) 133.62,58.99 133.69,59.13 arc(133.71,59.2) 133.72,59.26 133.72,59.36 arc(133.75,59.51) 133.83,59.64 133.85,59.66 arc(133.95,59.81) 133.99,59.98 UC1.AY39 ; UD3.T9 131.56,41.83 130.82,41.83 v2(130.5,41.51)
DDR_B_D1: length 26.7
  IN1 w0.08: v2(132.2,40.22) 132.21,40.23 133.3,39.91 133.6,39.87 134.21,39.87 134.55,39.98 134.98,40.25 136.48,41.75 136.48,45.22 136.15,45.56 136.15,46.85 136.68,47.38 136.68,52.28 136.49,52.47 136.49,52.76 136.21,53.05 136.21,54.99 136.16,55.03 136.16,55.46 136.12,55.67 135.97,55.82 135.65,55.91 135.62,55.92 135.44,56.1 135.18,56.72 135.12,57.02 v2(134.69,57.45)
  BOTTOM w0.076: v2(134.69,57.45) 135.04,57.81 135.04,58.3 134.89,58.45 134.89,58.87 134.9,58.89 134.9,59.15 134.89,59.18 134.89,59.52 134.9,59.54 134.9,60.36 134.9,60.37 134.62,60.65 UC1.AW39 ; UD3.R8 v2(132.2,40.22)
DDR_B_D2: length 28.4
  IN1 w0.08: v2(130.44,42.78) 130.85,42.37 130.85,41.9 130.95,41.8 131.16,41.8 131.26,41.9 131.26,42.58 130.65,43.19 130.29,43.19 129.99,43.49 129.99,46.22 133.6,49.83 133.6,52.02 133.89,52.31 133.89,54.17 133.99,54.27 134.16,54.27 134.26,54.37 134.26,54.57 134.16,54.67 133.99,54.67 133.89,54.78 133.89,54.98 133.99,55.08 134.19,55.08 134.29,55.18 134.29,55.39 134.19,55.49 133.99,55.49 133.89,55.59 133.89,55.79 133.99,55.89 134.17,55.89 134.27,55.99 134.27,56.2 134.17,56.3 133.78,56.3 133.59,56.49 133.59,57.56 133.77,57.74 134.03,57.74 134.19,57.58 134.19,56.92 134.29,56.82 v2(134.67,56.82)
  BOTTOM w0.076: UC1.AY37 135.21,59.93 135.06,59.49 135.06,59.22 135.07,59.18 135.07,58.85 135.06,58.83 135.06,58.52 135.21,58.37 135.21,57.47 134.67,56.93 v2(134.67,56.82) ; UD3.T10 131.49,42.7 130.52,42.7 v2(130.44,42.78)
DDR_B_D3: length 29.2
  IN1 w0.08: v2(131.61,40.22) 131.61,40.54 131.71,40.65 132.12,40.65 132.22,40.75 132.22,41.43 132.33,41.53 132.64,41.53 132.76,41.41 133.01,41.41 133.11,41.31 133.11,41.11 133.01,41.01 132.77,41.01 132.65,40.88 132.65,40.5 132.75,40.4 132.99,40.4 133.29,40.69 134.42,40.69 134.54,40.57 134.71,40.57 134.9,40.76 134.9,40.95 134.77,41.08 134.77,41.22 134.91,41.37 135.05,41.37 135.25,41.17 135.49,41.17 136.19,41.88 136.19,45.1 135.86,45.43 135.86,46.95 136.39,47.47 136.39,52.16 136.2,52.35 136.2,52.64 v2(135.79,53.04)
  BOTTOM w0.076: UD3.T8 v2(131.61,40.22) ; UC1.AW37 135.49,60.07 135.49,59.76 135.57,59.52 135.57,59.08 135.73,58.91 135.73,58.48 135.7,58.45 135.7,57.24 135.4,56.94 135.4,53.43 135.45,53.38
  BOTTOM w0.127: 135.45,53.38 135.78,53.04 v2(135.79,53.04)
DDR_B_D4: length 26.9
  IN1 w0.08: v2(130.7,43.82) 130.28,44.24 130.28,46.13 130.49,46.34 130.62,46.34 130.85,46.11 130.98,46.11 131.08,46.21 131.08,46.34 130.85,46.57 130.85,46.7 130.94,46.79 131.08,46.79 131.3,46.57 131.44,46.57 131.53,46.66 131.53,46.79 131.3,47.02 131.3,47.15 131.4,47.25 131.53,47.25 131.76,47.02 131.89,47.02 131.98,47.11 131.98,47.25 131.76,47.47 131.76,47.6 131.85,47.7 131.98,47.7 132.21,47.47 132.34,47.47 132.44,47.57 132.44,47.7 132.21,47.92 132.21,48.06 132.3,48.15 132.44,48.15 132.66,47.92 132.79,47.92 132.89,48.02 132.89,48.15 132.66,48.38 132.66,48.51 132.76,48.6 132.89,48.6 133.11,48.38 133.25,48.38 133.34,48.47 133.34,48.6 133.11,48.83 133.11,48.96 133.21,49.06 133.34,49.06 133.57,48.83 133.7,48.83 133.79,48.92 133.79,49.06 133.57,49.28 133.57,49.41 133.89,49.74 133.89,50.11 133.99,50.21 134.24,50.21 134.33,50.3 134.33,50.43 134.24,50.53 133.99,50.53 133.89,50.62 133.89,50.75 133.99,50.85 134.24,50.85 134.33,50.94 134.33,51.07 134.24,51.17 133.99,51.17 133.89,51.26 133.89,51.39 133.99,51.49 134.24,51.49 134.33,51.58 134.33,51.71 134.24,51.81 134.1,51.81 134.02,51.89 134.02,52.03 134.18,52.19 134.18,52.67 134.28,52.77 134.28,53.17 134.18,53.26 134.18,53.88 134.28,53.98 134.43,53.98 v2(134.69,53.72)
  BOTTOM w0.076: 134.12,54.75 133.97,54.9 133.97,58.44 133.99,58.46 UC1.BB39 ; v2(130.7,43.82) 131.04,43.48 131.51,43.48 UD3.T11
  BOTTOM w0.127: 134.12,54.75 134.12,53.9 134.3,53.72 v2(134.69,53.72)
DDR_B_D5: length 27.2
  IN1 w0.08: v2(134.68,52.53) 134.61,52.46 134.61,50.08 134.11,49.57 134.11,48.83 133.69,48.41 133.69,48.28 133.74,48.22 133.74,48.09 133.65,47.99 133.52,47.99 133.46,48.05 133.33,48.05 133.23,47.96 133.23,47.82 133.29,47.77 133.29,47.63 133.2,47.54 133.07,47.54 133.01,47.6 132.88,47.6 132.78,47.5 132.78,47.37 132.84,47.31 132.84,47.18 132.75,47.09 132.61,47.09 132.56,47.15 132.42,47.15 132.33,47.05 132.33,46.92 132.39,46.86 132.39,46.73 132.29,46.64 132.16,46.64 132.1,46.69 131.97,46.69 131.11,45.83 130.63,45.83 130.55,45.75 130.55,45.04 130.7,44.89 131.15,44.89 131.25,44.8 131.25,44.57 131.31,44.51 131.54,44.51 131.72,44.33 131.72,44.22 131.63,44.13 131.21,44.13 131.13,44.05 131.13,43.89 131.21,43.81 131.63,43.81 131.72,43.72 131.72,43.58 131.63,43.49 131.18,43.49 131.07,43.39 131.07,43.27 131.18,43.17 131.63,43.17 131.72,43.08 131.72,42.99 131.72,42.99 131.72,42.89 131.55,42.72 131.55,42.3 131.65,42.2 131.89,42.2 132.18,42.49 v2(132.18,42.73)
  BOTTOM w0.076: UC1.BA39 133.99,59.1 133.73,58.85 133.73,54.68 ; UD3.R10 v2(132.18,42.73)
  BOTTOM w0.127: v2(134.68,52.53) 134.68,52.04 134.37,51.73 133.96,51.73 133.73,51.96 133.73,54.68
DDR_B_D6: length 28.3
  IN1 w0.08: v2(135.79,52.38) 135.79,52.34 136.1,52.04 136.1,48.3 136,48.21 135.75,48.21 135.65,48.11 135.65,47.98 135.75,47.89 136,47.89 136.1,47.79 136.1,47.56 135.49,46.95 135.49,45.39 135.6,45.27 135.61,45.27 135.88,45 135.88,44.85 135.77,44.74 135.77,44.38 135.89,44.26 135.89,44.05 135.78,43.94 135.32,43.94 135.22,43.84 135.22,43.64 135.32,43.54 135.8,43.54 135.9,43.44 135.9,43.23 135.8,43.13 135.3,43.13 135.2,43.03 135.2,42.83 135.3,42.73 135.8,42.73 135.9,42.62 135.9,42 135.46,41.56 135.34,41.56 135.21,41.69 135.21,41.9 135.38,42.06 135.38,42.21 135.26,42.32 134.29,42.32 134.27,42.34 133.81,42.34 133.67,42.2 133.67,41.63 133.56,41.53 133.36,41.53 133.26,41.63 133.26,42.2 133.16,42.31 133.04,42.31 133,42.34 132.45,42.34 132.18,42.08 v2(132.18,41.91)
  BOTTOM w0.076: UC1.BA37 135.31,59.1 135.57,58.85 135.57,58.55 135.54,58.52 135.54,57.31 135.24,57.01 135.24,52.93 135.3,52.87 ; UD3.R9 v2(132.18,41.91)
  BOTTOM w0.127: v2(135.79,52.38) 135.3,52.87
DDR_B_D7: length 27.5
  IN1 w0.08: v2(133.08,45.01) 132.86,45.01 132.71,44.86 132.71,44.04 132.82,43.94 133.16,43.94 133.26,43.84 133.26,42.7 133.36,42.6 133.57,42.6 133.67,42.7 133.67,43.03 133.79,43.16 134.31,43.16 134.42,43.26 134.42,43.46 134.31,43.56 133.78,43.56 133.67,43.67 133.67,44.5 133.9,44.73 134.04,44.73 134.37,44.4 134.5,44.4 134.6,44.49 134.6,44.63 134.26,44.96 134.26,45.09 134.58,45.4 134.69,45.4 134.77,45.32 134.89,45.32 135,45.43 135,45.55 134.92,45.63 134.92,45.74 135.18,46.01 135.18,48.43 135.82,49.07 135.82,51.07 v2(135.68,51.21)
  BOTTOM w0.076: UD3.R11 132.22,43.43 132.22,44.14 132.67,44.6 132.67,44.61 132.88,44.82 132.89,44.82 133.08,45.01 v2(133.08,45.01) ; 135.13,52.59 135.07,52.65 135.07,57.1 135.37,57.4 135.37,58.44 135.31,58.5 UC1.BB37
  BOTTOM w0.127: 135.13,52.59 135.13,51.95 134.57,51.4 134.57,51.02 134.79,50.8 135.27,50.8 v2(135.68,51.21)
DDR_B_D8: length 23.6
  IN4 w0.08: v2(132.84,41.93) 132.84,42.22 132.73,42.32 132.01,42.32 131.78,42.55 131.78,42.97 132.03,43.22 132.03,43.82 132.14,43.92 132.66,43.92 132.76,44.02 132.76,44.23 132.66,44.33 132.14,44.33 132.03,44.43 132.03,44.7 132.14,44.81 132.56,44.81 132.67,44.92 132.67,48.57 135.28,51.18 135.28,52.14 135.38,52.24 135.38,53.27 135.76,53.66 v2(135.8,53.66)
  BOTTOM w0.076: UC1.AY35 136.55,59.88 136.55,59.55 136.56,59.54 136.59,59.43 136.59,59.2 136.58,59.19 136.58,58.86 136.59,58.83 136.59,58.48 136.53,58.19 136.53,57.13 136.54,57.12 v1(136.54,54.39) ; v2(132.84,41.93) 133.44,41.93 UD3.N10
  BOTTOM w0.127: v2(135.8,53.66) v1(136.54,54.39)
DDR_B_D9: length 24.7
  IN4 w0.08: v2(132.25,45.22) 132.25,48.53 134.99,51.27 134.99,52.26 135.09,52.36 135.09,53.36 135.11,53.38 135.11,53.58 135.21,53.68 135.29,53.68 135.39,53.78 135.39,53.99 135.29,54.09 135.21,54.09 135.11,54.19 135.11,54.39 135.21,54.49 135.26,54.49 135.36,54.6 135.36,54.8 135.26,54.9 135.21,54.9 135.11,55 135.11,55.21 135.21,55.31 135.24,55.31 135.34,55.41 135.34,55.61 135.24,55.71 135.21,55.71 135.11,55.82 135.11,56.02 135.21,56.12 135.29,56.12 135.39,56.22 135.39,56.42 135.29,56.53 135.21,56.53 135.11,56.63 135.11,56.83 135.21,56.93 135.29,56.93 135.39,57.03 135.39,57.24 135.29,57.34 135.21,57.34 135.11,57.44 135.11,57.85 135.22,57.97 135.45,57.97 135.85,57.56 v2(135.85,56.87)
  BOTTOM w0.076: v2(132.25,45.22) 132.32,45.3 132.38,45.3 132.49,45.41 133.28,45.41 133.5,45.19 133.5,43.44 UD3.N11 ; UC1.AW35 136.44,60.41 136.12,60.08 136.12,59.59 136.05,59.52 136.05,59.07 136.03,59.05 136.03,59.03 135.92,58.91 135.92,58.48 136.03,58.37 136.03,57.05 v2(135.85,56.87)
DDR_B_D10: length 23.7
  IN4 w0.08: v2(137.89,54.02) 137.6,54.02 137.5,53.92 137.5,50 134.85,47.35 134.85,47.17 134.94,47.08 135.31,47.08 135.4,46.98 135.4,46.85 135.31,46.76 134.94,46.76 134.85,46.66 134.85,46.53 134.94,46.44 135.31,46.44 135.4,46.34 135.4,46.21 135.31,46.12 134.94,46.12 134.85,46.02 134.85,45.89 134.94,45.8 135.31,45.8 135.4,45.7 135.4,45.57 135.31,45.48 134.94,45.48 134.85,45.38 134.85,44.08 135.22,43.71 135.22,42.17 134.95,41.9 v2(134.8,41.9)
  BOTTOM w0.076: v2(137.89,54.02) 138.38,54.52 138.38,57.45 137.95,57.88 137.95,58.29 138.09,58.42 138.09,58.9 138.02,59.05 137.96,59.13 137.96,59.14 137.95,59.14 137.94,59.18 137.94,59.72 UC1.AY33 ; UD3.M9 v2(134.8,41.9)
DDR_B_D11: length 22.8
  IN4 w0.08: v2(134.18,41.11) 134.74,41.26 135.56,42.08 135.77,42.48 135.77,47.89 137.81,49.93 137.81,52.51 v2(137.93,52.84)
  BOTTOM w0.076: UD3.N9 v2(134.18,41.11) ; 136.87,55.25 136.7,55.8 136.7,57.19 136.69,57.2 136.69,58.08 136.76,58.44 136.76,58.86 136.75,58.89 136.75,59.13 136.76,59.14 136.76,59.49 136.73,59.6 136.74,59.77 136.81,60.34 136.85,60.45 136.97,60.6 137.21,60.65 UC1.AW33
  BOTTOM w0.127: 136.87,55.25 137.42,53.34 137.92,52.84 v2(137.93,52.84)
DDR_B_D12: length 22.2
  IN4 w0.08: v2(135.79,54.86) 136.21,54.44 136.21,51.14 135.79,50.72 135.21,50.72 133.52,49.03 133.52,47.98 133.39,47.85 133.39,47.66 133.52,47.53 133.52,47.34 133.39,47.21 133.39,47.02 133.52,46.89 133.52,44.23 133.26,43.97 133.26,42.52 133.35,42.43 133.64,42.43 133.74,42.33 133.74,42.12 133.64,42.02 133.35,42.02 133.25,41.92 133.25,41.64 133.35,41.54 133.69,41.54 133.73,41.5 134.05,41.5 134.22,41.67 134.22,41.81 v2(134.12,41.92)
  BOTTOM w0.076: v2(134.12,41.92) UD3.M10 ; UC1.BB35 136.36,58.67 136.36,57.06 136.37,57.05 136.37,55.07 136.16,54.86 v2(135.79,54.86)
DDR_B_D13: length 22.7
  IN4 w0.08: v2(134.15,42.75) 134.05,42.64 133.87,42.64 133.64,42.87 133.64,43.97 133.79,44.12 133.79,48.92 133.96,49.09 134.09,49.09 134.5,48.67 134.64,48.67 134.73,48.77 134.73,48.9 134.31,49.31 134.31,49.45 134.87,50.01 135.01,50.01 135.42,49.59 135.55,49.59 135.65,49.69 135.65,49.82 135.23,50.23 135.23,50.37 135.32,50.45 135.98,50.45 136.5,50.97 136.5,54.72 135.76,55.46 v2(135.76,55.46)
  BOTTOM w0.076: UC1.BA35 136.34,59.12 136.2,58.98 136.2,58.96 136.09,58.85 136.09,58.55 136.2,58.44 136.2,56.99 136.21,56.98 136.21,55.59 136.08,55.46 v2(135.76,55.46) ; UD3.M11 v2(134.15,42.75)
DDR_B_D14: length 22.9
  IN4 w0.08: v2(134.15,40.27) 134.58,40.27 135.18,40.88 135.32,40.88 135.44,40.76 135.58,40.76 135.73,40.9 135.73,41.05 135.61,41.16 135.61,41.31 136.35,42.05 136.35,47.71 138.39,49.75 138.39,52.32 138.62,52.55 138.62,55.22 v2(137.93,55.92)
  BOTTOM w0.076: v2(134.15,40.27) UD3.M8 ; UC1.BA33 137.67,59.2 137.68,59.18 137.84,59.01 137.87,58.96 137.92,58.87 137.92,58.55 137.79,58.41 137.79,57.81 138.12,57.48 138.12,56.12 v2(137.93,55.92)
DDR_B_D15: length 21.9
  IN4 w0.08: v2(133.52,41.13) 133.54,41.13 133.96,40.7 134.59,40.7 136.06,42.17 136.06,47.8 138.1,49.84 138.1,52.44 138.33,52.67 138.33,54.19 v2(137.89,54.63)
  BOTTOM w0.076: v2(137.89,54.63) 137.57,54.95 137.57,56.07 137.95,56.46 137.95,57.41 137.62,57.74 137.62,58.52 137.67,58.56 UC1.BB33 ; UD3.P9 v2(133.52,41.13)
DDR_B_D16: length 26.4
  IN1 w0.08: v2(132.96,61.38) 132.94,61.36 132.94,60.3 133.2,60.03 134.09,60.03 136.38,57.75 137.22,57.75 137.52,57.45 137.52,56.87 137.62,56.77 137.85,56.77 137.95,56.67 137.95,56.47 137.85,56.37 137.62,56.37 137.52,56.26 137.52,56.09 137.52,56.09 137.52,55.76 137.6,55.68 137.6,55.47 137.53,55.4 137.53,55.36 137.48,55.31 137.48,52.72 137.56,52.64 137.56,47.12 137.03,46.58 137.03,45.92 137.36,45.59 137.36,42.03 137.87,41.52 138.58,41.52 138.68,41.62 v2(138.68,41.92)
  BOTTOM w0.076: UC1.AU40 v2(132.96,61.38) ; UD3.E10 v2(138.68,41.92)
DDR_B_D17: length 27
  IN1 w0.08: v2(138.02,41.11) 137.86,41.11 137.07,41.9 137.07,45.47 136.74,45.8 136.74,46.67 137.26,47.2 137.26,52.52 137.07,52.71 137.07,53.01 137.19,53.12 137.19,53.38 137.09,53.48 136.9,53.48 136.79,53.59 136.79,53.77 136.9,53.88 137.09,53.88 137.19,53.99 137.19,54.19 137.09,54.29 136.9,54.29 136.8,54.39 136.8,54.6 136.9,54.7 137.09,54.7 137.19,54.8 137.19,54.98 137.09,55.08 136.92,55.08 136.75,55.26 136.75,55.95 136.71,55.99 136.71,57.01 133.97,59.74 133.08,59.74 132.56,60.27 132.56,61.99 132.68,62.11 v2(132.92,62.11)
  BOTTOM w0.076: UC1.AT40 v2(132.92,62.11) ; UD3.F8 v2(138.02,41.11)
DDR_B_D18: length 27.6
  IN1 w0.08: v2(134.73,62.11) 134.73,62.02 135.84,60.91 135.85,60.91 135.86,60.91 135.94,60.91 136.47,60.39 136.78,60.39 136.86,60.31 136.86,60.17 136.71,60.02 136.71,59.87 136.85,59.73 136.99,59.73 137.14,59.88 137.29,59.88 137.45,59.72 138.44,59.72 140.24,57.92 140.24,57.58 140.34,57.48 140.67,57.48 140.78,57.38 140.78,57.18 140.67,57.08 140.34,57.08 140.24,56.97 140.24,56.77 140.34,56.67 140.39,56.67 140.49,56.57 140.49,56.36 140.39,56.26 140.34,56.26 140.24,56.16 140.24,47.96 140.14,47.86 139.76,47.86 139.67,47.77 139.67,47.64 139.76,47.54 140.41,47.54 140.51,47.45 140.51,47.32 140.41,47.22 139.76,47.22 139.67,47.13 139.67,47 139.76,46.9 140.14,46.9 140.24,46.81 140.24,46.2 v2(139.63,45.59)
  BOTTOM w0.076: UD3.F11 138.68,43.41 138.68,44.74 139.53,45.59 v2(139.63,45.59) ; UC1.AT37 v2(134.73,62.11)
DDR_B_D19: length 27.3
  IN1 w0.08: v2(138.72,42.71) 139.05,42.71 139.19,42.86 139.19,43.09 139.29,43.2 139.46,43.2 139.56,43.3 139.56,43.5 139.46,43.6 139.29,43.6 139.19,43.7 139.19,43.98 139.05,44.12 139.05,46.69 139.35,46.99 139.35,48.1 139.44,48.2 139.78,48.2 139.87,48.29 139.87,48.42 139.78,48.52 139.44,48.52 139.35,48.61 139.35,48.74 139.44,48.84 139.78,48.84 139.87,48.93 139.87,49.06 139.78,49.16 139.44,49.16 139.35,49.25 139.35,49.38 139.44,49.48 139.78,49.48 139.87,49.57 139.87,49.7 139.78,49.8 139.44,49.8 139.35,49.89 139.35,50.02 139.44,50.12 139.78,50.12 139.87,50.21 139.87,50.34 139.78,50.44 139.44,50.44 139.35,50.53 139.35,58.39 138.32,59.42 136.55,59.42 135.91,60.07 135.72,60.07 134.73,61.06 v2(134.73,61.46)
  BOTTOM w0.076: v2(138.72,42.71) UD3.F10 ; UC1.AU37 v2(134.73,61.46)
DDR_B_D20: length 27.7
  IN1 w0.08: v2(132.9,62.75) 132.26,62.11 132.26,60.15 132.96,59.45 133.85,59.45 136.41,56.89 136.41,55.87 136.45,55.83 136.45,55.15 136.5,55.1 136.5,53.17 136.78,52.89 136.78,52.59 136.97,52.4 136.97,47.29 136.44,46.76 136.44,45.68 136.78,45.34 136.78,41.78 137.86,40.7 138.29,40.7 v2(138.68,41.1)
  BOTTOM w0.076: UC1.AR40 v2(132.9,62.75) ; UD3.E9 v2(138.68,41.1)
DDR_B_D21: length 28.5
  IN1 w0.08: v2(138.04,41.92) 137.65,42.32 137.65,45.71 137.32,46.04 137.32,46.49 138.35,47.53 138.35,48.15 138.26,48.25 138.16,48.25 138.07,48.34 138.07,48.47 138.16,48.57 138.26,48.57 138.35,48.66 138.35,48.79 138.26,48.89 138.16,48.89 138.07,48.98 138.07,49.11 138.16,49.21 138.26,49.21 138.35,49.3 138.35,49.43 138.26,49.53 138.16,49.53 138.07,49.62 138.07,49.75 138.16,49.85 138.26,49.85 138.35,49.94 138.35,50.07 138.26,50.17 138.16,50.17 138.07,50.26 138.07,50.39 138.16,50.49 138.26,50.49 138.35,50.58 138.35,50.71 138.26,50.81 138.16,50.81 138.07,50.9 138.07,51.03 138.16,51.13 138.26,51.13 138.35,51.22 138.35,51.35 138.26,51.45 138.16,51.45 138.07,51.54 138.07,51.67 138.16,51.77 138.26,51.77 138.35,51.86 138.35,57.03 137.1,58.27 136.95,58.27 136.72,58.04 136.51,58.04 136.41,58.14 136.41,58.33 136.31,58.43 136.12,58.43 133.38,61.17 133.38,62.9 v2(132.9,63.38)
  BOTTOM w0.076: UD3.F9 v2(138.04,41.92) ; UC1.AP40 v2(132.9,63.38)
DDR_B_D22: length 29
  IN1 w0.08: v2(134.73,63.38) 135.27,62.84 135.27,62.44 135.28,62.44 135.28,61.97 135.28,61.96 135.28,61.95 135.49,61.74 135.5,61.74 135.94,61.31 136.2,61.31 136.52,60.98 138.36,60.98 138.93,60.41 138.93,60.12 141.43,57.62 141.43,56.45 140.82,55.84 140.82,48.74 141.83,47.74 141.83,43.92 141.02,43.11 140.46,43.11 140.44,43.1 139.84,43.1 139.33,42.58 v2(139.33,41.91)
  BOTTOM w0.076: UC1.AP37 v2(134.73,63.38) ; UD3.D9 v2(139.33,41.91)
DDR_B_D23: length 28.7
  IN1 w0.08: v2(139.64,44.42) 140.62,44.42 140.86,44.66 140.86,45.43 140.95,45.53 141.3,45.53 141.39,45.62 141.39,45.75 141.3,45.85 140.95,45.85 140.86,45.94 140.86,46.07 140.95,46.17 141.3,46.17 141.39,46.26 141.39,46.39 141.3,46.49 140.95,46.49 140.86,46.58 140.86,46.71 140.95,46.81 141.3,46.81 141.39,46.9 141.39,47.03 141.3,47.13 140.95,47.13 140.86,47.22 140.86,47.66 140.53,47.99 140.53,55.97 141.12,56.56 141.12,57.45 138.56,60.01 138.16,60.01 137.98,60.18 137.84,60.18 137.69,60.03 137.54,60.03 137.4,60.18 137.4,60.32 137.55,60.47 137.55,60.62 137.47,60.69 136.51,60.69 136.12,61.08 135.91,61.08 135.11,61.88 135.11,62.37 v2(134.73,62.75)
  BOTTOM w0.076: UD3.E11 139.34,43.42 139.34,44.12 v2(139.64,44.42) ; UC1.AR37 v2(134.73,62.75)
DDR_B_D24: length 28.8
  IN4 w0.08: v2(147.08,41.09) 146.79,41.38 146.03,41.38 145.66,41.75 145.53,41.75 145.44,41.66 145.31,41.66 145.22,41.75 145.22,41.89 145.31,41.98 145.31,42.11 145.21,42.2 145.08,42.2 144.99,42.11 144.86,42.11 144.76,42.21 144.76,42.34 144.85,42.43 144.85,42.56 144.76,42.65 144.63,42.65 144.54,42.57 144.41,42.57 144.31,42.66 144.31,42.79 144.4,42.88 144.4,43.01 144.11,43.31 144.11,46.96 142.93,48.13 142.93,53.96 142.22,54.66 142.22,55.93 141.25,56.9 141.25,57.63 140.18,58.7 139.77,58.7 138.7,59.77 137.99,59.77 136.92,60.83 136.92,61.75 v2(136.56,62.11)
  BOTTOM w0.076: v2(136.56,62.11) 136.74,62.25 UC1.AT33 ; UD4.T9 v2(147.08,41.09)
DDR_B_D25: length 28.5
  IN4 w0.08: v2(136.56,61.48) 136.56,60.78 137.87,59.47 138.58,59.47 139.64,58.41 140.06,58.41 140.96,57.51 140.96,56.78 141.93,55.81 141.93,54.54 142.64,53.83 142.64,51.52 142.64,51.52 142.64,48.04 143.84,46.84 143.84,42.61 145.36,41.09 146.42,41.09 146.84,40.67 147.26,40.67 v2(147.67,40.26)
  BOTTOM w0.076: UC1.AU33 136.74,61.61 v2(136.56,61.48) ; UD4.R8 v2(147.67,40.26)
DDR_B_D26: length 27
  IN4 w0.08: v2(147.06,42.72) 146.58,42.72 146.45,42.85 146.45,43.68 146.33,43.8 146.33,44.97 145.47,45.83 145.47,49.73 145.38,49.82 144.87,49.82 144.77,49.92 144.77,50.05 144.87,50.14 145.38,50.14 145.47,50.24 145.47,50.37 145.38,50.46 144.87,50.46 144.77,50.56 144.77,50.69 144.87,50.78 145.38,50.78 145.47,50.88 145.47,52.7 144.69,53.48 144.69,56.81 144.42,57.08 144,57.08 142.22,58.86 141.85,58.86 140.89,59.83 140.04,59.83 v2(138.39,61.48)
  BOTTOM w0.076: UC1.AU30 v2(138.39,61.48) ; UD4.T10 v2(147.06,42.72)
DDR_B_D27: length 28.3
  IN4 w0.08: v2(147.06,43.52) 146.6,43.99 146.6,45.09 145.74,45.96 145.74,46.5 145.83,46.59 146.1,46.59 146.19,46.68 146.19,46.82 146.1,46.91 145.83,46.91 145.74,47 145.74,47.14 145.83,47.23 146.1,47.23 146.19,47.32 146.19,47.46 146.1,47.55 145.83,47.55 145.74,47.64 145.74,47.78 145.83,47.87 146.1,47.87 146.19,47.96 146.19,48.1 146.1,48.19 145.83,48.19 145.74,48.28 145.74,48.42 145.83,48.51 146.1,48.51 146.19,48.6 146.19,48.74 146.1,48.83 145.83,48.83 145.74,48.92 145.74,49.06 145.83,49.15 146.1,49.15 146.19,49.24 146.19,49.38 146.1,49.47 145.83,49.47 145.74,49.56 145.74,49.7 145.83,49.79 146.1,49.79 146.19,49.88 146.19,50.02 146.1,50.11 145.83,50.11 145.74,50.2 145.74,52.81 144.99,53.57 144.99,56.93 144.57,57.35 144.11,57.35 142.31,59.15 142.14,59.15 141.19,60.11 140.28,60.11 138.39,62 v2(138.39,62.11)
  BOTTOM w0.076: UD4.T11 v2(147.06,43.52) ; UC1.AT30 v2(138.39,62.11)
DDR_B_D28: length 29.1
  IN4 w0.08: v2(136.56,62.75) 137.09,62.22 137.09,61.08 138.11,60.06 138.83,60.06 139.89,59 140.3,59 141.6,57.69 142.01,57.69 143.23,56.47 143.23,56.11 143.12,56 143.12,55.79 143.23,55.68 143.23,55.47 143.12,55.36 143.12,55.15 143.23,55.04 143.23,48.39 144.39,47.23 144.39,43.41 146.12,41.68 147.15,41.68 v2(147.72,41.11)
  BOTTOM w0.076: UD4.R9 v2(147.72,41.11) ; v2(136.56,62.75) 136.74,62.89 UC1.AR33
DDR_B_D29: length 30.4
  IN4 w0.08: v2(136.56,63.38) 136.19,63.02 136.19,60.74 137.75,59.18 138.46,59.18 139.52,58.12 139.93,58.12 140.67,57.39 140.67,56.66 141.64,55.69 141.64,54.42 142.35,53.71 142.35,47.9 143.57,46.68 143.57,42.47 145.8,40.24 147,40.24 v2(147.02,40.26)
  BOTTOM w0.076: v2(136.56,63.38) 136.74,63.53 UC1.AP33 ; UD4.T8 v2(147.02,40.26)
DDR_B_D30: length 28.4
  IN4 w0.08: v2(138.39,63.38) 138.75,63.02 138.75,61.88 139.8,60.84 140.98,60.84 141.35,60.47 141.35,60.39 142.3,59.45 142.4,59.45 144.22,57.63 144.71,57.63 145.29,57.04 145.29,56 145.39,55.89 145.7,55.89 145.81,55.79 145.81,55.59 145.7,55.49 145.39,55.49 145.29,55.39 145.29,53.65 146.01,52.93 146.01,50.82 146.5,50.33 146.5,49.75 146.59,49.66 146.66,49.66 146.75,49.57 146.75,49.43 146.66,49.34 146.59,49.34 146.5,49.25 146.5,49.11 146.59,49.02 146.66,49.02 146.75,48.93 146.75,48.79 146.66,48.7 146.59,48.7 146.5,48.61 146.5,48.47 146.59,48.38 146.66,48.38 146.75,48.29 146.75,48.15 146.66,48.06 146.59,48.06 146.5,47.97 146.5,47.83 146.59,47.74 146.66,47.74 146.75,47.65 146.75,47.51 146.66,47.42 146.59,47.42 146.5,47.33 146.5,47.19 146.59,47.1 146.66,47.1 146.75,47.01 146.75,46.87 146.66,46.78 146.59,46.78 146.5,46.69 146.5,46.55 146.59,46.46 146.66,46.46 146.75,46.37 146.75,46.23 146.66,46.14 146.59,46.14 146.5,46.05 146.5,45.72 147.71,44.51 v2(147.71,43.52)
  BOTTOM w0.076: UD4.R11 v2(147.71,43.52) ; UC1.AR30 v2(138.39,63.38)
DDR_B_D31: length 29.6
  IN4 w0.08: v2(138.39,64.02) 138.92,63.48 138.92,61.97 139.78,61.11 141.12,61.11 144.33,57.9 144.85,57.9 146.22,56.53 146.22,54.82 146.04,54.64 145.69,54.64 145.56,54.52 145.56,53.76 145.63,53.69 145.77,53.69 145.85,53.77 145.98,53.77 146.07,53.67 146.07,53.54 145.99,53.46 145.99,53.33 146.28,53.04 146.28,50.93 147.03,50.18 147.03,45.57 148.02,44.58 148.02,43.79 148.17,43.64 148.53,43.64 148.63,43.54 148.63,43.33 148.53,43.23 148.22,43.23 v2(147.71,42.72)
  BOTTOM w0.076: UC1.AP30 v2(138.39,64.02) ; UD4.R10 v2(147.71,42.72)
DDR_B_D32: length 27.2
  IN4 w0.08: v2(139.8,52.17) 139.38,51.76 139.38,48.9 139.02,48.54 138.89,48.54 138.82,48.61 138.69,48.61 138.59,48.52 138.59,48.38 138.66,48.31 138.66,48.18 138.57,48.09 138.44,48.09 138.37,48.16 138.24,48.16 138.14,48.06 138.14,47.93 138.21,47.86 138.21,47.73 137.74,47.25 137.46,47.25 137.35,47.14 137.35,41.58 137.55,41.37 137.55,41 138.06,40.5 138.35,40.5 138.54,40.69 138.91,40.69 139.17,40.44 139.43,40.44 139.69,40.69 139.88,40.69 139.88,40.7 140.18,40.7 140.44,40.43 140.77,40.43 141.31,40.97 v2(141.31,41.1)
  BOTTOM w0.076: UD3.B9 v2(141.31,41.1) ; UC1.AY31 138.97,59.79 138.7,59.53 138.7,59.24 138.55,58.87 138.55,58.87 138.55,58.46 138.67,58.34 138.67,54.05 138.71,54.01
  BOTTOM w0.127: 138.71,54.01 138.71,52.72 139.26,52.17 v2(139.8,52.17)
DDR_B_D33: length 27.1
  IN4 w0.08: v2(139.98,43.51) 139.86,43.39 139.71,43.39 139.48,43.62 139.48,43.84 139.66,44.02 139.92,44.02 140.02,44.12 140.02,44.29 140.13,44.4 140.3,44.4 140.43,44.27 140.43,44.03 140.53,43.93 140.88,43.93 141.12,43.68 141.36,43.68 141.98,44.3 141.98,45.24 141.8,45.42 141.67,45.42 140.89,44.64 140.76,44.64 140.66,44.73 140.66,44.87 141.44,45.65 141.44,45.78 141.35,45.87 141.22,45.87 140.87,45.52 140.74,45.52 140.64,45.62 140.64,45.75 140.99,46.1 140.99,46.23 140.83,46.4 140.83,55.93 140.67,56.08 140.33,56.08 140.26,56.15 140.26,57.02 140.16,57.12 v2(139.77,57.12)
  BOTTOM w0.076: v2(139.77,57.12) 140.12,57.48 140.12,58.09 139.87,58.34 139.87,58.87 139.88,58.89 139.88,59.15 139.87,59.18 139.87,59.52 139.88,59.54 139.88,60.36 139.88,60.37 139.6,60.65 UC1.AW31 ; UD3.C11 v2(139.98,43.51)
DDR_B_D34: length 26.6
  IN4 w0.08: v2(139.81,50.98) 139.67,50.84 139.67,48.61 138.59,47.52 138.59,47.23 138.5,47.13 138.01,47.13 137.91,47.04 137.91,46.91 138.01,46.81 138.5,46.81 138.59,46.72 138.59,46.51 138.19,46.11 138.19,45.97 138.59,45.57 138.59,45.44 138.5,45.35 138.37,45.35 137.96,45.75 137.83,45.75 137.62,45.53 137.62,45.05 137.71,44.95 138.35,44.95 138.45,44.86 138.45,44.73 138.35,44.63 137.71,44.63 137.62,44.54 137.62,41.78 137.88,41.52 138.51,41.52 138.51,41.51 138.99,41.51 139.13,41.37 139.13,41.22 139.23,41.12 v2(139.98,41.12)
  BOTTOM w0.076: 140.32,53.65 140.32,58.12 140.04,58.41 140.04,58.84 140.05,58.85 140.05,58.86 140.05,59.18 140.04,59.22 140.04,59.49 140.09,59.64 140.09,59.9 UC1.AY29 ; UD3.C9 v2(139.98,41.12)
  BOTTOM w0.127: 140.32,53.65 140.32,51.49 140.23,51.4 140.23,51.39 139.97,51.13 139.96,51.13 v2(139.81,50.98)
DDR_B_D35: length 26.8
  IN4 w0.08: v2(141.31,41.91) 141.86,41.91 142.06,42.1 142.49,42.1 142.67,41.92 142.67,40.45 142.77,40.35 143.74,40.35 143.86,40.47 143.86,40.65 143.71,40.8 143.25,40.8 143.17,40.88 143.17,46.48 141.94,47.71 141.94,53.54 v2(141.24,54.24)
  BOTTOM w0.076: UC1.AW29 140.19,60.43 140.5,60.12 140.5,59.57 140.74,59.34 140.74,58.41 140.82,58.33 140.82,54.67 v2(141.24,54.24) ; UD3.B10 v2(141.31,41.91)
DDR_B_D36: length 25.5
  IN4 w0.08: v2(141.3,40.34) 140.06,39.61 139.87,39.56 137.94,39.56 137.68,39.65 136.44,40.88 136.38,41.06 136.38,41.17 136.43,41.35 136.76,41.95 136.76,47.57 138.8,49.61 138.8,52.02 139.01,52.39 139.23,53.31 139.48,53.74 v2(139.77,54.04)
  BOTTOM w0.076: v2(139.77,54.04) 139.31,54.5 139.31,54.75 139.01,55.04 139.01,58.46 138.97,58.51 UC1.BB31 ; UD3.B8 v2(141.3,40.34)
DDR_B_D37: length 25.8
  IN4 w0.08: v2(139.79,52.77) 139.32,52.31 139.32,52.12 139.09,51.89 139.09,49.52 137.66,48.08 137.66,47.95 137.76,47.84 137.76,47.71 137.67,47.62 137.54,47.62 137.43,47.72 137.3,47.72 137.05,47.48 137.05,41.46 137.19,41.32 137.19,40.81 137.15,40.77 137.15,40.62 137.29,40.48 137.44,40.48 137.48,40.52 137.62,40.52 137.77,40.38 137.77,40.23 137.73,40.19 137.73,40.05 137.87,39.9 138.01,39.9 138.17,40.06 138.38,40.06 138.61,39.83 138.97,39.83 139.1,39.96 139.1,40.04 139.23,40.17 139.37,40.17 139.5,40.04 139.5,39.96 139.61,39.86 139.79,39.86 139.89,39.96 v2(139.89,40.28)
  BOTTOM w0.076: 139.13,54.16 139.13,54.37 138.83,54.66 138.83,58.41 138.71,58.53 138.71,58.83 138.82,59.05 138.97,59.2 UC1.BA31 ; UD3.C8 139.89,40.28 v2(139.89,40.28)
  BOTTOM w0.127: v2(139.79,52.77) 139.72,52.77 139.13,53.36 139.13,54.16
DDR_B_D38: length 25.3
  IN4 w0.08: v2(140.63,42.71) 140.47,42.56 140.47,41.01 140.58,40.91 140.8,40.91 140.9,41.01 140.9,42.28 141.08,42.46 142.82,42.46 142.9,42.54 142.9,42.9 142.81,42.99 142.71,42.99 142.61,43.08 142.61,43.22 142.71,43.31 142.81,43.31 142.9,43.4 142.9,46.34 141.42,47.83 141.42,47.99 141.57,48.14 141.57,48.31 141.42,48.46 141.42,48.63 141.57,48.78 141.57,48.95 141.42,49.1 141.42,49.27 141.57,49.42 141.57,49.59 141.42,49.74 141.42,49.91 141.57,50.06 141.57,50.23 141.42,50.38 141.42,50.55 141.57,50.7 141.57,50.87 141.42,51.02 141.42,51.19 141.57,51.34 141.57,51.51 141.42,51.66 141.42,51.87 141.65,52.1 141.65,53.19 v2(141.24,53.6)
  BOTTOM w0.076: v2(141.24,53.6) 140.65,54.18 140.65,58.26 140.57,58.34 140.57,59.07 UC1.BA29 ; UD3.C10 v2(140.63,42.71)
DDR_B_D39: length 24.6
  IN4 w0.08: v2(140.64,43.52) 140.85,43.52 141.01,43.37 141.01,42.85 141.11,42.75 141.62,42.75 141.7,42.82 141.7,43.04 141.52,43.21 141.52,43.42 142.05,43.95 142.55,43.95 142.63,44.03 142.63,44.17 142.54,44.27 142.35,44.27 142.26,44.36 142.26,44.49 142.35,44.59 142.54,44.59 142.63,44.68 142.63,44.81 142.54,44.91 142.35,44.91 142.26,45 142.26,45.13 142.35,45.23 142.54,45.23 142.63,45.32 142.63,45.45 142.54,45.55 142.35,45.55 142.26,45.64 142.26,45.77 142.35,45.87 142.54,45.87 142.63,45.96 142.63,46.23 142.52,46.34 142.25,46.34 141.87,45.96 141.73,45.96 141.64,46.05 141.64,46.19 142.07,46.62 142.07,46.75 141.98,46.85 141.85,46.85 141.41,46.41 141.28,46.41 141.15,46.55 141.15,46.96 141.24,47.05 141.48,47.05 141.57,47.15 141.57,47.28 141.48,47.37 141.24,47.37 141.15,47.47 141.15,52.25 v2(141.24,52.35)
  BOTTOM w0.076: UD3.B11 v2(140.64,43.52) ; UC1.BB29 140.29,58.39 140.49,58.19 140.49,53.83 140.6,53.72
  BOTTOM w0.127: 140.6,53.72 140.73,53.59 140.73,52.86 v2(141.24,52.35)
DDR_B_D40: length 27.5
  IN1 w0.08: v2(142.56,56.19) 142.97,56.19 143.11,56.05 143.11,51.64 143.23,51.52 143.43,51.52 143.53,51.62 143.53,53.19 143.63,53.29 145.29,53.29 146.06,52.52 146.06,50.82 146.15,50.73 146.51,50.73 146.6,50.64 146.6,50.5 146.51,50.41 146.15,50.41 146.06,50.32 146.06,46.12 147.46,44.71 147.46,44.37 148.6,43.23 149.16,43.23 v2(149.67,42.73)
  BOTTOM w0.076: UD4.M10 v2(149.67,42.73) ; UC1.AY27 141.52,59.9 141.52,59.63 141.58,59.48 141.58,59.21 141.57,59.18 141.57,58.86 141.58,58.83 141.58,58.53 141.56,58.51 141.56,56.86 142.23,56.19 v2(142.56,56.19)
DDR_B_D41: length 28.2
  IN1 w0.08: v2(141.23,55.52) 141.98,54.78 141.98,48.6 144.01,46.56 144.01,41.76 146.22,39.56 149.31,39.56 150,40.25 v2(150.15,40.25)
  BOTTOM w0.076: UD4.M8 v2(150.15,40.25) ; UC1.AW27 141.42,60.46 141.1,60.14 141.1,59.59 140.9,59.39 140.9,58.48 141.07,58.31 141.07,55.69 v2(141.23,55.52)
DDR_B_D42: length 27.3
  IN1 w0.08: v2(150.34,43.52) 150.58,43.77 150.58,43.91 150.35,44.15 150.15,44.15 149.97,43.97 149.79,43.97 149.52,44.24 149.38,44.24 149.12,43.99 148.98,43.99 148.84,44.13 148.84,44.28 149.3,44.74 149.3,45.09 148.42,45.97 148.29,45.97 147.9,45.58 147.76,45.58 147.67,45.68 147.67,45.81 148.06,46.2 148.06,46.33 147.92,46.47 147.92,49.81 147.83,49.9 147.63,49.9 147.54,50 147.54,50.13 147.63,50.22 147.83,50.22 147.92,50.32 147.92,50.53 148.27,50.88 148.27,52.35 147.65,52.97 147.4,52.97 146.28,54.09 146.28,54.46 146.1,54.64 145.64,54.64 145.26,55.02 145.26,55.21 145.42,55.36 145.42,55.5 145.27,55.65 145.13,55.65 144.98,55.49 144.83,55.49 144.69,55.64 144.69,55.78 144.84,55.93 144.84,56.08 144.7,56.22 144.55,56.22 144.4,56.07 v2(144.26,56.07)
  BOTTOM w0.076: UD4.M9 150.34,41.86 v2(150.34,43.52) ; v2(144.26,56.07) 144.25,56.07 143.4,56.93 143.4,57.87 143.09,58.18 143.09,58.82 142.92,59.18 142.92,59.72 UC1.AY25
DDR_B_D43: length 28.3
  IN1 w0.08: v2(149.02,41.14) 148.76,40.13 148.48,39.85 146.34,39.85 144.28,41.91 144.28,46.76 142.27,48.78 142.27,54.85 141.89,56.27 141.83,56.82 v2(141.92,57.21)
  BOTTOM w0.076: UD4.N10 149.02,41.99 v2(149.02,41.14) ; UC1.AW25 142.01,60.65 141.79,60.42 141.73,60.34 141.73,59.54 141.74,59.51 141.74,59.18 141.73,59.15 141.73,58.89 141.75,58.83 141.75,57.38 141.75,57.38 v2(141.92,57.21)
DDR_B_D44: length 26.1
  IN1 w0.08: v2(148.34,41.11) 147.91,40.69 146.69,40.69 144.55,42.83 144.55,46.87 142.67,48.75 142.67,49.12 142.77,49.22 143.28,49.22 143.38,49.31 143.38,49.44 143.28,49.54 142.77,49.54 142.67,49.63 142.67,49.76 142.77,49.86 143.28,49.86 143.38,49.95 143.38,50.08 143.28,50.18 142.77,50.18 142.67,50.27 142.67,50.4 142.77,50.5 143.28,50.5 143.38,50.59 143.38,50.72 143.28,50.82 142.77,50.82 142.67,50.91 v2(142.67,54.97)
  BOTTOM w0.076: v2(142.67,54.97) 141.4,56.25 141.4,58.62 UC1.BB27 ; UD4.P9 v2(148.34,41.11)
DDR_B_D45: length 26.6
  IN1 w0.08: v2(149.67,41.1) 149.06,41.7 146.6,41.7 144.82,43.48 144.82,48.14 144.73,48.23 144.21,48.23 144.11,48.33 144.11,48.46 144.21,48.55 144.73,48.55 144.82,48.65 144.82,50.2 144.73,50.29 144.46,50.29 144.37,50.38 144.37,50.52 144.46,50.61 144.73,50.61 144.82,50.7 144.82,51.28 v2(145.05,51.51)
  BOTTOM w0.076: UD4.N9 v2(149.67,41.1) ; UC1.BA27 141.07,59.09 141.07,58.55 141.23,58.38 141.23,56.12 142,55.35 142,55.04
  BOTTOM w0.127: 142,55.04 142,53.57 v1(142.87,52.7) 144.06,51.51 v2(145.05,51.51)
DDR_B_D46: length 26.7
  IN1 w0.08: v2(148.68,45.04) 148.68,45.04 147.9,45.04 147.11,45.83 147.11,46.01 147.2,46.1 147.47,46.1 147.57,46.19 147.57,46.33 147.47,46.42 147.2,46.42 147.11,46.51 147.11,46.65 147.2,46.74 147.47,46.74 147.57,46.83 147.57,46.97 147.47,47.06 147.2,47.06 147.11,47.15 147.11,47.29 147.2,47.38 147.47,47.38 147.57,47.47 147.57,47.61 147.47,47.7 147.2,47.7 147.11,47.79 147.11,47.93 147.2,48.02 147.47,48.02 147.57,48.11 147.57,48.25 147.47,48.34 147.2,48.34 147.11,48.44 147.11,48.57 147.2,48.66 147.47,48.66 147.57,48.76 147.57,48.89 147.47,48.98 147.2,48.98 147.11,49.08 147.11,49.21 147.2,49.3 147.47,49.3 147.57,49.4 147.57,49.53 147.47,49.62 147.2,49.62 147.11,49.72 147.11,50.12 147.98,50.99 147.98,52.22 147.53,52.67 147.28,52.67 147.11,52.85 146.96,52.85 146.86,52.74 146.71,52.74 146.57,52.88 146.57,53.03 146.68,53.13 146.68,53.28 146.53,53.42 146.39,53.42 146.28,53.32 146.14,53.32 145.93,53.52 145.93,53.67 146.01,53.75 146.01,53.89 145.82,54.09 145.67,54.09 145.51,53.93 145.21,53.93 145.03,54.11 145.03,54.26 145.23,54.46 145.23,54.6 145.09,54.75 144.94,54.75 144.74,54.55 144.6,54.55 v2(144.26,54.89)
  BOTTOM w0.076: v2(144.26,54.89) 143.82,55.33 143.82,56.18 143.22,56.78 143.22,57.82 142.92,58.11 142.92,58.78 142.82,59 142.8,59.05 142.65,59.2 UC1.BA25 ; v2(148.68,45.04) 149,44.73 149,43.47 UD4.N11
DDR_B_D47: length 25.9
  IN1 w0.08: v2(144.27,54.3) 144.27,54.3 144.96,53.61 145.38,53.61 146.36,52.63 146.36,51.83 146.44,51.74 146.74,51.74 146.86,51.87 146.86,52.23 147.01,52.38 147.41,52.38 147.69,52.1 147.69,51.08 146.33,49.72 146.33,49.52 146.42,49.43 146.74,49.43 146.83,49.34 146.83,49.2 146.74,49.11 146.42,49.11 146.33,49.02 146.33,48.88 146.42,48.79 146.74,48.79 146.83,48.7 146.83,48.56 146.74,48.47 146.42,48.47 146.33,48.38 146.33,48.24 146.42,48.15 146.74,48.15 146.83,48.06 146.83,47.92 146.74,47.83 146.42,47.83 146.33,47.73 146.33,47.6 146.42,47.51 146.74,47.51 146.83,47.41 146.83,47.28 146.74,47.19 146.42,47.19 146.33,47.09 146.33,46.96 146.42,46.87 146.65,46.87 146.73,46.79 146.73,46.63 146.65,46.55 146.42,46.55 146.33,46.45 146.33,46.23 147.76,44.8 147.76,44.49 148.68,43.57 149.62,43.57 v2(149.66,43.52)
  BOTTOM w0.076: v2(149.66,43.52) UD4.M11 ; UC1.BB25 142.76,58.58 142.76,58.04 143.05,57.75 143.05,56.71 143.64,56.12 143.64,55.25 143.86,55.03 143.86,54.7 v2(144.27,54.3)
DDR_B_D48: length 31.7
  IN1 w0.08: v2(140.21,61.46) 140.21,60.52 140.64,60.1 140.9,60.1 143.02,57.97 144.77,57.97 147.75,55 148.76,55 150.04,53.72 150.04,52.48 149.52,51.97 149.52,47.75 149.71,47.57 149.71,47.43 149.4,47.13 149.4,46.99 149.49,46.9 149.63,46.9 149.93,47.21 150.06,47.21 150.16,47.11 150.16,46.98 149.85,46.67 149.85,46.54 149.95,46.45 150.08,46.45 150.39,46.75 150.52,46.75 152.27,45 152.27,43.24 153.18,42.33 154.47,42.33 154.87,41.93 v2(154.88,41.93)
  BOTTOM w0.076: UC1.AU27 v2(140.21,61.46) ; v2(154.88,41.93) UD4.D9
DDR_B_D49: length 32.3
  IN1 w0.08: v2(140.21,62.11) 140.21,62 140,61.79 139.84,61.63 139.84,60.51 142.13,58.22 142.35,58.22 142.91,57.67 144.67,57.67 147.63,54.71 148.64,54.71 149.75,53.6 149.75,52.58 149.22,52.05 149.22,49.37 149.13,49.27 148.98,49.27 148.89,49.18 148.89,49.05 148.98,48.95 149.13,48.95 149.22,48.86 149.22,48.73 149.13,48.63 148.98,48.63 148.89,48.54 148.89,48.41 148.98,48.31 149.13,48.31 149.22,48.22 149.22,48.09 149.13,47.99 148.98,47.99 148.89,47.9 148.89,47.77 148.98,47.67 149.13,47.67 149.22,47.58 149.22,47.45 149.13,47.35 148.98,47.35 148.89,47.26 148.89,47.02 150.26,45.65 150.39,45.65 150.51,45.77 150.64,45.77 150.74,45.68 150.74,45.55 150.61,45.42 150.61,45.29 150.71,45.2 150.84,45.2 150.96,45.32 151.1,45.32 151.19,45.23 151.19,45.1 151.07,44.97 151.07,44.84 151.98,43.92 151.98,43.09 153.15,41.92 v2(153.56,41.92)
  BOTTOM w0.076: v2(153.56,41.92) UD4.F9 ; UC1.AT27 v2(140.21,62.11)
DDR_B_D50: length 30.9
  IN1 w0.08: v2(141.13,62.11) 141.13,62 142.35,60.78 142.35,60.47 143.52,59.29 146.34,59.29 147.09,58.54 147.09,58.31 147.19,58.21 147.41,58.21 147.51,58.11 147.51,57.91 147.41,57.81 147.25,57.81 147.15,57.7 147.15,57.49 147.82,56.81 147.96,56.81 148.28,57.13 148.45,57.13 148.56,57.01 148.56,56.84 148.25,56.53 148.25,56.38 148.35,56.29 148.63,56.29 148.87,56.52 149.06,56.52 152.05,53.53 152.05,51.18 151.43,50.55 151.43,48.03 154.18,45.28 154.18,44.26 154.08,44.16 153.93,44.16 153.83,44.06 153.83,43.85 153.93,43.75 154.08,43.75 154.18,43.65 154.18,42.79 v2(154.22,42.75)
  BOTTOM w0.076: v2(154.22,42.75) UD4.F10 ; UC1.AT25 v2(141.13,62.11)
DDR_B_D51: length 30.5
  IN1 w0.08: v2(153.7,44.51) 153.7,44.95 153.1,45.55 153.1,45.68 153.14,45.72 153.14,45.85 153.04,45.94 152.91,45.94 152.88,45.91 152.74,45.91 152.65,46 152.65,46.13 152.68,46.17 152.68,46.3 152.59,46.39 152.46,46.39 152.42,46.36 152.29,46.36 152.2,46.45 152.2,46.59 152.23,46.62 152.23,46.75 152.14,46.85 152.01,46.85 151.97,46.81 151.84,46.81 151.74,46.91 151.74,47.04 151.78,47.07 151.78,47.21 151.68,47.3 151.55,47.3 151.52,47.27 151.39,47.27 151.1,47.55 151.1,48.11 151,48.21 150.71,48.21 150.61,48.3 150.61,48.43 150.71,48.53 151,48.53 151.1,48.62 151.1,48.75 151,48.85 150.71,48.85 150.61,48.94 150.61,49.07 150.71,49.17 151,49.17 151.1,49.26 151.1,49.39 151,49.49 150.71,49.49 150.61,49.58 150.61,49.71 150.71,49.81 151,49.81 151.1,49.9 151.1,50.61 151.76,51.27 151.76,53.41 149.17,56 148.16,56 146.8,57.36 146.8,58.42 146.22,59 143.39,59 141.91,60.48 141.91,60.7 v2(141.13,61.48)
  BOTTOM w0.076: UC1.AU25 v2(141.13,61.48) ; v2(153.7,44.51) 153.74,44.51 154.2,44.06 154.2,43.41 UD4.F11
DDR_B_D52: length 32.5
  IN1 w0.08: v2(154.22,41.93) 153.8,41.52 153.14,41.52 151.69,42.97 151.69,43.8 148.58,46.92 148.58,49.55 148.67,49.65 148.77,49.65 148.86,49.74 148.86,49.87 148.77,49.97 148.67,49.97 148.58,50.06 148.58,50.26 148.92,50.6 148.92,54.01 148.52,54.42 147.5,54.42 144.54,57.38 142.79,57.38 142.23,57.93 141.98,57.93 139.61,60.3 139.61,61.63 139.82,61.84 139.82,61.85 139.83,61.86 139.83,63.01 v2(140.21,63.38)
  BOTTOM w0.076: UC1.AP27 v2(140.21,63.38) ; v2(154.22,41.93) UD4.E9
DDR_B_D53: length 33
  IN1 w0.08: v2(140.21,64.02) 139.67,63.47 139.67,63.08 139.67,63.08 139.67,61.93 139.34,61.6 139.34,60.12 141.82,57.64 142.11,57.64 142.67,57.08 144.42,57.08 146.68,54.82 146.68,54.26 147.57,53.37 147.82,53.37 148.65,52.54 148.65,50.72 148.31,50.37 148.31,46.77 151.4,43.68 151.4,42.85 153.37,40.88 153.97,40.88 v2(154.2,41.11)
  BOTTOM w0.076: UC1.AN27 v2(140.21,64.02) ; UD4.F8 154.2,41.01 v2(154.2,41.11)
DDR_B_D54: length 32.8
  IN1 w0.08: v2(141.13,64.02) 141.67,63.48 141.67,61.93 142.55,61.05 143.24,61.05 143.82,60.47 143.82,60.33 143.71,60.21 143.71,60.07 143.85,59.93 143.99,59.93 144.11,60.04 144.25,60.04 144.42,59.87 146.58,59.87 147.43,59.03 147.56,59.03 147.61,59.07 147.74,59.07 147.83,58.98 147.83,58.84 147.79,58.8 147.79,58.67 147.88,58.57 148.02,58.57 148.06,58.62 148.19,58.62 148.28,58.52 148.28,58.39 148.24,58.35 148.24,58.22 148.34,58.12 148.47,58.12 148.51,58.16 148.64,58.16 148.74,58.07 148.74,57.94 148.69,57.9 148.69,57.76 148.79,57.67 148.92,57.67 148.96,57.71 149.1,57.71 149.19,57.62 149.19,57.49 149.15,57.44 149.15,57.31 149.24,57.22 149.37,57.22 149.42,57.26 149.55,57.26 149.64,57.17 149.64,57.03 149.6,56.99 149.6,56.86 149.69,56.76 149.83,56.76 149.87,56.81 150,56.81 150.09,56.71 150.09,56.58 150.05,56.54 150.05,56.41 150.15,56.31 150.28,56.31 150.32,56.35 150.45,56.35 150.55,56.26 150.55,56.13 150.5,56.08 150.5,55.95 150.6,55.86 150.73,55.86 150.77,55.9 150.91,55.9 151,55.81 151,55.68 150.96,55.63 150.96,55.5 151.05,55.41 151.18,55.41 151.23,55.45 151.36,55.45 151.45,55.36 151.45,55.22 151.41,55.18 151.41,55.05 151.5,54.95 151.64,54.95 151.68,55 151.81,55 151.91,54.9 151.91,54.77 151.86,54.73 151.86,54.59 151.96,54.5 152.09,54.5 152.13,54.54 152.26,54.54 152.36,54.45 152.36,54.32 152.32,54.27 152.32,54.14 152.67,53.78 152.67,51.03 152.39,50.75 152.39,47.86 154.88,45.37 v2(154.88,43.53)
  BOTTOM w0.076: UC1.AN25 v2(141.13,64.02) ; UD4.E11 v2(154.88,43.53)
DDR_B_D55: length 32.3
  IN1 w0.08: v2(141.13,63.38) 141.5,63.01 141.5,61.86 142.48,60.88 142.52,60.88 142.63,60.78 142.63,60.6 143.65,59.58 146.46,59.58 147.96,58.08 147.96,57.94 147.62,57.59 147.62,57.45 147.76,57.3 147.91,57.3 148.24,57.64 148.38,57.64 149.55,56.47 149.55,56.45 152.35,53.65 152.35,51.09 152.12,50.87 152.12,50.42 152.03,50.32 151.8,50.32 151.71,50.23 151.71,50.1 151.8,50 152.03,50 152.12,49.91 152.12,49.78 152.03,49.68 151.8,49.68 151.71,49.59 151.71,49.46 151.8,49.36 152.03,49.36 152.12,49.27 152.12,49.14 152.03,49.04 151.8,49.04 151.71,48.95 151.71,48.82 151.8,48.72 152.03,48.72 152.12,48.63 152.12,47.75 154.47,45.4 154.47,43.15 v2(154.89,42.73)
  BOTTOM w0.076: UC1.AP25 v2(141.13,63.38) ; v2(154.89,42.73) UD4.E10
