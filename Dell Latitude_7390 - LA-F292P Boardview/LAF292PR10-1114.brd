# Allegro board LAF292PR10-1114.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_P8: length 149
  TOP w0.088: CZ11.1 225.69,76.5 225.5,76.5 v3(225.38,76.63)
  GND1 w0.088: v4(225.87,76.71) 225.67,76.5 225.5,76.5 v3(225.38,76.63)
  IN1 w0.062: v4(142.63,86.16) 142.43,86.36 142.43,86.77 142.82,87.16 154.12,87.16 157.08,84.19 167.86,84.19 172.17,79.88 172.17,71.71 174.99,68.89 174.99,63.46 178.52,59.93 178.52,57.23 188.03,47.73 189.48,47.73 192.07,45.14 198.14,45.14 198.74,44.54 211.73,44.54 214.53,47.34 215.54,47.34 215.93,47.72 215.93,48.33 v4(216.16,48.56)
  IN2 w0.083: v4(225.87,76.71) 226.09,76.49 226.26,76.49 226.46,76.29 226.46,74.76 226.47,74.75 226.47,74.41 226.38,74.32 226.38,66.17 225.33,65.13 225.33,60.67 225.58,60.43 225.58,53.75 222.42,50.6 221.85,50.6 220.64,49.38 216.32,49.38 216.16,49.23 v4(216.16,48.56)
  GND5 w0.081: v4(142.63,86.16) 142.39,85.92 142.39,85.78 v5(142.47,85.7)
  BOTTOM w0.076: v5(142.47,85.7) 142.42,85.66 arc(142.34,85.54) 142.32,85.4 142.32,84.88 142.32,84.26 arc(142.34,84.15) 142.4,84.06 142.96,83.51 arc(143.15,83.25) 143.28,82.97 arc(143.43,82.66) 143.67,82.42 arc(143.88,82.15) 143.91,81.81 arc(143.88,81.65) 143.82,81.5 arc(143.77,81.33) 143.79,81.14 arc(143.82,80.98) 143.8,80.82 arc(143.78,80.72) 143.79,80.63 arc(143.8,80.57) 143.81,80.52 arc(143.84,80.36) 143.81,80.2 arc(143.77,80.06) 143.75,79.93 143.75,79.92 arc(143.75,79.92) 143.75,79.92 arc(143.75,79.92) 143.75,79.92 arc(143.76,79.83) 143.79,79.74 arc(143.88,79.68) 143.98,79.71 arc(144.06,79.86) UC1.C21
PCIE_PTX_DRX_P9: length 176
  IN1 w0.062: v4(141.35,81.27) 141.25,81.17 141.08,81.17 140.94,81.31 140.94,82.1 139.74,83.3 135.29,83.3 134.7,83.9 130.64,83.9 129.15,85.39 112.76,85.39 110.52,87.63 94.62,87.63 92.93,85.94 84.03,85.94 83.81,86.16 65.62,86.16 64.65,85.19 58.5,85.19 57.15,83.83 51.13,83.83 48.26,80.97 46.49,80.97 44.96,79.44 44.96,77 40.77,72.81 40.77,61.44 40.49,61.16 40.49,54.67 40.79,54.37 40.79,52.37 41.1,52.07 41.1,48.11 40.5,47.51 40.5,46.69 39.07,45.26 39.07,44.52 38.3,43.76 38.3,41.23 36.49,39.41 36.49,38 36.3,37.81 36.3,36.65 31.59,31.94 31.59,31.88 29.01,29.29 29.01,22.32 28.92,22.23 28.92,21.11 29.15,20.89 29.28,20.89 v4(29.48,20.68)
  GND5 w0.076: v4(141.35,81.27) 141.4,81.22 142.06,81.22 v5(142.42,81.58)
  GND5 w0.088: v4(29.48,20.68) 29.65,20.85 29.9,20.85 v5(29.99,20.76)
  BOTTOM w0.088: UC1.A23 142.7,81.43 142.55,81.58 v5(142.42,81.58) ; v5(29.99,20.76) 30.03,20.76 30.13,20.86 30.37,20.86 31.15,20.09 31.15,18.95 v7(31.15,18.95) 31.15,18.68 31.15,18.68 31.15,18.29 31.05,18.2 30.74,18.2 30.65,18.1 CN66.2
PCIE_PTX_DRX_P10: length 180
  IN1 w0.062: v4(142.92,80.07) 142.83,79.98 142.56,79.98 142.41,80.13 142.41,82.1 140.16,84.35 135.74,84.35 135.11,84.97 131.02,84.97 129.57,86.42 113.22,86.42 110.98,88.66 94.2,88.66 92.87,87.33 87.32,87.33 87.02,87.33 86.44,87.9 71.67,87.9 70.95,87.19 64.03,87.19 63.06,86.21 58.08,86.21 56.73,84.86 50.65,84.86 47.86,82.08 45.93,82.08 43.78,79.93 43.78,78 39.75,73.97 39.75,61.99 39.36,61.6 39.36,52.34 40.07,51.63 40.07,48.54 39.47,47.94 39.47,47.13 37.98,45.63 37.98,44.97 36.86,43.84 36.86,41.23 35.46,39.84 35.46,38.58 34.59,37.71 34.59,36.39 30.57,32.36 30.57,32.35 27.91,29.69 27.91,23.51 26.8,22.4 26.8,21.96 v4(26.59,21.75)
  GND5 w0.076: v4(142.92,80.07) 142.84,79.99 142.35,79.99 v5(142.31,80.02)
  GND5 w0.088: v4(26.59,21.75) 26.61,21.75 26.78,21.58 26.78,21.37 v5(26.68,21.27)
  BOTTOM w0.088: v5(26.68,21.27) 26.68,21.2 26.79,21.09 26.79,19.71 27.66,18.84 27.66,18.77 28.08,18.36 28.15,18.36 28.34,18.16 28.34,18.04 CN68.2 ; v5(142.31,80.02) UC1.C23
PCIE_PTX_DRX_P11: length 183.2
  IN1 w0.062: v4(25.21,18.64) 25.21,19.52 24.84,19.89 24.84,22.42 26.05,23.63 26.05,26.05 25.74,26.35 25.74,28.97 29.55,32.77 29.55,32.79 33.01,36.25 33.01,37.98 34.42,39.39 34.42,42.85 36.23,44.67 36.23,46.35 37.19,47.31 38.12,47.31 38.45,47.64 38.45,48.21 37.77,48.9 37.77,50.81 38.2,51.25 38.2,70.68 38.03,70.85 38.03,75.07 39.37,76.41 39.37,76.97 45.62,83.22 47.03,83.22 50,86.19 55.29,86.19 56.92,87.83 63.07,87.83 63.56,88.32 65.48,88.32 66.17,89.01 86.79,89.01 87.44,88.35 92.44,88.35 93.77,89.68 111.53,89.68 112.5,88.71 123.16,88.71 124.43,87.44 130,87.44 131.37,86.06 140.73,86.06 141.11,85.69 141.11,85.48 v2(141.31,85.27)
  GND5 w0.088: v5(25.06,17.69) 25.33,17.69 25.42,17.78 25.42,18.43 v4(25.21,18.64)
  BOTTOM w0.076: UC1.C24 142.37,80.3 arc(142.43,80.31) 142.46,80.37 142.46,80.51 arc(142.42,80.6) 142.32,80.65 142.32,80.65 arc(142.2,80.65) 142.08,80.65 142.07,80.65 arc(142.02,80.68) 141.99,80.73 141.99,80.86 arc(142,80.88) 142.01,80.9 arc(142.08,80.99) 142.11,81.09 arc(142.12,81.25) 142.13,81.4 142.13,82.55 arc(142.1,82.7) 142.02,82.82 141.24,83.6 arc(141.14,83.75) 141.1,83.94 141.1,84.34 141.1,84.96 arc(141.12,85.06) 141.17,85.13 v2(141.31,85.27)
PCIE_PTX_DRX_P12: length 175.6
  IN1 w0.062: v2(139.54,81.84) 139.52,81.81 139.52,80.99 138.29,79.76 135.73,79.76 135.31,79.34 132.8,79.34 132.39,79.74 117.67,79.74 117,80.41 115.47,80.41 114.5,81.39 112.31,81.39 109.39,84.31 95.34,84.31 93.73,82.7 69.55,82.7 69.13,82.28 64.92,82.28 64.38,81.74 59.36,81.74 57.65,80.03 53.16,80.03 44.19,71.06 44.19,47.54 43.09,46.44 43.09,44.87 40.92,42.7 40.92,39.35 41.14,39.14 41.14,37.78 32.94,29.57 32.94,28.65 31.39,27.11 31.39,24.79 31.04,24.44 31.04,20.97 27.76,17.68 22.59,17.68 22.38,17.89 22.38,18.33 v4(22.29,18.41)
  GND5 w0.088: v5(22.14,17.69) 22.5,18.05 22.5,18.21 v4(22.29,18.41)
  BOTTOM w0.076: UC1.B25 arc(141.63,80.84) 141.48,80.95 arc(141.26,81) 141.13,81.19 arc(140.99,81.54) 140.76,81.85 arc(140.38,82.14) 139.94,82.34 arc(139.7,82.37) 139.46,82.32 arc(139.41,82.3) 139.36,82.27 arc(139.31,82.23) 139.27,82.19 arc(139.24,82.12) 139.26,82.05 arc(139.38,81.92) v2(139.54,81.84)
PCIE_PTX_L_DRX_N7: length 5.7
  TOP w0.088: RI29.2 226.99,78.68 LI17.2 227.35,78.57 227.56,78.36 227.78,78.36 227.91,78.49 227.91,78.86 227.82,78.95 227.64,78.95 227.55,79.04 227.55,79.21 v2(227.62,79.28)
  BOTTOM w0.088: v2(227.62,79.28) 227.62,79.91 227.83,80.12 228.7,80.12 228.88,79.94 229.18,79.94 229.38,80.15 JNGFF2.35
PCIE_PTX_L_DRX_P7: length 5.7
  TOP w0.088: RI30.2 226.99,77.96 LI17.3 227.33,78.07 227.45,78.19 227.85,78.19 228.08,78.42 228.08,79.16 v2(228.2,79.28)
  BOTTOM w0.088: v2(228.2,79.28) 228.2,79.53 228.14,79.6 227.88,79.6 227.79,79.68 227.79,79.84 227.9,79.95 228.63,79.95 228.81,79.77 229.27,79.77 229.39,79.65 JNGFF2.37
PCIE_PTX_SW_DRX_N7: length 19.2
  TOP w0.088: UZ29.8 226.48,63.15 226.64,63.31 226.64,63.45 v2(226.46,63.64) ; v3(225.04,78.52) 225.15,78.41 225.46,78.41 225.62,78.57 LI17.1
  GND1 w0.088: v3(225.04,78.52) 225.15,78.4 225.71,78.4 v4(225.9,78.6)
  IN4 w0.062: v2(226.46,63.64) 226.7,63.88 226.7,64.05 225.15,65.6 225.15,78.37 225.3,78.52 225.82,78.52 v4(225.9,78.6)
PCIE_PTX_SW_DRX_P7: length 19.3
  TOP w0.088: v2(227.04,63.64) 226.84,63.43 226.84,63.31 226.98,63.17 UZ29.7 ; v3(225.04,78.11) 225.16,78.24 225.45,78.24 225.61,78.07 LI17.4
  GND1 w0.088: v3(225.04,78.11) 225.15,78.23 225.68,78.23 v4(225.9,78.01)
  IN4 w0.062: v2(227.04,63.64) 226.85,63.83 226.85,64.11 225.3,65.66 225.3,78.31 225.36,78.38 225.51,78.38 225.56,78.33 225.56,78.07 225.62,78.01 v4(225.9,78.01)
PCIE_RCOMPN: length 2
  TOP w0.102: v2(153.03,78.19) 152.94,78.19 v1(152.49,78.63)
  TOP w0.381: v2(153.03,78.19) 153.57,78.19 RC45.1
  BOTTOM w0.254: UC1.F5 153.43,78.04 153.03,78.19 v2(153.03,78.19)
PCIE_RCOMPP: length 2.3
  TOP w0.127: v1(154.78,78.93) RC45.2
  TOP w0.381: RC45.2 153.16,78.93 153.05,78.83 v2(153.03,78.83)
  BOTTOM w0.254: v2(153.03,78.83) 153.06,78.81 153.06,78.8 UC1.E5
PCIE_WAKE#: length 423.2
  TOP w0.076: JNGFF3.54 21.1,12.57
  TOP w0.086: v2(21.23,13.1) 21.63,13.51 21.63,14.07 RT421.2 20.79,13.71 20.79,12.87 21.1,12.57 ; v2(229.86,32.3) 229.86,32.25 229.28,31.67 v6(229.28,27.15) 229.28,26.35 v3(229.84,25.79) ; RE275.1 269.41,49.18 RE274.1 270.73,49.08 270.73,51.39 271.21,51.87 v2(271.32,51.87)
  GND1 w0.086: v3(229.84,25.79) 229.95,25.9 v4(230.42,25.9)
  IN1 w0.051: v4(249.66,74.93) 249.61,74.93 247.19,72.5 247.19,71.23 247.14,71.18 246.19,71.18 244.54,69.53 244.54,68.77 244.04,68.26 243.65,68.26 242.77,67.37 242.77,66.84 241.9,65.97 240.38,65.97 239.75,65.35 232.86,65.35 229.75,68.46 229.75,71.06 230.75,72.07 230.75,74.99 231.16,75.4 JNGFF2.54 ; v2(271.32,51.87) 271.05,51.61 271.05,50.97 270.11,50.03 270.11,47.74 268.98,46.6 268.98,46.16 269.44,45.7 269.44,44.36 267.88,42.8 266.57,42.8 v4(266.24,42.46)
  IN2 w0.061: v2(271.32,51.87) 271.75,51.87 272.04,52.17 272.04,52.78 271.99,52.83 271.99,53.17 274.15,55.34 274.15,60.37 275.15,61.36 275.15,64.74 271.23,68.67 267.17,68.67 263.8,72.04 258.92,72.04 257.95,73.01 252.39,73.01 251.78,73.62 250.97,73.62 v4(249.66,74.93)
  IN3 w0.061: v2(21.23,13.1) 22.3,14.18 27.78,14.18 31.09,17.48 31.09,22.85 33.01,24.77 33.01,25.15 33.41,25.54 34.2,25.54 38.33,29.67 50.42,29.67 50.59,29.5 58.56,29.5 58.77,29.29 91.36,29.29 91.7,28.95 105.05,28.95 108.33,25.67 142.53,25.67 144.9,28.04 155.01,28.04 157.73,25.31 191.25,25.31 191.42,25.14 193.51,25.14 193.68,25.31 227.06,25.31 227.65,25.9 v4(230.42,25.9) 231.01,25.31 240.11,25.31 241.61,26.81 251.31,26.81 252.58,25.54 257.81,25.54 262.09,29.82 v4(262.09,30.46)
  IN4 w0.051: v4(262.09,30.46) 262.58,30.95 262.58,36.67 261.61,37.63 261.61,38.52 262.22,39.13 262.22,40.01 264.76,42.55 266.15,42.55 v4(266.24,42.46)
  IN4 w0.062: v2(229.86,32.3) 229.86,32.43 232.44,35.01 235.76,35.01 236,35.26 239.68,35.26 241.72,37.3 241.72,38.29 242.33,38.9 JNGFF1.70
  BOTTOM w0.076: JNGFF1.70 242.2,38.9
  BOTTOM w0.086: RT448.1 10.89,10.74 12.64,12.49 12.64,13.02 13.41,13.8 14.31,13.8 15.69,15.17 18.18,15.17 19.22,14.13 19.22,13.5 20.01,12.71 20.84,12.71 v2(21.23,13.1) ; JNGFF1.55 241.42,42.65 241.8,42.27 241.8,39.3 242.2,38.9
PCIE_WAKE#_AR: length 83.8
  TOP w0.086: v6(21.87,16.48) 21.39,16 v3(21.39,15.22) RT422.1 RT454.1
  GND1 w0.086: v3(21.39,15.22) v4(21.96,15.22)
  IN1 w0.051: v4(36.59,63.46) 36.39,63.25 35.81,63.25 33.53,60.98 33.53,57.49 34.9,56.12 34.9,54.24 35.15,54 36.95,54 37.33,53.62 37.33,51.64 36.89,51.2 36.89,49.86 35.27,48.24 35.27,44.95 33.36,43.04 32.4,43.04 28.26,38.9 28.26,36.81 27.45,36 27.45,33.28 23.33,29.16 22.15,29.16 20.77,27.78 20.77,19.72 21.15,19.34 21.15,17.97 22.55,16.57 22.55,15.81 v4(21.96,15.22) 21.19,14.45 14.2,14.45 12.44,12.69 v2(12.44,11.67)
  GND5 w0.086: v4(36.59,63.46) 36.59,63.86 v5(36.42,64.04)
  BOTTOM w0.086: UT1.W1 36.25,63.87 v5(36.42,64.04) 36.42,64.83 RT455.1 ; v2(12.44,11.67) 10.72,9.95 RT441.2
PCIE_WAKE#_AR_R: length 6.5
  BOTTOM w0.086: RT440.2 9.04,8.73 10.26,8.73 v1(10.62,9.09) ; RT440.2 8.58,9.17 6.48,9.17 6.05,9.6 UT32.4 ; RT440.2 RT441.1
PCIE_WAKE#_R: length 7.2
  TOP w0.086: UE1.N13 270.32,53.68 v1(270.43,53.68) RE35.1 271.37,52.55 270.2,51.38 270.2,50.94 269.59,50.33 RE275.2
PD1_GPIO2: length 4.8
  BOTTOM w0.076: 32.46,76.44 32.46,75.78 UT5.D10
  BOTTOM w0.086: 32.46,76.44 32.46,76.55 32.75,76.84 33.46,76.84 33.71,77.09 34.29,77.09 34.51,77.3 35.17,77.3 RT71.1
PD1_GPIO6: length 3.3
  BOTTOM w0.076: 30.98,76.2 30.98,75.77 UT5.G10
  BOTTOM w0.086: 30.98,76.2 30.98,76.54 30.26,77.26 29.76,77.26 29.34,77.68 RT75.1
PD1_GPIO7: length 3.9
  BOTTOM w0.076: UT5.D7 32.97,74.27 34.33,74.27
  BOTTOM w0.086: 34.33,74.27 34.35,74.3 35.54,74.3 ; RT339.1 36.41,74.3 35.54,74.3 ; 35.54,74.3 v1(35.54,74.32)
PD1_GPIO8: length 5.1
  TOP w0.086: v2(30.24,73.33) 30.42,73.33 RT377.1 31.42,73.23 32.57,73.23 v1(32.83,73.49) 33.47,74.13 RT76.1
  BOTTOM w0.086: v2(30.24,73.33) 30.24,73.34 30.43,73.53 UT5.H6
PD1_USB20_N: length 5
  TOP w0.088: v2(26.51,72.5) 26.31,72.5 RT402.1
  BOTTOM w0.076: 28.5,72.85 28.52,72.85 28.52,72.86 28.97,72.86 29.04,72.78 29.41,72.78 29.65,73.03 UT5.K5
  BOTTOM w0.088: 28.5,72.85 27.87,72.85 27.57,72.55 26.56,72.55 v2(26.51,72.5) 26.31,72.5 RT402.1
PD1_USB20_P: length 4.9
  TOP w0.088: RT401.1 26.38,72.98 v2(26.51,73.11)
  BOTTOM w0.076: UT5.L5 29.21,73.02 28.52,73.02 28.52,73.02 28.5,73.02
  BOTTOM w0.088: RT401.1 26.38,72.98 v2(26.51,73.11) 26.7,73.3 26.96,73.3 27.04,73.22 27.04,73.11 26.88,72.95 26.88,72.82 26.96,72.74 27.51,72.74 27.8,73.02 28.5,73.02
PD2_GPIO2: length 2.3
  TOP w0.086: v3(31.87,43.44) 31.82,43.44 RT167.1
  GND1 w0.086: v3(31.87,43.44) 31.55,43.12 v4(31.49,43.12)
  GND5 w0.086: v5(30.73,43.12) v4(31.49,43.12)
PD2_GPIO6: length 2.9
  BOTTOM w0.076: UT11.G10 30.79,44.62 31.03,44.38 31.58,44.38 31.59,44.39
  BOTTOM w0.086: 31.59,44.39 31.71,44.39 32.45,43.65 RT171.1
PD2_GPIO7: length 5.6
  TOP w0.086: v3(29.3,41.89) 29.39,41.81 29.39,40.12 RT340.1 30.6,39.5 v1(30.97,39.14)
  GND1 w0.086: v4(29.6,42.59) 29.6,42.19 v3(29.3,41.89)
  GND5 w0.086: v4(29.6,42.59) 29.19,42.59 29.13,42.66 v5(29.12,42.66)
  BOTTOM w0.086: v5(29.12,42.66) 29.23,42.77 UT11.D7
PD2_GPIO8: length 3.1
  TOP w0.086: v3(29.23,44.43) 28.29,44.43 RT172.1 28.24,45.42 RT378.1
  GND1 w0.086: v4(28.73,44.64) 28.98,44.39 29.21,44.39 29.23,44.41 29.23,44.43 v3(29.23,44.43)
  GND5 w0.086: v4(28.73,44.64) v5(28.73,45.12)
PD2_USB20_N: length 5
  BOTTOM w0.076: UT11.K5 28.49,46.38 28.49,46.72
  BOTTOM w0.088: 28.49,46.72 28.29,46.92 28.27,46.94 28.21,47 28.21,47.48 28.59,47.86 28.59,48.34 28.26,48.66 27.66,48.66 RT406.1 27.35,48.97 27,48.62 26.87,48.62 RT408.1
PD2_USB20_P: length 5
  BOTTOM w0.076: 28.04,46.93 28.04,46.83 27.98,46.77 27.98,46.44 28.04,46.38 28.18,46.38 28.24,46.44 28.24,46.61 UT11.L5
  BOTTOM w0.088: 28.04,46.93 28.04,47.55 28.41,47.93 28.41,48.27 28.19,48.49 27.59,48.49 27.55,48.54 27.4,48.54 27.35,48.48 RT405.1 26.99,48.45 26.87,48.45 RT407.1
PD#: length 11.1
  TOP w0.086: 258.86,38.34 258.88,38.31 259.57,38.31 259.76,38.12 CA31.1 260.09,38.12 260.76,38.79 261.45,38.79 v1(261.66,39.01) 262.04,39.01 262.55,38.5 262.55,37.55 263.79,36.32 UA1.3 ; 258.86,38.34 258.83,38.31 258.68,38.31 258.31,38.68 RA48.2 258.31,39.71 RA18.1 RA50.2 ; 258.86,38.34 DA8.2
PECI_EC: length 207
  TOP w0.117: v2(125.26,81.87) v1(124.42,81.87) ; RE60.2 v3(273.12,54.46)
  GND1 w0.117: v3(273.12,54.46) 272.81,54.77 v4(272.81,55.05)
  IN2 w0.061: v4(257.42,35.39) 257,34.97 257,32.13 252.96,28.09 252.36,28.09 251.53,28.92 233.56,28.92 233.22,28.59 227.34,28.59 224.22,31.71 216.67,31.71 215.69,32.7 209.83,32.7 207.61,30.48 201.32,30.48 200.9,30.91 196.42,30.91 195.72,31.61 181.21,31.61 180.14,32.68 177.76,32.68 176.06,34.38 175.98,34.38 175.97,34.38 175.65,34.38 175.03,35 169.39,35 168.94,35.46 168.94,37 164.56,41.38 164.56,42.88 164.25,43.19 164.15,43.19 162.76,44.59 162.76,45.14 159.19,48.71 159.19,49.12 157.66,50.66 157.66,52.17 149.44,60.39 148.91,60.39 147.97,61.33 147.97,62.49 147.05,63.41 147.05,65.59 147.46,66 147.46,66.72 147.13,67.05 147.13,69.1 146.51,69.72 146.51,70.53 146.88,70.9 146.88,71.46 146.11,72.22 145.25,72.22 143.32,74.15 143.32,75.4 140.95,77.77 140.95,78.99 139.33,80.61 134.89,80.61 134.87,80.62 132.37,80.62 131.76,80.01 126.74,80.01 125.26,81.49 v2(125.26,81.87)
  IN3 w0.061: v4(257.42,35.39) 258.91,36.88 258.91,40.89 259.28,41.26 259.28,44.3 257.98,45.6 257.57,45.6 257.37,45.81 257.37,46.22 257.85,46.69 260.25,46.69 262.01,48.45 263.42,48.45 263.64,48.68 263.64,49.54 266.66,52.55 268.77,52.55 271.27,55.05 v4(272.81,55.05)
  BOTTOM w0.117: UC1.A54 125.35,81.78 v2(125.26,81.87)
PECI_EC_R: length 5.7
  TOP w0.086: RE60.1 273.01,55.51 272,55.51 271.53,55.04 270.78,55.04 269.49,56.34 269.49,56.91 UE1.K13
PGOOD_3V: length 42.7
  TOP w0.086: v2(65.24,76.08) 64.14,76.08 63.45,76.77 PR119.1 PR107.2
  IN2 w0.061: v2(75.85,45.68) 74.67,46.86 74.67,56.13 72.16,58.64 72.16,60.85 70.7,62.32 68.57,62.32 66.08,64.81 66.08,66.3 63.81,68.58 63.81,73.9 64.37,74.46 64.37,75.21 v2(65.24,76.08)
  BOTTOM w0.254: PU100.9 74.53,46.13 74.82,46.41 75.25,46.41 75.85,45.82 v2(75.85,45.68)
PGOOD_5V: length 2.7
  BOTTOM w0.254: PU102.9 52.69,73.14
  BOTTOM w0.305: PR113.2 PR120.1 53.32,73.77 52.69,73.14
PLTRST_TPM#: length 35.5
  IN1 w0.051: v4(174.53,43.01) 174.49,43.05 169.57,43.05 168.41,44.2 166.4,44.2 166.35,44.26 v4(166.35,44.29)
  GND5 w0.086: v5(165.89,44.15) 166.21,44.15 v4(166.35,44.29) ; v4(174.53,43.01) 174.81,43.29 v5(174.96,43.29)
  BOTTOM w0.086: v5(174.96,43.29) v1(175.98,43.29) 176.5,43.29 178.05,41.74 178.05,41.33 177.25,40.54 177.25,39.3 177.75,38.81 179.46,38.81 180.73,37.53 180.73,36.84 180.97,36.6 181.28,36.6 181.56,36.88 183.05,36.88 183.23,36.7 183.23,35.53 185.3,33.46 RC325.2 185.93,33.65 186.72,33.65 187,33.93 187,35.19 186.63,35.56 186.63,36.46 187.8,37.63 RC60.2 ; UZ12.17 166.38,44.24 166.29,44.15 v5(165.89,44.15)
PME#: length 2.4
  TOP w0.086: v2(149.37,61.48) 149.01,61.84 149.01,62.32 T115.1
  BOTTOM w0.086: v2(149.37,61.48) 149.7,61.81 UC1.AU11
POA_WAKE#: length 13.3
  TOP w0.086: UE1.E4 v2(261.42,61.78) ; RZ364.1 v3(253.46,62.95) RE324.1 252.37,62.39 251.34,62.39 v1(250.96,62.77)
  GND1 w0.086: v4(254.25,63.37) 254.25,63.32 253.88,62.95 v3(253.46,62.95)
  IN1 w0.051: v4(254.25,63.37) 254.69,62.92 260.24,62.92 260.29,62.98 260.8,62.98 261.03,62.75 261.03,62.42 261.42,62.03 v2(261.42,61.78)
POA_WAKE#_R: length 107.8
  TOP w0.086: v2(257.57,63.33) 257.27,63.03 256.37,63.03 256.13,63.27 256.13,63.58 v1(256,63.71) 255.74,63.6 RZ364.2
  IN2 w0.061: v2(257.57,63.33) 258.64,63.33 259.83,62.14 260.1,62.14 260.19,62.05 260.19,60.77 260.45,60.51 264.33,60.51 264.73,60.11 266.88,60.11 267.38,59.61 267.38,56.85 267.58,56.65 267.96,56.65 268.19,56.42 268.19,54.71 267.39,53.91 266.91,53.91 265.01,52.01 265.01,51.48 263.15,49.62 262.6,49.62 260.43,47.44 260.43,46.88 259.79,46.24 259.79,43.47 257.2,40.89 257.2,40.79 257.2,40.79 257.2,40.35 255.28,38.42 255.28,34.91 251.24,30.87 237.69,30.87 236.36,32.19 231.67,32.19 230.61,33.25 227.57,33.25 226.31,34.51 222.34,34.51 221.59,35.26 217.78,35.26 216.22,36.82 202.01,36.82 201.52,36.33 201.21,36.33 v4(200.78,36.76)
  GND5 w0.086: v4(200.78,36.76) 200.78,36.28 200.83,36.23 v5(200.83,36.18)
  BOTTOM w0.086: v5(200.83,36.18) 200.83,36.08 200.25,35.5 JUSH1.4
POWER_SW#_MB: length 218
  TOP w0.086: v2(248.63,76.29) 248.63,76.29 247.9,77.02 246.58,77.02 v6(246.42,76.86) 245.53,75.97 RE33.2 CE10.1 ; v3(189.86,45.14) 189.84,45.13 JAPS1.11
  TOP w0.117: SW3.4 v3(262.01,84.79)
  GND1 w0.086: v3(189.86,45.14) 189.86,45.58 v4(190.03,45.75)
  GND1 w0.117: v3(262.01,84.79) v4(262.39,84.41)
  IN2 w0.061: v4(190.03,45.75) 201,45.75 201.67,45.08 212.42,45.08 v4(213.05,44.46) ; v4(261.83,76.78) 261.83,78.61 261.33,79.1 261.33,83.35 v4(262.39,84.41)
  IN4 w0.051: 248.63,76.29 249.04,76.7 250.45,76.7 251.06,76.1 261.15,76.1 v4(261.83,76.78) 265.38,76.78 266.88,75.27 268.39,75.27 269.14,74.52 269.14,70.08 272.56,66.66 273.14,66.66 274.69,65.11 274.69,61.09 273.7,60.1 273.7,58.3 276.19,55.81 276.19,51.26 275.95,51.03 274.66,51.03 270.71,47.07 270.71,46.34 268.72,44.36 268.72,42.32 268.48,42.07 267.55,42.07 264.16,38.67 264.16,29.99 266.63,27.52 283.61,27.52 285.2,25.93 292.56,25.93 v2(292.73,25.76) ; 248.63,76.29 248.59,76.33 246.53,76.33 245.92,75.71 245.92,70.71 245.78,70.57 245.78,67.84 244.44,66.51 244.44,65.58 243.21,64.35 237.54,64.35 236.21,63.03 236.21,61.86 234.41,60.06 234.41,58.36 233.98,57.93 233.98,55.84 232.87,54.73 232.87,51.32 231.28,49.74 230.17,49.74 225.07,44.65 216.22,44.65 215.47,43.9 213.61,43.9 v4(213.05,44.46) ; 248.63,76.29 v2(248.63,76.29)
  BOTTOM w0.086: v2(292.73,25.76) 292.75,25.74 292.75,24.61 293.21,24.15 296.44,24.15 296.7,24.42 JPWR1.2
POWER_SW_IN#: length 26.9
  TOP w0.086: v1(245.53,73.38) RE33.1 RE31.2 247.43,74.38 CE12.1 247.9,74.38 v2(248.12,74.61) ; UE1.D5 v2(262.22,62.58)
  BOTTOM w0.086: v2(248.12,74.61) 247.5,74.61 247.19,74.3 247.19,72.7 250.34,69.55 251.2,69.55 252.51,68.24 255.43,68.24 258.01,65.66 260.09,65.66 261.14,64.6 261.51,64.6 261.82,64.3 261.82,63.18 262.22,62.78 v2(262.22,62.58)
PROCHOT#: length 399.4
  TOP w0.086: v2(275.68,59.37) 275.58,59.27 273.36,59.27 v1(273.13,59.04) 272.95,58.86 RE288.2 ; v3(65.76,75.54) 66.11,75.89 66.11,76.95 66.35,77.19 PC605.2 66.36,77.85 PR678.1
  GND1 w0.086: v4(66.42,74.8) 65.78,75.44 65.78,75.52 v3(65.76,75.54) ; v4(57.9,32.39) 57.9,32.29
  GND1 w0.117: 57.9,32.29 v3(57.9,31.89)
  IN1 w0.051: v4(66.42,74.8) 66.49,74.72 66.49,73.77 65.6,72.88 65.6,70.37 66.46,69.51 66.46,64.18 77.03,53.61 77.03,48.19 77.32,47.9 77.32,46 77.03,45.7 76.5,45.7 75.81,45.02 73.98,45.02 73.19,44.23 70.12,44.23 69.84,43.95 68.7,43.95 68.7,43.96 68.48,44.18 67.63,44.18 64.56,41.11 60.88,41.11 57.45,37.68 57.45,35.39 55.8,33.74 55.8,32.22 56,32.01 57.53,32.01 v4(57.9,32.39)
  IN2 w0.061: v4(66.42,74.8) 66.29,74.8 66.24,74.75 66.24,74.29 65.37,73.43 64.71,73.43 64.18,72.9 64.18,68.74 66.51,66.4 66.51,64.91 68.72,62.7 70.85,62.7 72.53,61.01 72.53,58.79 77,54.33 77,48.18 78.04,47.14 78.2,47.14 78.2,47.14 81.74,47.14 85.25,43.63 89.41,43.63 91.5,41.53 91.5,41.08 94.7,37.88 94.7,33.29 96.83,31.16 105.1,31.16 106.23,30.04 126.15,30.04 126.58,30.46 140.98,30.46 141.28,30.76 159.39,30.76 160.49,29.66 162.68,29.66 163.19,30.17 168.99,30.17 169.71,30.89 173.04,30.89 174.09,29.84 179.26,29.84 180.32,28.78 186.84,28.78 187.87,27.74 199.13,27.74 200.6,26.27 227.21,26.27 227.99,27.06 231.15,27.06 231.6,26.6 241.6,26.6 242.61,27.62 251.17,27.62 252.12,26.66 253.63,26.66 255.46,28.49 256.57,28.49 259.78,31.71 259.78,35.52 259.51,35.79 259.51,39 261.19,40.68 262.06,40.68 262.91,41.54 262.91,42.71 263.36,43.16 264.59,43.16 265.95,44.52 265.95,45.13 267.95,47.13 269.09,47.13 270.74,48.78 271.9,48.78 274.59,51.46 275.03,51.46 275.47,51.91 275.47,53.61 275.68,53.82 v2(275.68,59.37)
  IN4 w0.051: v4(106.21,85.05) 105.68,85.58 94.71,85.58 93.03,83.9 75.23,83.9 75.1,84.03 68.85,84.03 67.33,82.51 67.33,82.11 66.16,80.94 66.16,76.46 66.92,75.7 66.92,75.17 66.55,74.8 v4(66.42,74.8)
  GND5 w0.086: v5(105.55,85.91) 105.55,85.71 v4(106.21,85.05)
  BOTTOM w0.086: CC310.1 105.3,86.21 105.3,86.16 RC83.1 ; RC83.1 105.55,85.94 RC84.1 ; RC83.1 v5(105.55,85.91)
PROCHOT#_ISL9538: length 88
  TOP w0.117: PU901.23 56.54,33.76 56.94,33.36 57.35,33.36 PR926.2 57.9,33.36 v3(57.9,33.36)
  GND1 w0.117: v4(57.93,34.58) 57.9,34.55 v3(57.9,33.36)
  IN3 w0.061: v2(62.76,80.81) 61.64,79.69 52.41,79.69 48.65,75.93 46.86,75.93 45.18,74.25 45.18,61.84 44.56,61.21 44.56,48.66 44.63,48.59 44.63,44.99 45.49,44.13 47.35,44.13 47.67,43.81 47.67,42.05 47.24,41.61 47.24,36.99 46.91,36.66 46.91,35.39 46.91,35.24 47.14,35 48.22,35 v4(48.42,35.2)
  IN4 w0.069: v4(48.42,35.2) 48.46,35.16 50.82,35.16 51.14,34.84 57.03,34.84 57.29,34.58 v4(57.93,34.58)
  BOTTOM w0.086: PQ1228.1 60.42,88.28 60.01,87.88 60.01,86.94 59.75,86.68 59.75,85.25 v1(60.14,84.86) 61.86,83.14 62.11,83.14 62.91,82.34 62.91,80.96 v2(62.76,80.81)
PROCHOT#_R: length 16.5
  BOTTOM w0.076: 116.27,82.69 116.58,82.38 118.79,82.38 119.19,81.98 119.19,81.67 119,81.48 119,81.22 119.06,81.1 119.06,80.95 119,80.76 119,80.59 119.09,80.33 UC1.C65
  BOTTOM w0.086: 116.27,82.69 111.36,82.69 109.39,84.66 v1(108.82,84.66) 107.7,84.66 RC84.2
PROCHOT#_R1: length 2.4
  TOP w0.086: RE288.1 v1(270.36,58.86) 270,58.86 269.91,58.95 269.05,58.95 UE1.H13
PWM1_IA: length 19.9
  IN1 w0.203: v2(85.72,70.67) 85.02,71.37 79.94,71.37 77.73,73.58 75.44,73.58 74.9,74.13 74.9,78.23 v2(75.71,79.05)
  BOTTOM w0.203: v2(75.71,79.05) 75.71,78.42 75.22,77.93 PU602.12 ; PR687.1 v2(85.72,70.67)
PWM2_IA: length 35.2
  TOP w0.086: v3(86.23,61.97) v1(85.34,61.97)
  GND1 w0.203: v3(86.23,61.97) v4(85.73,61.97)
  IN1 w0.203: v4(75.96,77.28) 75.51,76.82 75.51,74.38 75.7,74.19 77.98,74.19 80.03,72.14 86,72.14 86.62,71.52 86.62,69.74 86.28,69.4 83.15,69.4 81.95,68.2 81.95,64.49 82.96,63.47 85.87,63.47 86.2,63.14 86.2,62.44 v4(85.73,61.97)
  GND5 w0.203: v4(75.96,77.28) 75.58,77.66 v5(75.51,77.66)
  BOTTOM w0.203: PU602.13 75.33,77.53 75.46,77.66 v5(75.51,77.66)
PWM_FAN1: length 160.2
  TOP w0.086: v2(168.14,70.65) 167.43,71.36 RE48.2 164.88,71.36 v1(164.4,70.88) ; UE1.L10 v2(266.96,56.24)
  IN2 w0.061: v4(216.91,43.77) 216.3,43.77 215.75,43.23 212.12,43.23 211.27,44.08 201.26,44.08 200.58,44.75 190.86,44.75 190.4,44.29 187.82,44.29 185.14,46.97 182.74,46.97 182.49,47.22 181.77,47.22 180.16,48.83 180.16,50.18 173.95,56.39 173.95,64.76 168.14,70.57 v2(168.14,70.65)
  IN4 w0.051: v4(246.7,75.93) 246.07,75.29 246.07,70.64 245.93,70.51 245.93,67.78 244.59,66.44 244.59,65.52 243.27,64.2 237.6,64.2 236.36,62.96 236.36,61.79 234.57,60 234.57,57.59 234.76,57.39 234.76,56.41 233.02,54.67 233.02,51.21 231.4,49.59 230.23,49.59 225.14,44.5 217.3,44.5 216.91,44.1 v4(216.91,43.77)
  GND5 w0.086: v5(247.13,75.55) 246.75,75.93 v4(246.7,75.93)
  BOTTOM w0.086: v2(168.14,70.65) 168.12,70.63 JFAN1.2 ; v5(247.13,75.55) 247.13,74.74 246.93,74.53 246.93,72.61 250.24,69.3 251.1,69.3 252.38,68.02 255.35,68.02 257.95,65.41 259.99,65.41 261,64.4 261,63.15 261.17,62.99 261.59,62.99 261.83,62.75 261.83,62.33 261.99,62.16 264.09,62.16 264.62,61.63 264.62,60.63 265.27,59.98 265.5,59.98 265.78,59.7 265.78,56.09 266.04,55.83 266.55,55.83 v2(266.96,56.24)
PWM_GT: length 4
  BOTTOM w0.203: PR664.1 76.18,71.77 75.39,72.56 74.71,72.56 73.69,73.58 PU602.22
PWM_SA: length 4.3
  TOP w0.086: v1(89.49,47.95) 89.31,48.13 89.31,48.89 PR606.2
  TOP w0.254: PR606.2 90.07,48.91 v2(90.48,49.32)
  BOTTOM w0.254: v2(90.48,49.32) 90.48,49.58 90.11,49.95 PU614.3
PWM_VSA: length 41.2
  TOP w0.086: v3(88.37,48.91) 88.17,48.91 v1(87.32,49.77)
  GND1 w0.254: v3(88.37,48.91) v4(88.37,48.43)
  IN1 w0.203: v4(88.37,48.43) 88.23,48.57 85.17,48.57 84.97,48.78 84.97,49.31 83.67,50.61 78.71,50.61 77.73,51.58 77.73,53.8 73.2,58.33 73.2,66.89 69.11,70.98 v2(69.11,73.44)
  BOTTOM w0.203: v2(69.11,73.44) 69.16,73.44 69.77,74.05 PU602.30
REM_DIODE1_N: length 194.9
  TOP w0.127: QE3.3 123.44,65.74 v3(124.25,65.74) ; UE1.A8 264.69,64.91 264.69,65.28 264.04,65.92 263.34,65.92 263.01,66.26 263.01,66.53 v3(263.34,66.86)
  GND1 w0.127: v4(263.14,66.35) 263.34,66.56 v3(263.34,66.86) ; v3(124.25,65.74) v4(124.93,65.74)
  IN1 w0.127: v4(233.52,57.24) 233.77,57.49 233.77,59.95 234.86,61.03 242.93,61.03 246.68,64.78 246.68,66.15 247.34,66.81 248.26,66.81 250.11,68.65 250.11,68.99 250.64,69.52 252.3,69.52 253.8,71.01 259.34,71.01 260.12,71.79 264.31,71.79 266.08,70.02 266.08,67.5 265.14,66.56 263.34,66.56 v4(263.14,66.35) ; v4(124.93,65.74) 125.19,65.49 131.36,65.49 133.15,67.28 133.15,67.4 133.76,68 146.66,68 147.24,67.42 147.24,67 147.99,66.25 148.68,66.25 148.98,65.95 153.84,65.95 155.96,63.83 155.96,59.03 158.9,56.1 158.9,54.25 163.24,49.9 163.95,49.9 164.72,49.13 164.72,47.27 166.9,45.09 169.19,45.09 170.34,43.95 176.11,43.95 179.09,40.98 181.54,40.98 182.31,40.2 183.42,40.2 184.74,38.88 186.7,38.88 187.75,37.84 193.69,37.84 194.25,38.4 195.87,38.4 196.8,37.47 205.86,37.47 206.42,38.03 218.58,38.03 221.2,40.65 223.97,40.65 224.35,41.03 224.35,41.55 v4(224.19,41.72)
  IN2 w0.127: v4(224.19,41.72) 224.38,41.91 224.38,42.22 225.06,42.91 225.26,42.91 232.2,49.84 232.2,53.55 234.05,55.41 234.05,56.32 233.82,56.55 233.82,56.93 v4(233.52,57.24)
REM_DIODE1_P: length 197
  TOP w0.127: v3(262.42,66.86) 262.76,66.53 262.76,66.15 263.24,65.67 263.94,65.67 264.43,65.17 264.43,64.85 UE1.A7 ; v3(124.25,64.83) 124.13,64.71 QE3.2 122.77,64.71 122.12,65.36 QE3.1
  GND1 w0.127: v3(262.42,66.86) 262.43,66.86 v4(262.43,66.38) ; v3(124.25,64.83) v4(124.88,64.83)
  IN1 w0.127: v4(234.36,57.21) 234.03,57.54 234.03,59.84 234.97,60.78 243.03,60.78 246.93,64.68 246.93,66.04 247.45,66.56 248.37,66.56 250.36,68.55 250.36,68.88 250.74,69.26 252.4,69.26 253.9,70.76 259.45,70.76 260.22,71.54 264.2,71.54 265.83,69.91 265.83,67.6 265.04,66.81 262.86,66.81 v4(262.43,66.38) ; v4(224.77,41.72) 224.6,41.55 224.6,40.93 224.07,40.39 221.31,40.39 218.69,37.78 206.52,37.78 205.96,37.22 196.69,37.22 195.77,38.15 194.36,38.15 193.79,37.58 187.64,37.58 186.6,38.62 184.64,38.62 183.31,39.95 182.21,39.95 181.44,40.72 178.98,40.72 176.01,43.7 170.23,43.7 169.09,44.84 166.79,44.84 164.46,47.17 164.46,49.03 163.85,49.65 163.13,49.65 158.64,54.14 158.64,55.99 155.7,58.93 155.7,63.73 153.74,65.69 148.88,65.69 148.57,66 147.89,66 146.99,66.9 146.99,67.32 146.55,67.75 133.86,67.75 133.4,67.29 133.4,67.17 131.46,65.24 125.24,65.24 124.88,64.88 v4(124.88,64.83)
  IN2 w0.127: v4(224.77,41.72) 224.63,41.86 224.63,42.12 225.17,42.66 225.37,42.66 232.45,49.74 232.45,53.45 234.31,55.3 234.31,56.42 234.08,56.65 234.08,56.93 v4(234.36,57.21)
REM_DIODE2_N: length 342.5
  TOP w0.127: v3(265.17,66.89) 264.84,66.56 264.84,66.25 265.27,65.82 265.65,65.82 266.31,65.16 266.31,64.89 UE1.A10
  GND1 w0.127: v3(265.17,66.89) 265.02,67.04 v4(265.02,67.52)
  IN1 w0.127: v4(265.02,67.52) 264.76,67.78 264.76,69.43 263.75,70.44 261.45,70.44 260.13,69.12 258.76,69.12 258.11,68.47 252.98,68.47 251.55,67.04 249.75,67.04 247.57,64.86 247.57,63.74 246.83,63.01 246.83,62.44 v2(246.63,62.24)
  IN3 w0.127: v4(40.15,44.73) 40.4,44.73 40.58,44.56 40.97,44.56 41.24,44.83 41.24,46.5 41.81,47.07 41.81,51.28 40.76,52.33 40.76,52.84 40.51,53.1 40.51,61.54 42.5,63.53 42.5,64.73 42.64,64.87 42.83,64.87 v2(42.94,64.75)
  IN4 w0.127: v4(40.15,44.73) 40.38,44.73 40.95,44.17 53.96,44.17 54.7,43.42 59.82,43.42 60.07,43.17 62.02,43.17 65.5,46.64 70.44,46.64 71.54,47.74 74.01,47.74 74.62,47.13 83.33,47.13 84.39,46.06 87.57,46.06 91.58,42.05 91.58,38.52 91.44,38.38 91.44,35.55 92.55,34.45 95.68,34.45 96.34,33.79 125.51,33.79 125.89,33.41 155.92,33.41 160.05,37.54 160.05,40.37 160.75,41.08 161.39,41.08 v4(161.52,40.94) ; v4(252.57,52.08) 252.72,51.93 253.2,51.93 255.8,49.34 255.9,49.23 255.9,46.59 255.75,46.44 255.75,31.26 253.64,29.16 252.8,29.16 252.29,28.64 235.39,28.64 234.86,29.17 230.24,29.17 229.44,28.37 224.53,28.37 224.45,28.44 218.52,28.44 217.23,29.73 214.12,29.73 211.91,27.52 206.93,27.52 205.98,28.47 205.34,28.47 204.66,29.14 200.29,29.14 199.86,28.71 194.68,28.71 194.26,29.13 180.58,29.13 179.35,30.36 178.17,30.36 177.23,31.3 173.33,31.3 170.11,34.53 169.36,34.53 167.15,36.73 167.15,37.7 166.72,38.13 165.32,38.13 164.81,38.64 164.48,38.64 v4(164.23,38.9)
  GND5 w0.127: v5(162.07,41.16) 161.74,41.16 v4(161.52,40.94) ; v4(252.57,52.08) 252.75,52.26 v5(252.75,52.56) ; v5(163.75,38.77) 164.1,38.77 v4(164.23,38.9)
  BOTTOM w0.127: v2(246.63,62.24) 246.78,62.09 246.78,60.74 248.4,59.11 251.45,59.11 252.5,58.06 252.5,55.55 253.1,54.94 253.1,52.49 253.05,52.44 252.87,52.44 v5(252.75,52.56) ; CE37.2 43.6,68.72 43.6,68.36 QE5.3 43.86,67.57 43.86,66.42 44.11,66.17 44.11,65.98 44.31,65.78 44.31,65.39 43.83,64.91 43.1,64.91 v2(42.94,64.75) ; v5(163.75,38.77) 163.8,38.72 163.8,38.36 163.63,38.2 QE7.1 162.77,38.83 162.97,39.04 162.97,39.32 162.71,39.58 162.54,39.58 162.12,40.01 QE7.2 162.45,40.1 162.93,40.58 162.93,40.83 CE46.2 162.09,41.18 v5(162.07,41.16)
REM_DIODE2_P: length 338.4
  TOP w0.127: UE1.A9 266.06,64.88 266.06,65.06 265.55,65.57 265.16,65.57 264.58,66.15 264.58,66.56 v3(264.25,66.89)
  GND1 w0.127: v4(264.3,67.5) 264.3,66.94 v3(264.25,66.89)
  IN1 w0.127: v4(264.3,67.5) 264.51,67.7 264.51,69.33 263.65,70.19 261.56,70.19 260.24,68.87 258.87,68.87 258.22,68.22 253.09,68.22 251.66,66.79 249.86,66.79 247.82,64.75 247.82,63.64 247.08,62.9 247.08,62.37 v2(247.21,62.24)
  IN3 w0.127: v4(40.56,45.15) 40.56,44.93 40.68,44.81 40.86,44.81 40.99,44.94 40.99,46.61 41.56,47.18 41.56,51.17 40.51,52.22 40.51,52.74 40.25,52.99 40.25,61.65 42.25,63.64 42.25,64.84 42.53,65.12 42.72,65.12 v2(42.94,65.35)
  IN4 w0.127: v4(252.57,51.49) 252.75,51.67 253.1,51.67 255.64,49.13 255.64,46.69 255.49,46.55 255.49,31.37 253.54,29.41 252.7,29.41 252.18,28.89 235.49,28.89 234.97,29.42 230.14,29.42 229.34,28.62 224.63,28.62 224.56,28.7 218.62,28.7 217.34,29.98 214.01,29.98 211.8,27.77 207.03,27.77 206.08,28.72 205.44,28.72 204.77,29.4 200.19,29.4 199.75,28.96 194.78,28.96 194.36,29.38 180.69,29.38 179.46,30.61 178.28,30.61 177.34,31.56 173.44,31.56 170.21,34.78 169.46,34.78 167.4,36.84 167.4,37.81 166.82,38.39 165.42,38.39 164.79,39.02 v4(164.79,39.07) ; v4(40.56,45.15) 40.56,44.91 41.05,44.42 54.06,44.42 54.81,43.67 59.92,43.67 60.17,43.42 61.92,43.42 65.39,46.9 70.34,46.9 71.43,47.99 74.12,47.99 74.73,47.38 83.43,47.38 84.5,46.31 87.68,46.31 91.84,42.15 91.84,38.41 91.7,38.27 91.7,35.66 92.65,34.71 95.78,34.71 96.44,34.04 125.62,34.04 126,33.66 155.81,33.66 159.79,37.64 159.79,40.47 160.65,41.33 161.3,41.33 v4(161.51,41.54)
  GND5 w0.127: v4(252.57,51.49) 252.75,51.49 v5(253.07,51.81) ; v5(164.23,39.38) 164.48,39.38 v4(164.79,39.07) ; v5(162.07,41.61) 161.64,41.61 161.56,41.54 v4(161.51,41.54)
  BOTTOM w0.127: v5(253.07,51.81) 253.07,52.09 253.36,52.38 253.36,55.05 252.75,55.65 252.75,58.17 251.55,59.37 248.51,59.37 247.03,60.84 247.03,62.06 v2(247.21,62.24) ; CE37.1 43.35,68.72 43.35,68.36 QE5.2 43.6,67.06 43.6,66.06 QE5.1 43.62,65.8 43.93,65.8 44.06,65.67 44.06,65.49 43.73,65.16 43.13,65.16 v2(42.94,65.35) ; v5(162.07,41.61) 162.12,41.66 163.01,41.66 CE46.1 163.19,40.87 163.19,40.62 163.42,40.39 QE7.3 163.42,39.75 163.79,39.38 v5(164.23,39.38)
REM_DIODE4_N: length 243.9
  TOP w0.127: UE1.A11 267.3,64.7 267.3,64.96 266.65,65.61 266.65,66.8 265.76,67.7 265.3,67.7 CE27.1 264.41,68.59 v2(263.29,68.59)
  IN1 w0.127: v2(83.06,49.94) 83.25,49.75 83.57,49.75 84.04,49.28 84.04,47.25 85.11,46.19 87.44,46.19 87.8,46.54 89.56,46.54 90.09,46.01 90.09,38.98 90.67,38.39 90.67,36.59 92.16,35.1 96.1,35.1 96.95,34.25 108.51,34.25 110.24,32.52 124.62,32.52 126.07,33.97 157.98,33.97 159.45,35.44 168.85,35.44 172,32.29 181.09,32.29 183.3,30.08 196.05,30.08 196.79,30.82 207.43,30.82 208.19,30.06 209.29,30.06 210.11,30.88 219.71,30.88 220.2,31.38 235.55,31.38 236.09,30.84 248.42,30.84 251.43,33.85 251.53,33.85 253.57,35.89 253.57,39.72 253.12,40.18 253.12,43.85 253.18,43.92 253.18,54.99 253.78,55.58 253.78,55.95 253.63,56.1 253.44,56.1 v4(253.29,55.95)
  IN4 w0.127: v4(253.29,55.95) 253.12,56.12 252.53,56.12 252.27,56.38 252.27,58.2 251.93,58.54 251.93,60.32 254.93,63.32 254.93,64.12 255.8,64.98 257.52,64.98 258.38,65.85 260.25,65.85 261.46,67.06 261.46,67.88 261.97,68.39 263.09,68.39 v2(263.29,68.59)
  BOTTOM w0.127: QE6.3 81.97,50.78 82.19,51 82.66,51 CE39.1 83.38,50.91 83.47,50.91 83.63,50.74 83.63,49.9 83.51,49.78 83.19,49.78 83.06,49.9 v2(83.06,49.94)
REM_DIODE4_P: length 247.4
  TOP w0.127: v2(263.26,68) 263.29,68.03 CE27.2 264.63,67.45 265.65,67.45 266.4,66.7 v7(266.4,66.07) 266.4,65.5 267.05,64.85 267.05,64.27 UE1.B10
  IN1 w0.127: v2(83.06,49.36) 83.21,49.5 83.47,49.5 83.79,49.18 83.79,47.15 85,45.93 87.55,45.93 87.91,46.29 89.45,46.29 89.83,45.91 89.83,38.87 90.42,38.29 90.42,36.49 92.06,34.84 96,34.84 96.85,33.99 108.4,33.99 110.13,32.27 124.73,32.27 126.18,33.71 158.08,33.71 159.56,35.19 168.75,35.19 171.9,32.04 180.99,32.04 183.2,29.83 196.16,29.83 196.89,30.57 207.33,30.57 208.09,29.8 209.39,29.8 210.22,30.63 219.81,30.63 220.31,31.13 235.44,31.13 235.98,30.59 248.53,30.59 251.54,33.6 251.64,33.6 253.83,35.79 253.83,39.82 253.37,40.28 253.37,43.75 253.44,43.82 253.44,54.89 254.03,55.48 254.03,56.06 253.74,56.35 253.51,56.35 v4(253.31,56.56)
  IN4 w0.127: v4(253.31,56.56) 253.12,56.37 252.64,56.37 252.53,56.48 252.53,58.3 252.19,58.64 252.19,60.22 255.19,63.21 255.19,64.01 255.9,64.73 257.62,64.73 258.49,65.59 260.35,65.59 261.71,66.95 261.71,67.78 262.07,68.14 263.13,68.14 v2(263.26,68)
  BOTTOM w0.127: v2(83.06,49.36) 83.06,49.39 83.19,49.52 83.61,49.52 83.89,49.8 83.89,50.85 83.57,51.16 83.41,51.16 CE39.2 82.8,51.25 82.34,51.25 81.97,51.63 QE6.2 80.72,51.9 QE6.1
RESET_IN#: length 5.1
  TOP w0.086: UE1.C1 259.39,63.05 258.39,64.04 256.69,64.04 256.01,64.73 RE362.1
RESET_OUT: length 7.1
  TOP w0.086: UE1.G4 v2(261.42,59.44) ; v2(257.88,62.39) 257.7,62.57 RE548.2
  IN2 w0.061: v2(261.42,59.44) 261.19,59.44 260.8,59.83 260.16,59.83 257.88,62.11 v2(257.88,62.39)
  BOTTOM w0.086: v1(258.15,63.06) 257.88,62.8 v2(257.88,62.39)
RESET_OUT#_R: length 4.1
  TOP w0.086: JXDP1.47 62.67,92.66 62.5,92.82 v2(62.37,92.82)
  BOTTOM w0.086: v2(62.37,92.82) 62.2,92.64 CC33.1 RC129.2 RC128.2
RING2: length 0.9
  TOP w0.508: RA5.1 273.62,31.68 v2(274.24,31.68)
  vias: v1(278.11,38.5) v2(271.04,34.32) v2(271.53,33.97) v2(278.17,39.07) v2(278.81,38.69)
RING2_R:
  vias: v1(284.8,39.52) v2(284.27,40.09) v2(284.9,40.09)
RTCRST_ON: length 34.8
  TOP w0.086: v3(261.46,66.72) 261.52,66.72 261.87,67.06 261.87,67.71 260,69.58 v2(259.5,69.58) ; v2(260.34,74.56) v1(260.34,75.23) QE12.2 261.67,76.9 262.42,77.66 262.42,78.8 263.11,79.49 264.43,79.49 264.7,79.75 RE565.2 ; UE1.F11 v2(267.77,60.99)
  GND1 w0.117: v3(261.46,66.72) 261.46,66.67 261.76,66.37 v4(261.76,66.34)
  IN3 w0.061: v2(259.5,69.58) 260.03,70.11 260.03,74.25 v2(260.34,74.56) ; v4(261.76,66.34) 261.76,66.4 262.16,66.8 266.14,66.8 268.21,64.73 270.3,64.73 270.99,64.04 270.99,63.22 269.22,61.45 268.23,61.45 v2(267.77,60.99)
RTCRST_ON_R: length 3.4
  TOP w0.086: RE543.1 263.81,80.59 DE2.2 262.62,80.27 CE65.1 261.67,80.15 QE17.2
RTD3 SELECT: length 314.3
  GND1 w0.086: v4(271.95,59.34) 272.2,59.6 v3(272.2,59.9)
  IN1 w0.051: v4(262.77,39.44) 262.77,43.91 263.99,45.13 263.99,45.6 264.47,46.08 265.43,46.08 265.78,46.43 265.78,47.44 267.1,48.76 267.27,48.76 267.99,49.47 267.99,51.35 268.48,51.84 269.83,51.84 272.34,54.34 272.34,58.49 271.95,58.88 v4(271.95,59.34)
  IN2 w0.061: v4(27.49,25.84) 27.49,26.31 28.93,27.75 28.93,28.44 30.01,29.51 104.89,29.51 106.52,27.89 125.86,27.89 126.94,28.96 144.84,28.96 145.32,29.44 154.82,29.44 157,27.26 158.16,27.26 160.03,25.39 176.87,25.39 177.61,26.13 191.13,26.13 191.61,26.61 198.66,26.61 200.13,25.14 241.73,25.14 243.03,26.44 250.75,26.44 251.88,25.3 260.01,25.3 260.35,25.65 260.35,27.92 261.61,29.18 261.61,34.84 261.09,35.37 261.09,36.37 261.6,36.88 261.6,38.58 262.46,39.44 v4(262.77,39.44)
  IN3 w0.061: v4(13.12,14.37) 14.52,14.37 22.43,22.28 22.43,23.36 23.37,24.3 25.95,24.3 v4(27.49,25.84)
  GND5 w0.086: v5(27.2,26.36) 27.49,26.07 v4(27.49,25.84) ; v4(13.12,14.37) 13.5,14.37 v5(13.63,14.5)
  BOTTOM w0.086: v5(13.63,14.5) 13.15,14.5 12.48,13.83 v1(11.98,13.83) 10.92,12.78 7.43,12.78 RT449.1 6.67,11.55 6.01,10.9 UT32.6 ; UT33.6 26.91,25.69 27.2,25.98 v5(27.2,26.36)
RTD3_CIO_PWR_EN: length 169
  TOP w0.086: RC559.1 39.25,70.7 v3(38.8,71.14)
  GND1 w0.086: v3(38.8,71.14) 39.21,71.14 v4(39.36,71.29) ; v4(29.89,66.59) 29.67,66.59 v3(29.46,66.38)
  IN3 w0.061: v4(29.89,66.59) 29.89,67.09 32.22,69.43 35.24,69.43 35.8,68.86 35.8,68.45 36.32,67.94 39.35,67.94 40,68.59 40,70.66 v4(39.36,71.29) 40,71.93 40,73.46 39.71,73.75 39.71,76.19 39.91,76.39 39.91,77.19 41.85,79.12 42.15,79.12 44.98,81.95 59.68,81.95 61.86,84.13 65.89,84.13 66.22,84.46 67.25,85.5 76.84,85.5 78.55,83.78 104.06,83.78 104.39,84.11 105.78,85.51 124.42,85.51 124.59,85.34 128.45,85.34 130.03,83.76 130.5,83.76 139.16,83.76 139.45,83.48 142.14,83.48 142.66,84 145.8,84 146.48,83.31 149.44,83.31 150.28,82.47 153.84,82.47 154.36,81.95 154.36,79.53 153.63,78.8 153.63,74.83 153.33,74.53 150.57,74.53 150.22,74.18 150.22,73.27 150.3,73.19 150.3,71.58 149.85,71.13 149.17,71.13 148.86,70.82 148.86,69.45 149.01,69.3 154.42,69.3 155.06,68.67 v4(155.11,68.67)
  GND5 w0.086: v4(155.11,68.67) 155.16,68.72 v5(155.16,69.19)
  BOTTOM w0.076: UC1.AC2 v5(155.16,69.19)
RTD3_CIO_PWR_EN_R: length 6.1
  GND1 w0.086: v3(30.33,66.4) 30.37,66.4 v4(30.71,66.06)
  GND5 w0.086: v4(30.71,66.06) 30.78,66 v5(31.27,66)
  BOTTOM w0.076: UT1.F1 30.27,63.87 30.23,63.91 30.23,64.49 31.27,65.53 v5(31.27,66)
  BOTTOM w0.086: v5(31.27,66) 31.27,66.2 31.6,66.53 31.61,66.53 31.73,66.65 31.73,67.01 32.43,67.71 RT372.1
RTD3_USB_PWR_EN: length 1.5
  TOP w0.086: v2(29.46,62.18) 29.76,62.48 RT26.1
  BOTTOM w0.127: v2(29.46,62.18) 29.44,62.19 29.44,62.19 29.43,62.18 29.43,62.17 29.13,62.47 UT1.D4
RUN_ON: length 383.3
  TOP w0.086: v3(168.04,26.2) 168.04,26.28 168.8,27.04 168.8,34.04 v3(168.83,34.07) 168.83,34.3 170.48,35.95 171.7,35.95 171.85,36.1 171.85,38.11 172.37,38.62 172.37,39.9 172.2,40.06 172.2,40.34 174.26,42.4 174.69,42.4 175,42.71 176.32,42.71 176.32,42.7 178.4,42.7 179.25,43.55 179.25,44.08 179.06,44.27 179.06,47.48 179.72,48.14 183.23,48.14 185.54,50.45 188.84,50.45 v2(189.25,50.05) ; QE2.2 250.6,69.92 249.55,70.97 249.55,71.87 248.95,72.47 248.53,72.47 247.96,73.04 244.55,73.04 v2(244.49,73.1) 243.97,73.62 243.97,75.49 246.03,77.54 251.27,77.54 251.42,77.4 251.42,75.74 252.37,74.79 253.66,74.79 254.11,75.24 254.63,75.24 255,74.86 256.25,74.86 RE280.2 257.22,74.38 RE292.1 257.24,72.88 256.98,72.88 256.87,73 UE5.4 ; UZ4.3 203.08,38.4 203.19,38.29 203.19,37.3 204.06,36.43 205.15,36.43 206.04,37.32 208.64,37.32 209.03,37.72 v6(209.89,37.72) 210.49,37.72 215.28,42.5 217.03,42.5 RZ345.1 218.27,44.4 217.14,45.53 217.14,46.59 v2(217.11,46.62) ; v3(24.94,29.55) 24.94,29.85 23.82,30.97 23.82,31.28 23.24,31.85 UZ3.5
  GND1 w0.086: v3(168.8,26.02) 168.74,26.02 168.56,26.2 v3(168.04,26.2) ; v3(168.83,34.07) 168.8,34.1 168.8,34.15 168.65,34.3 168.52,34.3 v4(168.39,34.43) ; v4(25.85,29.64) 25.76,29.55 v3(24.94,29.55)
  IN1 w0.051: v4(168.39,34.43) 168.23,34.59 159.8,34.59 158.32,33.11 126.89,33.11 125.52,31.73 125.52,30.99 125.37,30.84 110.59,30.84 v4(110.58,30.84)
  IN2 w0.061: v2(244.49,73.1) 244.49,72.98 242.52,71.01 242.52,69.43 240.98,67.88 237.6,67.88 236.66,66.94 233.35,66.94 231.28,64.88 231.28,64.19 229.48,62.39 229.01,62.39 228.42,61.8 228.42,61.49 226.52,59.59 226.52,53.26 222.91,49.65 222.25,49.65 218.94,46.34 217.39,46.34 v2(217.11,46.62) 217.11,47.05 216.22,47.94 213.79,47.94 212.95,47.94 212.01,47 209.4,47 208.68,46.28 202.22,46.28 201.24,47.26 201.19,47.26 201.19,47.26 200.35,47.26 200.35,47.26 192.04,47.26 v2(189.25,50.05) 188.84,50.46 188.06,50.46 187.31,51.2 185.53,51.2 180.5,56.23 180.5,58.33 180.5,58.68 180.5,58.68 180.5,59.37 179.01,60.86 179.01,64.76 178.35,65.41 178.35,67.28 177.57,68.06 177.57,80.18 176.73,81.03 v4(176.73,82.38)
  IN3 w0.061: v4(110.58,30.84) 109.93,31.49 95.11,31.49 94.07,32.54 91.81,32.54 88.92,35.43 88.92,37.83 87.65,39.1 87.65,41.21 85.36,43.49 74.01,43.49 73.5,44 70.87,44 68.16,41.29 68.16,36.9 67.38,36.11 66.41,36.11 62.95,32.65 60.16,32.65 59.79,33.03 54.68,33.03 54.15,32.5 52.86,32.5 52.54,32.82 37.36,32.82 34.58,30.03 26.24,30.03 v4(25.85,29.64)
  GND5 w0.086: v5(176.47,82.99) 176.47,82.94 176.73,82.69 v4(176.73,82.38)
  BOTTOM w0.086: v5(176.47,82.99) 176.37,83.09 175.32,83.09 173.84,84.57 UZ35.2 172.59,84.57 171.86,83.84 RZ320.1
RUN_ON#: length 7.2
  TOP w0.086: RE68.1 252.34,73.69 252.34,72.96 251.45,72.07 250.77,72.07 250.6,71.9 QE2.5 250.6,71.24 250.44,71.08 250.12,71.08 249.95,71.25 QE2.6 249.95,72.4 250.09,72.54 QZ4.2
RUN_ON_1.8V: length 2.9
  TOP w0.086: UZ8.3 v1(220.07,42.73) 219.24,42.73 CZ197.1 RZ345.2
RUN_ON_EC: length 48.9
  TOP w0.086: RPE10.4 256.09,42.46 256.33,42.71 256.92,42.71 257.27,43.06 258.37,43.06 258.73,43.42 262.63,43.42 262.69,43.48 263.33,43.48 263.5,43.65 264.03,43.65 v1(264.16,43.78) 264.38,44 v3(264.38,44.13) ; UE1.E8 v2(265.36,61.78) ; UE5.2 256.22,72.26 256.59,72.64 257.51,72.64 257.57,72.7 v3(257.98,72.7)
  GND1 w0.117: v4(258.23,72.14) 257.98,72.4 v3(257.98,72.7) ; v3(264.38,44.13) v4(264.79,44.54)
  IN4 w0.051: v4(264.79,44.54) 264.84,44.54 265.8,45.5 265.8,53.25 264.94,54.11 264.94,61.65 265.07,61.78 v2(265.36,61.78)
  GND5 w0.127: v4(258.23,72.14) 258.44,71.94 v5(258.44,71.69)
  BOTTOM w0.086: v2(265.36,61.78) 265.77,62.19 266.35,62.19 266.54,62.38 266.54,64.17 263.54,67.17 261.98,67.17 261.43,67.72 259.59,67.72 258.74,68.56 258.74,71.38 v5(258.44,71.69)
RUNPWROK: length 269.6
  TOP w0.086: QE2.3 251.25,69.92 251.37,70.04 251.92,70.04 RE67.1 252.74,69.58 253.31,70.14 v1(253.31,70.35) 253.31,70.65 252.82,71.13 252.37,71.13 v2(252.37,71.13) ; UE1.G3 v2(260.62,59.44) ; UC8.13 82.33,86.47 82.54,86.27 v3(82.72,86.27) ; v3(81.27,87.59) 81.27,87.89 81.59,88.22 UC8.10
  GND1 w0.086: v4(84.95,87.23) 84.95,87.55 v3(84.78,87.72) ; v3(82.72,86.27) 82.72,86.29 v4(83.17,86.75) ; v4(84.35,87.23) 84.35,86.78 v3(83.81,86.24) ; v4(81.68,86.73) 81.68,86.73 81.3,87.12 81.3,87.56 v3(81.27,87.59)
  IN2 w0.061: v2(260.62,59.44) 260.23,59.44 257.14,62.53 257.14,64.61 256.77,64.98 256.77,66.59 255.08,68.28 253.2,68.28 252.39,69.1 252.39,71.1 v2(252.37,71.13) ; v4(217.56,50.41) 217.56,50.28 217.5,50.22 217.46,50.22 217.19,49.94 214.99,49.94 213.17,48.13 211.41,48.13 v4(210.74,47.46)
  IN3 w0.061: v2(252.37,71.13) 251.36,70.12 247.53,70.12 247,70.65 244.18,70.65 243.26,69.73 243.26,67.73 240.5,64.97 237.16,64.97 236.83,65.3 232.81,65.3 232.39,65.72 226.95,65.72 226.69,65.72 224.94,63.97 224.94,60.81 225.3,60.45 225.3,53.77 221.75,50.22 218.03,50.22 217.84,50.41 v4(217.56,50.41) ; v4(210.74,47.46) 210.74,47.43 209.6,46.3 201.94,46.3 201.86,46.3 201.86,46.3 201.69,46.3 200.81,47.18 192.66,47.18 190.7,49.14 188.8,49.14 187.17,50.76 185.66,50.76 180.36,56.06 180.36,58.17 178.03,60.5 178.03,64.26 177.12,65.18 177.12,79.03 177.26,79.17 177.26,79.87 176.31,80.81 176.31,84.81 175.11,86.01 175.11,86.02 172.38,88.75 163.94,88.75 163.06,89.64 156.44,89.64 156.36,89.55 148.27,89.55 143.74,94.08 138.53,94.08 137.72,93.27 137.72,90.65 136.4,89.33 133.14,89.33 130.11,92.35 130.11,93.05 129.42,93.75 129.04,93.75 124.86,93.75 122.5,91.39 115.76,91.39 115.46,91.09 108.76,91.09 108.16,91.7 106.83,91.7 105.64,90.5 104.47,90.5 102.72,88.75 87.79,88.75 86.54,90 83.89,90 v4(83.38,89.49)
  IN4 w0.051: v4(83.38,89.49) 84.12,88.76 85.64,88.76 86.76,87.64 86.76,87.28 86.25,86.78 85.11,86.78 84.95,86.93 v4(84.95,87.23) 84.93,87.23 84.86,87.16 84.42,87.16 v4(84.35,87.23) 83.86,86.75 v4(83.17,86.75) 82.77,86.34 82.07,86.34 v4(81.68,86.73)
S1_OVP: length 57.4
  TOP w0.086: v1(47.95,41.18) 48.34,41.58 PR1296.2 47.92,42.55 47.92,43.01 v2(47.19,43.75) ; PQ1224.6 v2(41.67,84.82)
  IN3 w0.061: v4(50.49,79.1) 50.46,79.08 50.46,78.16 48.58,76.28 46.95,76.28 44.93,74.26 44.93,61.85 44.33,61.25 44.33,48.62 44.44,48.51 44.44,44.92 45.61,43.75 v2(47.19,43.75)
  GND5 w0.086: v4(50.49,79.1) 50.3,79.29 v5(50.3,79.8)
  BOTTOM w0.086: v5(50.3,79.8) 48.91,81.19 47.2,81.19 46.92,81.46 PR1279.2 45.69,81.46 44.6,82.55 44.6,83.77 43.55,84.82 v2(41.67,84.82)
S3_OVP: length 74.8
  TOP w0.086: v3(47.41,32.48) 47.44,32.51 47.44,34.04 47.01,34.48 47.01,35.9 48.02,36.91 48.02,37.43 47.49,37.96 v1(47.49,38.55) 47.49,39.21 PR1282.2 45.73,39.88 v2(45.33,39.48)
  GND1 w0.117: v3(47.41,32.48) 47.39,32.46 v3(46.56,32.46)
  IN3 w0.061: v2(45.33,39.48) 44.25,40.55 44.25,48.43 44.14,48.54 44.14,61.33 44.74,61.93 44.74,74.34 46.99,76.59 48.56,76.59 49.85,77.89 49.85,79.03 50.35,79.52 v4(50.89,79.52)
  IN4 w0.051: v4(46.9,85.28) 47.2,84.98 47.2,84.14 50.88,80.45 50.88,79.54 v4(50.89,79.52)
  GND5 w0.086: v4(46.9,85.28) 46.63,85.28 v5(46.32,85.59)
  BOTTOM w0.086: PR1295.2 43.92,91.3 43.67,91.04 43.67,90.31 42.97,89.61 42.97,88.91 43.6,88.27 44.65,88.27 46.32,86.6 v5(46.32,85.59)
S5_1.2V: length 6
  TOP w0.254: v2(86.14,45.51) 86.14,45.56 86.76,46.19 PC221.1 ; PR209.1 PC221.1 ; PC221.1 PR208.2
  BOTTOM w0.086: v2(86.14,45.51) 86.33,45.51 86.54,45.73 87.3,45.73 v1(87.36,45.68)
  BOTTOM w0.254: PU200.1 85.88,44.92 86.14,45.18 v2(86.14,45.51)
SA_LGATE: length 6.6
  TOP w0.086: v2(85.45,49.35) v1(84.97,49.82)
  IN2 w0.762: 87.75,54.9 85.07,52.22 85.07,50.03
  vias: v2(86.03,49.35) v4(87.93,55.88) v4(88.51,55.88) v5(88.26,55.39) v5(88.28,55.01)
SA_SNUB: length 1.7
  TOP w0.086: PR627.2 93.01,53.54 v1(93.44,53.11)
SA_SW: length 0.7
  TOP w0.086: v2(86.72,51.47) 86.71,51.46 v6(86.03,51.46)
  vias: v2(87.3,51.47) v2(89.55,53.12) v2(90.14,53.12)
SA_UGATE:
  vias: v1(89.12,51.88)
SAR_DPR#: length 30.6
  TOP w0.086: v2(243.98,68.87) 241.6,71.26 v1(241.6,72.18) Q1.1 ; UE1.M4 261.79,55.79 v2(261.41,55.41)
  BOTTOM w0.086: v2(261.41,55.41) 259.55,55.41 258.14,56.82 258.14,57.92 253.9,62.15 251.75,62.15 245.52,68.39 244.46,68.39 v2(243.98,68.87)
SAR_I2C0_SCL: length 18.7
  TOP w0.086: QZ10.3 229.5,53.02 230.34,52.18 230.81,52.18 v2(231.39,51.6) 231.78,51.6 CZ166.1 232.66,52.49 233.49,52.49 233.72,52.26 233.72,48.73 v1(231.98,46.98) 231.79,46.8 229.74,46.8 RZ351.1 229.5,47.55 QZ13.4
  BOTTOM w0.086: v2(231.39,51.6) 231.84,51.6 232.84,50.6 JSAR1.3
SAR_I2C0_SDA: length 8.2
  TOP w0.086: QZ13.1 QZ10.6 231.03,51.37 231.23,51.17 v2(231.23,50.82) 231.52,50.82 231.74,51.05 CZ165.1 232.17,50.6 232.12,50.55 RZ350.1 232.12,49.54 231.95,49.36 v1(231.95,49.17)
  BOTTOM w0.086: JSAR1.2 232.88,49.8 231.85,50.82 v2(231.23,50.82)
SATAGP0: length 21.3
  TOP w0.086: RPC4.3 171.11,87.08 v2(170.98,86.95)
  BOTTOM w0.076: UC1.H2 155.52,77.35 155.73,77.43 155.86,77.43 155.87,77.42 156.09,77.36 156.53,77.36 156.63,77.4 157.22,77.99
  BOTTOM w0.086: 157.22,77.99 160.45,77.99 164.8,82.34 164.8,82.48 v1(165.35,83.04) 165.83,83.51 168.28,83.51 168.93,84.16 168.93,84.51 170.98,86.57 v2(170.98,86.95)
SATALED#: length 461.8
  TOP w0.086: v2(228.26,84.16) 228.64,84.54 RN101.2 ; v3(24.36,23.91) 24.36,20.56 25.09,19.83 v6(25.09,18.63) 25.09,17.15 26.97,15.27 RN100.2 ; v2(171.62,86.95) 171.61,86.97 RPC4.4 ; QZ2.4 254.43,89.06 253.57,89.91 250.22,89.91 247.97,87.66 246.94,87.66 243.3,84.02 v2(243.3,80.59)
  GND1 w0.086: v3(24.36,23.91) 24.47,23.81 v4(24.47,23.4)
  IN1 w0.051: v2(243.3,80.59) 243.3,72.86 243.98,72.17 v4(243.98,69.45)
  IN2 w0.061: v4(24.47,23.4) 24.47,24.04 23.12,25.38 20.64,25.38 19.35,26.66 19.35,30.27 16.49,33.14 16.49,45.68 13.8,48.37 13.8,56.17 13.18,56.8 13.18,60.51 11.33,62.36 11.33,65.62 12.17,66.46 12.17,67.88 14.43,70.14 14.43,73.05 17.45,76.08 17.45,78.12 20.23,80.91 20.67,80.91 26.22,86.46 33.14,86.46 33.65,86.96 35.11,86.96 36.09,87.94 38.35,87.94 v4(38.4,87.99)
  IN3 w0.061: v4(38.4,87.99) 38.4,89.66 39.94,91.2 44.14,91.2 48.69,86.65 50.19,86.65 51.91,84.94 56.4,84.94 57.52,86.06 57.52,86.49 59.54,88.51 65.2,88.51 66.28,89.58 79.5,89.58 80.8,88.28 86.84,88.28 87.37,87.75 103.14,87.75 104.24,88.85 105.32,88.85 105.96,89.49 125.16,89.49 125.97,88.68 129.89,88.68 130.88,87.69 132.72,87.69 132.73,87.7 132.81,87.7 133.35,88.25 136.74,88.25 137.57,89.09 144.01,89.09 144.31,89.39 146.7,89.39 147.54,88.55 156.78,88.55 156.86,88.63 162.64,88.63 163.61,87.66 171.04,87.66 171.62,87.08 v2(171.62,86.95) 172.75,86.95 174.11,85.6 174.11,85.59 174.59,85.11 174.59,78.32 175.79,77.12 175.79,68.01 176.3,67.5 176.3,64.66 177.21,63.75 177.21,60.16 179.54,57.83 179.54,55.72 185.32,49.95 186.83,49.95 188.46,48.32 190.36,48.32 192.32,46.36 200.47,46.36 201.35,45.48 201.6,45.48 210.79,45.48 214.67,49.36 222.05,49.36 226.12,53.43 226.12,60.93 226,61.04 226,61.53 226.37,61.9 226.85,61.9 228.28,63.32 230.56,63.32 231.16,63.92 240.97,63.92 241.29,64.24 242.15,64.24 242.56,64.65 242.56,65.51 243.72,66.67 243.84,66.67 244.52,67.35 244.52,68.92 v4(243.98,69.45) ; v2(228.26,84.16) 228.31,84.16 228.62,84.46 229.3,84.46 230.41,83.36 230.41,80.4 230.02,80.02 230.02,67.71 230.7,67.03 232.94,67.03 233.3,66.67 235.21,66.67 235.84,67.3 239.83,67.3 241.95,69.42 241.95,70.28 243.21,71.54 243.21,80.5 v2(243.3,80.59)
  BOTTOM w0.076: 157.56,77.05 157.03,77.05 156.84,77.11 155.85,77.11 UC1.H1
  BOTTOM w0.086: 157.56,77.05 160.96,77.05 162.93,79.03 162.93,80.13 166.07,83.27 168.38,83.27 169.22,84.1 169.22,84.46 171.62,86.86 v2(171.62,86.95)
